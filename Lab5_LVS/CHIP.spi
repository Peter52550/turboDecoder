$ Spice netlist generated by v2lvs
$ v2021.1_33.19    Mon Mar 1 16:09:52 PST 2021
.INCLUDE "core.spi"
.INCLUDE "umc18_io_lvs.spi"
*.BUSDELIMITER [

.SUBCKT Siso_DW01_add_6 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN183_forward_sum_0__5__0
+ FE_OFN226_backward_metrics_6__3__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN226_backward_metrics_6__3__0
XU2 XOR2HS $PINS O=SUM[0] I1=FE_OFN183_forward_sum_0__5__0 I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_7 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN176_forward_sum_0__1__0
+ FE_OFN223_backward_metrics_6__1__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=FE_OFN176_forward_sum_0__1__0
+ I2=FE_OFN223_backward_metrics_6__1__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_8 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN227_backward_metrics_6__3__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN227_backward_metrics_6__3__0
.ENDS

.SUBCKT Siso_DW01_add_9 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN224_backward_metrics_6__1__0
+ FE_OFN245_forward_sum_0__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=FE_OFN245_forward_sum_0__2__0
+ I2=FE_OFN224_backward_metrics_6__1__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_10 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN225_backward_metrics_6__2__0
+ FE_OFN247_backward_metrics_6__2__0
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN225_backward_metrics_6__2__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN247_backward_metrics_6__2__0
.ENDS

.SUBCKT Siso_DW01_add_11 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN177_forward_sum_0__1__0
+ FE_OFN217_backward_metrics_6__0__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=FE_OFN177_forward_sum_0__1__0 I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN217_backward_metrics_6__0__0
.ENDS

.SUBCKT Siso_DW01_add_28 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN236_backward_metrics_5__3__0
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN236_backward_metrics_5__3__0
.ENDS

.SUBCKT Siso_DW01_add_29 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN155_branch_metrics_1__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=FE_OFN155_branch_metrics_1__2__0 I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=FE_OFN155_branch_metrics_1__2__0 I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_30 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_31 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_32 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_33 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_34 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN211_backward_metrics_5__2__0
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN211_backward_metrics_5__2__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_35 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_52 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN239_backward_metrics_4__3__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN239_backward_metrics_4__3__0
.ENDS

.SUBCKT Siso_DW01_add_53 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_54 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_55 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_56 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN205_backward_metrics_4__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN205_backward_metrics_4__2__0
.ENDS

.SUBCKT Siso_DW01_add_57 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_58 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN204_backward_metrics_4__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN204_backward_metrics_4__2__0
.ENDS

.SUBCKT Siso_DW01_add_59 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN240_backward_metrics_4__0__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN240_backward_metrics_4__0__0
.ENDS

.SUBCKT Siso_DW01_add_76 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_77 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN195_backward_metrics_3__1__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_78 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN198_backward_metrics_3__3__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN198_backward_metrics_3__3__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_79 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN194_backward_metrics_3__1__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN194_backward_metrics_3__1__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN194_backward_metrics_3__1__0
.ENDS

.SUBCKT Siso_DW01_add_80 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN196_backward_metrics_3__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1S $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN196_backward_metrics_3__2__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN196_backward_metrics_3__2__0
.ENDS

.SUBCKT Siso_DW01_add_81 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN192_backward_metrics_3__0__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN192_backward_metrics_3__0__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN192_backward_metrics_3__0__0
.ENDS

.SUBCKT Siso_DW01_add_82 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN197_backward_metrics_3__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1 $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN197_backward_metrics_3__2__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN197_backward_metrics_3__2__0
.ENDS

.SUBCKT Siso_DW01_add_83 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN193_backward_metrics_3__0__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN193_backward_metrics_3__0__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN193_backward_metrics_3__0__0
.ENDS

.SUBCKT Siso_DW01_add_100 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_101 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_102 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_103 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_104 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_105 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1 $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_106 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_107 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_124 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_125 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN243_backward_metrics_1__1__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN243_backward_metrics_1__1__0
.ENDS

.SUBCKT Siso_DW01_add_126 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1S $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_127 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN230_backward_metrics_1__1__0
+ FE_OFN244_backward_metrics_1__1__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=FE_OFN230_backward_metrics_1__1__0
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN244_backward_metrics_1__1__0
.ENDS

.SUBCKT Siso_DW01_add_128 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN189_backward_metrics_1__2__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN189_backward_metrics_1__2__0
.ENDS

.SUBCKT Siso_DW01_add_129 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN187_backward_metrics_1__0__0
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=FE_OFN187_backward_metrics_1__0__0
.ENDS

.SUBCKT Siso_DW01_add_130 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_4 FA1S $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_6 FA1S $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_add_131 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU1_1 FA1S $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n1
XU1_8 FA1S $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_10 FA1S $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_7 FA1 $PINS S=SUM[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU1_3 FA1S $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_5 FA1S $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_2 FA1S $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_11 XOR3 $PINS O=SUM[11] I1=A[11] I2=B[11] I3=carry[11]
XU1 AN2 $PINS O=n1 I1=B[0] I2=A[0]
XU2 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Siso_DW01_sub_6 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
XFE_OCPC3202_n38 BUF1S $PINS O=FE_OCPN3202_n38 I=n38
XFE_OCPC3201_n41 BUF1S $PINS O=FE_OCPN3201_n41 I=n41
XFE_RC_96_0 AOI12HP $PINS O=n25 A1=n27 B1=n30 B2=n122
XFE_RC_95_0 OAI12HT $PINS O=n22 A1=n24 B1=n25 B2=n23
XFE_RC_84_0 AOI12HT $PINS O=n33 A1=n35 B1=n38 B2=n121
XFE_RC_70_0 AOI12HP $PINS O=n17 A1=n19 B1=n22 B2=n123
XFE_RC_62_0 OAI12HP $PINS O=n30 A1=n32 B1=n33 B2=n31
XFE_RC_61_0 INV1S $PINS O=FE_RN_7_0 I=n16
XFE_RC_60_0 NR2T $PINS O=FE_RN_8_0 I1=n15 I2=n17
XFE_RC_59_0 NR2T $PINS O=n120 I1=FE_RN_7_0 I2=FE_RN_8_0
XFE_RC_52_0 INV2CK $PINS O=FE_RN_4_0 I=n1
XFE_RC_51_0 MXL2H $PINS OB=DIFF[11] S=n120 A=FE_RN_4_0 B=n1
XFE_RC_49_0 OAI12H $PINS O=n43 A1=n45 B1=n44 B2=n48
XFE_RC_45_0 OAI12HP $PINS O=n38 A1=n40 B1=n41 B2=n39
XFE_OFC2759_N2970 INV1S $PINS O=n69 I=B[7]
XFE_OFC2690_N2971 INV1S $PINS O=n68 I=B[8]
XU96 INV1S $PINS O=n19 I=n21
XU97 INV1S $PINS O=n57 I=n23
XU98 XOR2HS $PINS O=DIFF[8] I1=n4 I2=n25
XU99 XOR2HS $PINS O=DIFF[10] I1=n2 I2=n17
XU100 XNR2HS $PINS O=DIFF[9] I1=n3 I2=n22
XU102 ND2 $PINS O=n29 I1=n69 I2=A[7]
XU103 NR2P $PINS O=n53 I1=A[0] I2=n76
XU106 XOR2HS $PINS O=DIFF[3] I1=n9 I2=n119
XU107 OA12S $PINS O=n119 A1=n48 B1=n49 B2=n47
XU108 ND2S $PINS O=n5 I1=n122 I2=n29
XU109 ND2S $PINS O=n7 I1=n121 I2=n37
XU112 ND2 $PINS O=n45 I1=n73 I2=A[3]
XU113 ND2S $PINS O=n40 I1=n72 I2=A[4]
XU114 ND2S $PINS O=n37 I1=n71 I2=A[5]
XU115 ND2S $PINS O=n16 I1=n66 I2=A[10]
XU116 ND2S $PINS O=n32 I1=n70 I2=A[6]
XU117 ND2S $PINS O=n24 I1=n68 I2=A[8]
XU118 OAI12H $PINS O=n50 A1=n52 B1=n51 B2=n53
XU119 ND2S $PINS O=n52 I1=n75 I2=A[1]
XU120 INV2 $PINS O=n35 I=n37
XU121 INV2CK $PINS O=n27 I=n29
XU122 ND2 $PINS O=n3 I1=n123 I2=n21
XU123 XNR2HS $PINS O=DIFF[7] I1=n5 I2=n30
XU124 ND2 $PINS O=n2 I1=n55 I2=n16
XU125 INV1S $PINS O=n55 I=n15
XU126 ND2 $PINS O=n4 I1=n57 I2=n24
XU127 XOR2HS $PINS O=DIFF[6] I1=n6 I2=n33
XU128 ND2 $PINS O=n6 I1=n59 I2=n32
XU129 INV1S $PINS O=n59 I=n31
XU130 XOR2HS $PINS O=DIFF[2] I1=n10 I2=n49
XU131 ND2 $PINS O=n10 I1=n63 I2=n48
XU132 INV1S $PINS O=n63 I=n47
XU133 XNR2HS $PINS O=DIFF[5] I1=n7 I2=FE_OCPN3202_n38
XU134 XOR2HS $PINS O=DIFF[4] I1=n8 I2=FE_OCPN3201_n41
XU135 ND2 $PINS O=n8 I1=n61 I2=n40
XU136 INV1S $PINS O=n61 I=n39
XU137 ND2 $PINS O=n9 I1=n62 I2=n45
XU138 INV1S $PINS O=n62 I=n44
XU139 ND2 $PINS O=n48 I1=n74 I2=A[2]
XU140 NR2 $PINS O=n47 I1=A[2] I2=n74
XU141 NR2P $PINS O=n44 I1=A[3] I2=n73
XU142 AOI12H $PINS O=n41 A1=n43 B1=n42 B2=n50
XU143 NR2 $PINS O=n42 I1=n44 I2=n47
XU144 ND2P $PINS O=n1 I1=n124 I2=n13
XU145 ND2 $PINS O=n13 I1=n65 I2=A[11]
XU146 OR2 $PINS O=n121 I1=A[5] I2=n71
XU147 OR2 $PINS O=n122 I1=A[7] I2=n69
XU148 NR2 $PINS O=n39 I1=A[4] I2=n72
XU149 NR2P $PINS O=n31 I1=A[6] I2=n70
XU150 INV1S $PINS O=n49 I=n50
XU151 OR2 $PINS O=n123 I1=A[9] I2=n67
XU152 NR2 $PINS O=n15 I1=A[10] I2=n66
XU153 NR2P $PINS O=n23 I1=A[8] I2=n68
XU154 ND2 $PINS O=n21 I1=n67 I2=A[9]
XU155 OR2 $PINS O=n124 I1=A[11] I2=n65
XU156 INV1S $PINS O=n72 I=B[4]
XU157 INV1S $PINS O=n71 I=B[5]
XU158 INV1S $PINS O=n70 I=B[6]
XU159 INV1CK $PINS O=n73 I=B[3]
XU160 INV1CK $PINS O=n74 I=B[2]
XU161 NR2 $PINS O=n51 I1=A[1] I2=n75
XU162 XOR2HS $PINS O=DIFF[1] I1=n53 I2=n11
XU163 ND2 $PINS O=n11 I1=n64 I2=n52
XU164 INV1S $PINS O=n64 I=n51
XU167 INV1S $PINS O=n67 I=B[9]
XU168 INV1S $PINS O=n65 I=B[11]
XU169 INV1S $PINS O=n66 I=B[10]
XU170 INV1S $PINS O=n75 I=B[1]
XU171 XNR2HS $PINS O=DIFF[0] I1=A[0] I2=n76
XU172 INV2CK $PINS O=n76 I=B[0]
.ENDS

.SUBCKT Siso_DW01_add_240 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU84 OR2 $PINS O=n111 I1=A[0] I2=B[0]
XU85 XNR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU86 AO12S $PINS O=n113 A1=n17 B1=n20 B2=n118
XU87 AN2 $PINS O=SUM[0] I1=n111 I2=n56
XU88 ND2S $PINS O=n10 I1=n114 I2=n51
XU89 ND2S $PINS O=n8 I1=n115 I2=n43
XU90 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU91 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU92 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU93 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU95 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU96 ND2 $PINS O=n3 I1=n59 I2=n22
XU97 INV1S $PINS O=n59 I=n21
XU98 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU99 ND2 $PINS O=n9 I1=n65 I2=n46
XU100 INV1S $PINS O=n65 I=n45
XU101 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU102 ND2 $PINS O=n11 I1=n67 I2=n54
XU103 INV1S $PINS O=n67 I=n53
XU104 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU105 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU106 OAI12HP $PINS O=n36 A1=n38 B1=n39 B2=n37
XU107 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU108 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU109 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n114
XU110 INV1S $PINS O=n49 I=n51
XU111 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n115
XU112 INV1S $PINS O=n41 I=n43
XU113 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n116
XU114 INV1S $PINS O=n33 I=n35
XU115 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n117
XU116 INV1S $PINS O=n25 I=n27
XU117 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU118 ND2 $PINS O=n2 I1=n118 I2=n19
XU119 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU120 ND2 $PINS O=n5 I1=n61 I2=n30
XU121 INV1S $PINS O=n61 I=n29
XU122 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU123 ND2 $PINS O=n7 I1=n63 I2=n38
XU124 INV1S $PINS O=n63 I=n37
XU125 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU126 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU127 ND2 $PINS O=n6 I1=n116 I2=n35
XU128 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU129 ND2 $PINS O=n4 I1=n117 I2=n27
XU130 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU131 INV1S $PINS O=n17 I=n19
XU132 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU133 OR2 $PINS O=n114 I1=A[2] I2=B[2]
XU134 ND2 $PINS O=n1 I1=n119 I2=n14
XU135 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU136 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU137 OR2 $PINS O=n115 I1=A[4] I2=B[4]
XU138 OR2 $PINS O=n116 I1=A[6] I2=B[6]
XU139 OR2 $PINS O=n117 I1=A[8] I2=B[8]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU142 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU143 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU144 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU146 OR2 $PINS O=n118 I1=A[10] I2=B[10]
XU147 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU148 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_241 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO _backward_sum_0_0_10
XU84 OR2 $PINS O=n111 I1=A[0] I2=B[0]
XU85 ND2S $PINS O=n10 I1=n114 I2=n51
XU86 ND2S $PINS O=n8 I1=n115 I2=n43
XU87 AN2 $PINS O=SUM[0] I1=n111 I2=n56
XU88 XNR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU89 AO12S $PINS O=n113 A1=n17 B1=n20 B2=n118
XU90 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU91 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU92 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU93 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU94 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU95 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU96 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU97 ND2 $PINS O=n9 I1=n65 I2=n46
XU98 INV1S $PINS O=n65 I=n45
XU99 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU100 ND2 $PINS O=n11 I1=n67 I2=n54
XU101 INV1S $PINS O=n67 I=n53
XU102 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU103 ND2 $PINS O=n3 I1=n59 I2=n22
XU104 INV1S $PINS O=n59 I=n21
XU105 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU106 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU107 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU108 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XU109 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU110 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n114
XU111 INV1S $PINS O=n49 I=n51
XU112 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n115
XU113 INV1S $PINS O=n41 I=n43
XU114 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n116
XU115 INV1S $PINS O=n33 I=n35
XU116 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n117
XU117 INV1S $PINS O=n25 I=n27
XU118 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU119 ND2 $PINS O=n2 I1=n118 I2=n19
XU120 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU121 ND2 $PINS O=n6 I1=n116 I2=n35
XU122 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU123 ND2 $PINS O=n7 I1=n63 I2=n38
XU124 INV1S $PINS O=n63 I=n37
XU125 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n61 I2=n30
XU127 INV1S $PINS O=n61 I=n29
XU128 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU129 ND2 $PINS O=n4 I1=n117 I2=n27
XU130 INV1S $PINS O=n17 I=n19
XU131 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU132 OR2 $PINS O=n114 I1=A[2] I2=B[2]
XU133 ND2 $PINS O=n1 I1=n119 I2=n14
XU134 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU135 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU136 OR2 $PINS O=n115 I1=A[4] I2=B[4]
XU137 OR2 $PINS O=n116 I1=A[6] I2=B[6]
XU138 OR2 $PINS O=n117 I1=A[8] I2=B[8]
XU139 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU142 ND2 $PINS O=n38 I1=B[5] I2=A[5]
XU143 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU144 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU146 OR2 $PINS O=n118 I1=A[10] I2=_backward_sum_0_0_10
XU147 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU148 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU149 ND2 $PINS O=n19 I1=_backward_sum_0_0_10 I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_242 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU84 OR2 $PINS O=n111 I1=A[0] I2=B[0]
XU85 AO12S $PINS O=n113 A1=n17 B1=n20 B2=n118
XU86 AN2 $PINS O=SUM[0] I1=n111 I2=n56
XU87 XNR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU88 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU89 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU90 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU91 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU92 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU93 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU94 OR2S $PINS O=n114 I1=A[2] I2=B[2]
XU95 OR2S $PINS O=n115 I1=A[4] I2=B[4]
XU96 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU97 ND2 $PINS O=n9 I1=n65 I2=n46
XU98 INV1S $PINS O=n65 I=n45
XU99 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU100 ND2 $PINS O=n10 I1=n114 I2=n51
XU101 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU102 ND2 $PINS O=n11 I1=n67 I2=n54
XU103 INV1S $PINS O=n67 I=n53
XU104 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU105 ND2 $PINS O=n3 I1=n59 I2=n22
XU106 INV1S $PINS O=n59 I=n21
XU107 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU108 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU109 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU110 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU111 OAI12HP $PINS O=n20 A1=n22 B1=n23 B2=n21
XU112 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n114
XU113 INV1S $PINS O=n49 I=n51
XU114 AOI12HS $PINS O=n39 A1=n41 B1=n44 B2=n115
XU115 INV1S $PINS O=n41 I=n43
XU116 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n116
XU117 INV1S $PINS O=n33 I=n35
XU118 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n117
XU119 INV1S $PINS O=n25 I=n27
XU120 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU121 ND2 $PINS O=n2 I1=n118 I2=n19
XU122 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU123 ND2 $PINS O=n5 I1=n61 I2=n30
XU124 INV1S $PINS O=n61 I=n29
XU125 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n63 I2=n38
XU127 INV1S $PINS O=n63 I=n37
XU128 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU129 ND2 $PINS O=n6 I1=n116 I2=n35
XU130 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU131 ND2 $PINS O=n4 I1=n117 I2=n27
XU132 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU133 ND2 $PINS O=n8 I1=n115 I2=n43
XU134 INV1S $PINS O=n17 I=n19
XU135 ND2 $PINS O=n1 I1=n119 I2=n14
XU136 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU137 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU138 OR2 $PINS O=n116 I1=A[6] I2=B[6]
XU139 OR2 $PINS O=n117 I1=A[8] I2=B[8]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU142 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU143 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU144 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU146 OR2 $PINS O=n118 I1=A[10] I2=B[10]
XU147 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU148 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_243 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU84 OR2 $PINS O=n111 I1=A[0] I2=B[0]
XU85 AN2 $PINS O=SUM[0] I1=n111 I2=n56
XU86 XNR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU87 AO12S $PINS O=n113 A1=n17 B1=n20 B2=n118
XU88 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU89 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU90 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU91 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU92 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU93 OR2S $PINS O=n114 I1=A[2] I2=B[2]
XU94 OR2S $PINS O=n115 I1=A[4] I2=B[4]
XU95 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU96 ND2 $PINS O=n3 I1=n59 I2=n22
XU97 INV1S $PINS O=n59 I=n21
XU98 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU99 ND2 $PINS O=n10 I1=n114 I2=n51
XU100 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU101 ND2 $PINS O=n8 I1=n115 I2=n43
XU102 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU103 ND2 $PINS O=n9 I1=n65 I2=n46
XU104 INV1S $PINS O=n65 I=n45
XU105 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU106 ND2 $PINS O=n11 I1=n67 I2=n54
XU107 INV1S $PINS O=n67 I=n53
XU108 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU109 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU110 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU111 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU112 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU113 AOI12HS $PINS O=n47 A1=n49 B1=n52 B2=n114
XU114 INV1S $PINS O=n49 I=n51
XU115 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n115
XU116 INV1S $PINS O=n41 I=n43
XU117 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n116
XU118 INV1S $PINS O=n33 I=n35
XU119 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n117
XU120 INV1S $PINS O=n25 I=n27
XU121 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU122 ND2 $PINS O=n2 I1=n118 I2=n19
XU123 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU124 ND2 $PINS O=n4 I1=n117 I2=n27
XU125 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU126 ND2 $PINS O=n6 I1=n116 I2=n35
XU127 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU128 ND2 $PINS O=n7 I1=n63 I2=n38
XU129 INV1S $PINS O=n63 I=n37
XU130 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU131 ND2 $PINS O=n5 I1=n61 I2=n30
XU132 INV1S $PINS O=n61 I=n29
XU133 INV1S $PINS O=n17 I=n19
XU134 ND2 $PINS O=n1 I1=n119 I2=n14
XU135 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU136 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU137 OR2 $PINS O=n116 I1=A[6] I2=B[6]
XU138 OR2 $PINS O=n117 I1=A[8] I2=B[8]
XU139 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU142 ND2 $PINS O=n38 I1=B[5] I2=A[5]
XU143 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU144 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU146 OR2 $PINS O=n118 I1=A[10] I2=B[10]
XU147 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU148 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_244 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO _backward_sum_0_2_10
XU84 OR2 $PINS O=n111 I1=A[0] I2=B[0]
XU85 AN2 $PINS O=SUM[0] I1=n111 I2=n56
XU86 XNR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU87 AO12S $PINS O=n113 A1=n17 B1=n20 B2=n118
XU88 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU89 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU90 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU91 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU92 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU93 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU94 OR2S $PINS O=n114 I1=A[2] I2=B[2]
XU95 OR2S $PINS O=n115 I1=A[4] I2=B[4]
XU96 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU97 ND2 $PINS O=n9 I1=n65 I2=n46
XU98 INV1S $PINS O=n65 I=n45
XU99 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU100 ND2 $PINS O=n10 I1=n114 I2=n51
XU101 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU102 ND2 $PINS O=n11 I1=n67 I2=n54
XU103 INV1S $PINS O=n67 I=n53
XU104 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU105 ND2 $PINS O=n3 I1=n59 I2=n22
XU106 INV1S $PINS O=n59 I=n21
XU107 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU108 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU109 OAI12HP $PINS O=n36 A1=n38 B1=n39 B2=n37
XU110 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU111 OAI12HP $PINS O=n20 A1=n22 B1=n23 B2=n21
XU112 AOI12HS $PINS O=n47 A1=n49 B1=n52 B2=n114
XU113 INV1S $PINS O=n49 I=n51
XU114 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n115
XU115 INV1S $PINS O=n41 I=n43
XU116 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n116
XU117 INV1S $PINS O=n33 I=n35
XU118 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n117
XU119 INV1S $PINS O=n25 I=n27
XU120 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU121 ND2 $PINS O=n2 I1=n118 I2=n19
XU122 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU123 ND2 $PINS O=n5 I1=n61 I2=n30
XU124 INV1S $PINS O=n61 I=n29
XU125 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n63 I2=n38
XU127 INV1S $PINS O=n63 I=n37
XU128 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU129 ND2 $PINS O=n6 I1=n116 I2=n35
XU130 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU131 ND2 $PINS O=n4 I1=n117 I2=n27
XU132 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU133 ND2 $PINS O=n8 I1=n115 I2=n43
XU134 INV1S $PINS O=n17 I=n19
XU135 ND2 $PINS O=n1 I1=n119 I2=n14
XU136 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU137 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU138 OR2 $PINS O=n116 I1=A[6] I2=B[6]
XU139 OR2 $PINS O=n117 I1=A[8] I2=B[8]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU142 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU143 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU144 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU146 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n19 I1=_backward_sum_0_2_10 I2=A[10]
XU149 OR2 $PINS O=n118 I1=A[10] I2=_backward_sum_0_2_10
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_245 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU84 OR2 $PINS O=n111 I1=A[0] I2=B[0]
XU85 AN2 $PINS O=SUM[0] I1=n111 I2=n56
XU86 XNR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU87 AO12S $PINS O=n113 A1=n17 B1=n20 B2=n118
XU88 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU89 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU90 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU91 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU92 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU93 OR2 $PINS O=n114 I1=A[2] I2=B[2]
XU94 OR2S $PINS O=n115 I1=A[4] I2=B[4]
XU95 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU96 ND2 $PINS O=n10 I1=n114 I2=n51
XU97 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU98 ND2 $PINS O=n8 I1=n115 I2=n43
XU99 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU100 ND2 $PINS O=n9 I1=n65 I2=n46
XU101 INV1S $PINS O=n65 I=n45
XU102 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU103 ND2 $PINS O=n11 I1=n67 I2=n54
XU104 INV1S $PINS O=n67 I=n53
XU105 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU106 ND2 $PINS O=n3 I1=n59 I2=n22
XU107 INV1S $PINS O=n59 I=n21
XU108 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU109 OAI12HS $PINS O=n44 A1=n46 B1=n47 B2=n45
XU110 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU111 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XU112 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU113 AOI12HS $PINS O=n47 A1=n49 B1=n52 B2=n114
XU114 INV1S $PINS O=n49 I=n51
XU115 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n115
XU116 INV1S $PINS O=n41 I=n43
XU117 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n116
XU118 INV1S $PINS O=n33 I=n35
XU119 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n117
XU120 INV1S $PINS O=n25 I=n27
XU121 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU122 ND2 $PINS O=n2 I1=n118 I2=n19
XU123 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU124 ND2 $PINS O=n6 I1=n116 I2=n35
XU125 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n63 I2=n38
XU127 INV1S $PINS O=n63 I=n37
XU128 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU129 ND2 $PINS O=n5 I1=n61 I2=n30
XU130 INV1S $PINS O=n61 I=n29
XU131 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU132 ND2 $PINS O=n4 I1=n117 I2=n27
XU133 INV1S $PINS O=n17 I=n19
XU134 ND2 $PINS O=n1 I1=n119 I2=n14
XU135 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU136 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU137 OR2 $PINS O=n116 I1=A[6] I2=B[6]
XU138 OR2 $PINS O=n117 I1=A[8] I2=B[8]
XU139 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU142 ND2 $PINS O=n38 I1=B[5] I2=A[5]
XU143 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU144 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU146 OR2 $PINS O=n118 I1=A[10] I2=B[10]
XU147 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU148 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_246 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2809_n57 INV1S $PINS O=n55 I=n57
XU85 OR2 $PINS O=n112 I1=B[0] I2=A[0]
XU86 ND2S $PINS O=n11 I1=n114 I2=n54
XU87 ND2S $PINS O=n9 I1=n115 I2=n46
XU88 AN2 $PINS O=SUM[0] I1=n112 I2=n57
XU89 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU90 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU91 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU93 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU94 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU95 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU96 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU97 AOI12HS $PINS O=n50 A1=n52 B1=n114 B2=n55
XU98 INV1S $PINS O=n52 I=n54
XU99 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n115
XU100 INV1S $PINS O=n44 I=n46
XU101 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n116
XU102 INV1S $PINS O=n36 I=n38
XU103 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n117
XU104 INV1S $PINS O=n28 I=n30
XU105 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n118
XU106 INV1S $PINS O=n20 I=n22
XU107 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU108 ND2 $PINS O=n3 I1=n118 I2=n22
XU109 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU110 ND2 $PINS O=n2 I1=n59 I2=n17
XU111 INV1S $PINS O=n59 I=n16
XU112 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU113 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU114 ND2 $PINS O=n7 I1=n116 I2=n38
XU115 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU116 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU117 ND2 $PINS O=n5 I1=n117 I2=n30
XU118 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU119 ND2 $PINS O=n10 I1=n67 I2=n49
XU120 INV1S $PINS O=n67 I=n48
XU121 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU122 ND2 $PINS O=n6 I1=n63 I2=n33
XU123 INV1S $PINS O=n63 I=n32
XU124 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU125 ND2 $PINS O=n8 I1=n65 I2=n41
XU126 INV1S $PINS O=n65 I=n40
XU127 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU128 ND2 $PINS O=n4 I1=n61 I2=n25
XU129 INV1S $PINS O=n61 I=n24
XU130 OR2 $PINS O=n114 I1=B[1] I2=A[1]
XU131 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU132 ND2 $PINS O=n1 I1=n119 I2=n14
XU133 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU134 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU135 ND2 $PINS O=n57 I1=A[0] I2=B[0]
XU136 OR2 $PINS O=n115 I1=B[3] I2=A[3]
XU137 OR2 $PINS O=n116 I1=B[5] I2=A[5]
XU138 OR2 $PINS O=n117 I1=B[7] I2=A[7]
XU139 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU143 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU144 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU145 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU146 OR2 $PINS O=n118 I1=B[9] I2=A[9]
XU147 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU148 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU149 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU150 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=A[9] I2=B[9]
XU152 OR2 $PINS O=n119 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_247 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN178_forward_sum_0__5__9 FE_OFN179_forward_sum_0__5__8
+ FE_OFN180_forward_sum_0__5__7 FE_OFN181_forward_sum_0__5__4
+ FE_OFN182_forward_sum_0__5__3
XU85 OR2 $PINS O=n116 I1=B[1] I2=A[1]
XU86 ND2S $PINS O=n11 I1=n116 I2=n54
XU87 ND2S $PINS O=n9 I1=n114 I2=n46
XU88 AN2 $PINS O=SUM[0] I1=n117 I2=n57
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU90 OA12 $PINS O=n113 A1=n17 B1=n18 B2=n16
XU91 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU92 ND2S $PINS O=n46 I1=FE_OFN182_forward_sum_0__5__3 I2=B[3]
XU93 OR2S $PINS O=n117 I1=B[0] I2=A[0]
XU94 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU95 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU96 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU97 ND2 $PINS O=n10 I1=n67 I2=n49
XU98 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU99 ND2 $PINS O=n8 I1=n65 I2=n41
XU100 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU101 ND2 $PINS O=n7 I1=n115 I2=n38
XU102 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU103 ND2 $PINS O=n3 I1=n118 I2=n22
XU104 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU105 ND2 $PINS O=n4 I1=n61 I2=n25
XU106 INV1S $PINS O=n55 I=n57
XU107 OAI12HS $PINS O=n31 A1=n33 B1=n34 B2=n32
XU108 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU109 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU110 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU111 AOI12HS $PINS O=n50 A1=n52 B1=n116 B2=n55
XU112 INV1S $PINS O=n52 I=n54
XU113 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n114
XU114 INV1S $PINS O=n44 I=n46
XU115 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n115
XU116 INV1S $PINS O=n36 I=n38
XU117 AOI12HS $PINS O=n26 A1=n28 B1=n31 B2=n119
XU118 INV1S $PINS O=n28 I=n30
XU119 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n118
XU120 INV1S $PINS O=n20 I=n22
XU121 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU122 ND2 $PINS O=n6 I1=n63 I2=n33
XU123 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU124 ND2 $PINS O=n5 I1=n119 I2=n30
XU125 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU126 ND2 $PINS O=n2 I1=n59 I2=n17
XU127 INV1S $PINS O=n59 I=n16
XU128 INV1S $PINS O=n67 I=n48
XU129 INV1S $PINS O=n65 I=n40
XU130 INV1S $PINS O=n63 I=n32
XU131 INV1S $PINS O=n61 I=n24
XU132 ND2 $PINS O=n57 I1=A[0] I2=B[0]
XU133 ND2 $PINS O=n1 I1=n120 I2=n14
XU134 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU135 OR2 $PINS O=n114 I1=B[3] I2=FE_OFN182_forward_sum_0__5__3
XU136 OR2 $PINS O=n115 I1=B[5] I2=A[5]
XU137 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU138 NR2 $PINS O=n40 I1=B[4] I2=FE_OFN181_forward_sum_0__5__4
XU139 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU140 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU141 ND2 $PINS O=n54 I1=A[1] I2=B[1]
XU142 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU143 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU144 OR2 $PINS O=n118 I1=B[9] I2=FE_OFN178_forward_sum_0__5__9
XU145 OR2 $PINS O=n119 I1=B[7] I2=A[7]
XU146 NR2 $PINS O=n24 I1=B[8] I2=FE_OFN179_forward_sum_0__5__8
XU147 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU148 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU149 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU150 ND2 $PINS O=n30 I1=FE_OFN180_forward_sum_0__5__7 I2=B[7]
XU151 ND2 $PINS O=n22 I1=A[9] I2=B[9]
XU152 OR2 $PINS O=n120 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_248 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU85 OR2 $PINS O=n112 I1=A[0] I2=B[0]
XU86 AN2 $PINS O=SUM[0] I1=n112 I2=n57
XU87 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU88 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU89 ND2S $PINS O=n57 I1=B[0] I2=A[0]
XU90 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU91 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU92 OR2S $PINS O=n115 I1=A[3] I2=B[3]
XU93 OR2S $PINS O=n114 I1=A[1] I2=B[1]
XU94 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU95 ND2 $PINS O=n1 I1=n119 I2=n14
XU96 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU97 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU98 ND2 $PINS O=n2 I1=n59 I2=n17
XU99 INV1S $PINS O=n59 I=n16
XU100 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU101 ND2 $PINS O=n10 I1=n67 I2=n49
XU102 INV1S $PINS O=n67 I=n48
XU103 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU104 ND2 $PINS O=n8 I1=n65 I2=n41
XU105 INV1S $PINS O=n65 I=n40
XU106 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU107 ND2 $PINS O=n9 I1=n115 I2=n46
XU108 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU109 ND2 $PINS O=n11 I1=n114 I2=n54
XU110 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU111 ND2 $PINS O=n3 I1=n118 I2=n22
XU112 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU113 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU114 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU115 OAI12H $PINS O=n47 A1=n49 B1=n50 B2=n48
XU116 INV1S $PINS O=n55 I=n57
XU117 AOI12HS $PINS O=n50 A1=n52 B1=n114 B2=n55
XU118 INV1S $PINS O=n52 I=n54
XU119 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n115
XU120 INV1S $PINS O=n44 I=n46
XU121 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n116
XU122 INV1S $PINS O=n36 I=n38
XU123 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n117
XU124 INV1S $PINS O=n28 I=n30
XU125 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n118
XU126 INV1S $PINS O=n20 I=n22
XU127 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU128 ND2 $PINS O=n6 I1=n63 I2=n33
XU129 INV1S $PINS O=n63 I=n32
XU130 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU131 ND2 $PINS O=n7 I1=n116 I2=n38
XU132 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU133 ND2 $PINS O=n5 I1=n117 I2=n30
XU134 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU135 ND2 $PINS O=n4 I1=n61 I2=n25
XU136 INV1S $PINS O=n61 I=n24
XU137 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU138 OR2 $PINS O=n116 I1=A[5] I2=B[5]
XU139 OR2 $PINS O=n117 I1=A[7] I2=B[7]
XU140 OR2 $PINS O=n118 I1=A[9] I2=B[9]
XU141 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU142 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU143 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU144 ND2 $PINS O=n33 I1=B[6] I2=A[6]
XU145 ND2 $PINS O=n38 I1=B[5] I2=A[5]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU151 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU152 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_249 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU85 OR2 $PINS O=n112 I1=B[11] I2=A[11]
XU86 OR2S $PINS O=n117 I1=B[1] I2=A[1]
XU87 AN2 $PINS O=SUM[0] I1=n119 I2=n57
XU88 XOR2HS $PINS O=SUM[11] I1=n1 I2=n114
XU89 OA12 $PINS O=n114 A1=n17 B1=n18 B2=n16
XU90 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU91 ND2S $PINS O=n57 I1=A[0] I2=B[0]
XU92 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU93 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU94 OR2S $PINS O=n115 I1=B[3] I2=A[3]
XU95 OR2S $PINS O=n119 I1=B[0] I2=A[0]
XU96 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU97 ND2 $PINS O=n11 I1=n117 I2=n54
XU98 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU99 ND2 $PINS O=n9 I1=n115 I2=n46
XU100 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU101 ND2 $PINS O=n10 I1=n67 I2=n49
XU102 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU103 ND2 $PINS O=n8 I1=n65 I2=n41
XU104 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU105 ND2 $PINS O=n7 I1=n116 I2=n38
XU106 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU107 ND2 $PINS O=n5 I1=n118 I2=n30
XU108 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU109 ND2 $PINS O=n3 I1=n120 I2=n22
XU110 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU111 ND2 $PINS O=n4 I1=n61 I2=n25
XU112 INV1S $PINS O=n55 I=n57
XU113 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU114 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU115 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU116 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU117 AOI12HS $PINS O=n50 A1=n52 B1=n117 B2=n55
XU118 INV1S $PINS O=n52 I=n54
XU119 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n115
XU120 INV1S $PINS O=n44 I=n46
XU121 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n116
XU122 INV1S $PINS O=n36 I=n38
XU123 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n118
XU124 INV1S $PINS O=n28 I=n30
XU125 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n120
XU126 INV1S $PINS O=n20 I=n22
XU127 ND2 $PINS O=n1 I1=n112 I2=n14
XU128 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU129 ND2 $PINS O=n6 I1=n63 I2=n33
XU130 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU131 ND2 $PINS O=n2 I1=n59 I2=n17
XU132 INV1S $PINS O=n59 I=n16
XU133 INV1S $PINS O=n67 I=n48
XU134 INV1S $PINS O=n65 I=n40
XU135 INV1S $PINS O=n63 I=n32
XU136 INV1S $PINS O=n61 I=n24
XU137 OR2 $PINS O=n116 I1=B[5] I2=A[5]
XU138 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU139 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU142 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU143 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU144 OR2 $PINS O=n118 I1=B[7] I2=A[7]
XU145 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU146 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU147 OR2 $PINS O=n120 I1=B[9] I2=A[9]
XU148 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU150 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU151 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU152 ND2 $PINS O=n22 I1=A[9] I2=B[9]
.ENDS

.SUBCKT Siso_DW01_add_250 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN221_backward_metrics_6__1__5
+ FE_OFN222_backward_metrics_6__1__3 FE_OFN232_backward_metrics_6__1__1
XFE_OFC3049_n57 INV1S $PINS O=n55 I=n57
XU85 OR2 $PINS O=n116 I1=FE_OFN232_backward_metrics_6__1__1 I2=A[1]
XU86 AN2 $PINS O=SUM[0] I1=n118 I2=n57
XU87 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU88 ND2 $PINS O=n57 I1=A[0] I2=B[0]
XU89 ND2S $PINS O=n54 I1=A[1] I2=FE_OFN232_backward_metrics_6__1__1
XU90 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU91 OR2 $PINS O=n113 I1=FE_OFN222_backward_metrics_6__1__3 I2=A[3]
XU92 OR2S $PINS O=n118 I1=B[0] I2=A[0]
XU93 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU94 ND2 $PINS O=n11 I1=n116 I2=n54
XU95 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU96 ND2 $PINS O=n9 I1=n113 I2=n46
XU97 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU98 ND2 $PINS O=n10 I1=n67 I2=n49
XU99 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU100 ND2 $PINS O=n8 I1=n65 I2=n41
XU101 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU102 ND2 $PINS O=n7 I1=n114 I2=n38
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 ND2 $PINS O=n6 I1=n63 I2=n33
XU105 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU106 ND2 $PINS O=n4 I1=n61 I2=n25
XU107 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU108 ND2 $PINS O=n5 I1=n115 I2=n30
XU109 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU110 ND2 $PINS O=n3 I1=n119 I2=n22
XU112 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU113 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU114 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU115 OAI12H $PINS O=n47 A1=n49 B1=n50 B2=n48
XU116 AOI12HS $PINS O=n50 A1=n52 B1=n116 B2=n55
XU117 INV1S $PINS O=n52 I=n54
XU118 AOI12H $PINS O=n42 A1=n44 B1=n47 B2=n113
XU119 INV1S $PINS O=n44 I=n46
XU120 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n114
XU121 INV1S $PINS O=n36 I=n38
XU122 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n115
XU123 INV1S $PINS O=n28 I=n30
XU124 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n119
XU125 INV1S $PINS O=n20 I=n22
XU126 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU127 ND2 $PINS O=n2 I1=n59 I2=n17
XU128 INV1S $PINS O=n59 I=n16
XU129 INV1S $PINS O=n67 I=n48
XU130 INV1S $PINS O=n65 I=n40
XU131 INV1S $PINS O=n63 I=n32
XU132 INV1S $PINS O=n61 I=n24
XU133 OR2 $PINS O=n114 I1=FE_OFN221_backward_metrics_6__1__5 I2=A[5]
XU134 OR2 $PINS O=n115 I1=B[7] I2=A[7]
XU135 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU136 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU139 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU140 ND2 $PINS O=n1 I1=n117 I2=n14
XU141 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU142 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU143 ND2 $PINS O=n38 I1=A[5] I2=FE_OFN221_backward_metrics_6__1__5
XU144 OR2 $PINS O=n117 I1=B[11] I2=A[11]
XU145 OR2 $PINS O=n119 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU147 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU148 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU149 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU150 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU151 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU152 ND2 $PINS O=n22 I1=A[9] I2=B[9]
.ENDS

.SUBCKT Siso_DW01_add_251 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN246_backward_metrics_6__2__0
XU85 AN2 $PINS O=SUM[0] I1=n113 I2=n57
XU86 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU87 ND2S $PINS O=n57 I1=A[0] I2=B[0]
XU88 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU89 OR2S $PINS O=n114 I1=B[3] I2=A[3]
XU90 OR2S $PINS O=n117 I1=B[1] I2=A[1]
XU91 OR2S $PINS O=n113 I1=FE_OFN246_backward_metrics_6__2__0 I2=A[0]
XU92 INV1S $PINS O=n55 I=n57
XU93 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU94 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU95 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU96 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU97 AOI12HS $PINS O=n50 A1=n52 B1=n117 B2=n55
XU98 INV1S $PINS O=n52 I=n54
XU99 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n114
XU100 INV1S $PINS O=n44 I=n46
XU101 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n115
XU102 INV1S $PINS O=n36 I=n38
XU103 AOI12HS $PINS O=n26 A1=n28 B1=n31 B2=n116
XU104 INV1S $PINS O=n28 I=n30
XU105 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU106 ND2 $PINS O=n9 I1=n114 I2=n46
XU107 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU108 ND2 $PINS O=n3 I1=n118 I2=n22
XU109 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n118
XU110 INV1S $PINS O=n20 I=n22
XU111 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU112 ND2 $PINS O=n11 I1=n117 I2=n54
XU113 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU114 ND2 $PINS O=n7 I1=n115 I2=n38
XU115 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU116 ND2 $PINS O=n5 I1=n116 I2=n30
XU117 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU118 ND2 $PINS O=n10 I1=n67 I2=n49
XU119 INV1S $PINS O=n67 I=n48
XU120 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU121 ND2 $PINS O=n2 I1=n59 I2=n17
XU122 INV1S $PINS O=n59 I=n16
XU123 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU124 ND2 $PINS O=n4 I1=n61 I2=n25
XU125 INV1S $PINS O=n61 I=n24
XU126 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU127 ND2 $PINS O=n6 I1=n63 I2=n33
XU128 INV1S $PINS O=n63 I=n32
XU129 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU130 ND2 $PINS O=n8 I1=n65 I2=n41
XU131 INV1S $PINS O=n65 I=n40
XU132 OR2 $PINS O=n115 I1=B[5] I2=A[5]
XU133 OR2 $PINS O=n116 I1=B[7] I2=A[7]
XU134 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU135 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU136 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU137 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU138 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU139 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU140 ND2 $PINS O=n1 I1=n119 I2=n14
XU141 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU142 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU143 ND2 $PINS O=n46 I1=A[3] I2=B[3]
XU144 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU145 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU146 OR2 $PINS O=n118 I1=B[9] I2=A[9]
XU147 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU148 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU149 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU150 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=A[9] I2=B[9]
XU152 OR2 $PINS O=n119 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_252 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN175_forward_sum_0__1__6
+ FE_OFN218_backward_metrics_6__1__10 FE_OFN219_backward_metrics_6__1__7
+ FE_OFN220_backward_metrics_6__1__6
XFE_OFC3072_n57 INV1S $PINS O=n55 I=n57
XU85 AN2 $PINS O=SUM[0] I1=n119 I2=n57
XU86 XOR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU87 OA12 $PINS O=n113 A1=n17 B1=n18 B2=n16
XU88 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU89 ND2S $PINS O=n57 I1=A[0] I2=B[0]
XU90 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU91 OR2S $PINS O=n117 I1=B[1] I2=A[1]
XU92 OR2S $PINS O=n119 I1=B[0] I2=A[0]
XU93 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU94 ND2 $PINS O=n11 I1=n117 I2=n54
XU95 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU96 ND2 $PINS O=n9 I1=n114 I2=n46
XU97 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU98 ND2 $PINS O=n10 I1=n67 I2=n49
XU99 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU100 ND2 $PINS O=n8 I1=n65 I2=n41
XU101 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU102 ND2 $PINS O=n7 I1=n115 I2=n38
XU103 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU104 ND2 $PINS O=n5 I1=n116 I2=n30
XU105 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU106 ND2 $PINS O=n3 I1=n120 I2=n22
XU107 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU108 ND2 $PINS O=n4 I1=n61 I2=n25
XU110 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU111 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU112 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU113 OAI12H $PINS O=n47 A1=n49 B1=n50 B2=n48
XU114 AOI12HS $PINS O=n50 A1=n52 B1=n117 B2=n55
XU115 INV1S $PINS O=n52 I=n54
XU116 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n114
XU117 INV1S $PINS O=n44 I=n46
XU118 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n115
XU119 INV1S $PINS O=n36 I=n38
XU120 AOI12HS $PINS O=n26 A1=n28 B1=n31 B2=n116
XU121 INV1S $PINS O=n28 I=n30
XU122 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n120
XU123 INV1S $PINS O=n20 I=n22
XU124 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU125 ND2 $PINS O=n6 I1=n63 I2=n33
XU126 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU127 ND2 $PINS O=n2 I1=n59 I2=n17
XU128 INV1S $PINS O=n59 I=n16
XU129 INV1S $PINS O=n67 I=n48
XU130 INV1S $PINS O=n65 I=n40
XU131 INV1S $PINS O=n63 I=n32
XU132 INV1S $PINS O=n61 I=n24
XU133 ND2 $PINS O=n1 I1=n118 I2=n14
XU134 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU135 OR2 $PINS O=n114 I1=B[3] I2=A[3]
XU136 OR2 $PINS O=n115 I1=B[5] I2=A[5]
XU137 OR2 $PINS O=n116 I1=FE_OFN219_backward_metrics_6__1__7 I2=A[7]
XU138 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU139 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU142 ND2 $PINS O=n46 I1=A[3] I2=B[3]
XU143 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU144 OR2 $PINS O=n118 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU146 OR2 $PINS O=n120 I1=B[9] I2=A[9]
XU147 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU148 ND2 $PINS O=n33 I1=FE_OFN175_forward_sum_0__1__6
+ I2=FE_OFN220_backward_metrics_6__1__6
XU149 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU150 ND2 $PINS O=n17 I1=A[10] I2=FE_OFN218_backward_metrics_6__1__10
XU151 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU152 ND2 $PINS O=n22 I1=A[9] I2=B[9]
.ENDS

.SUBCKT Siso_DW01_add_253 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC3021_n54 INV1S $PINS O=n52 I=n54
XFE_OFC2778_n57 INV1S $PINS O=n55 I=n57
XU85 OR2 $PINS O=n112 I1=A[0] I2=B[0]
XU86 AN2 $PINS O=SUM[0] I1=n112 I2=n57
XU87 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU88 ND2 $PINS O=n57 I1=B[0] I2=A[0]
XU89 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU90 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU91 OR2 $PINS O=n115 I1=A[3] I2=B[3]
XU92 OR2 $PINS O=n114 I1=A[1] I2=B[1]
XU93 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU94 ND2 $PINS O=n9 I1=n115 I2=n46
XU95 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU96 ND2 $PINS O=n10 I1=n67 I2=n49
XU97 INV1S $PINS O=n67 I=n48
XU98 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 ND2 $PINS O=n11 I1=n114 I2=n54
XU100 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU101 ND2 $PINS O=n3 I1=n118 I2=n22
XU102 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU103 ND2 $PINS O=n2 I1=n59 I2=n17
XU104 INV1S $PINS O=n59 I=n16
XU105 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU106 ND2 $PINS O=n1 I1=n119 I2=n14
XU107 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU108 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU109 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU110 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU111 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU113 AOI12HS $PINS O=n50 A1=n52 B1=n114 B2=n55
XU115 AOI12H $PINS O=n42 A1=n44 B1=n47 B2=n115
XU116 INV1S $PINS O=n44 I=n46
XU117 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n116
XU118 INV1S $PINS O=n36 I=n38
XU119 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n117
XU120 INV1S $PINS O=n28 I=n30
XU121 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n118
XU122 INV1S $PINS O=n20 I=n22
XU123 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU124 ND2 $PINS O=n5 I1=n117 I2=n30
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n116 I2=n38
XU127 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU128 ND2 $PINS O=n6 I1=n63 I2=n33
XU129 INV1S $PINS O=n63 I=n32
XU130 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU131 ND2 $PINS O=n4 I1=n61 I2=n25
XU132 INV1S $PINS O=n61 I=n24
XU133 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU134 ND2 $PINS O=n8 I1=n65 I2=n41
XU135 INV1S $PINS O=n65 I=n40
XU136 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU137 OR2 $PINS O=n116 I1=A[5] I2=B[5]
XU138 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU139 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU140 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU141 ND2 $PINS O=n33 I1=B[6] I2=A[6]
XU142 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU143 ND2 $PINS O=n41 I1=B[4] I2=A[4]
XU144 ND2 $PINS O=n38 I1=B[5] I2=A[5]
XU145 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU146 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU147 OR2 $PINS O=n117 I1=A[7] I2=B[7]
XU148 OR2 $PINS O=n118 I1=A[9] I2=B[9]
XU149 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU152 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_254 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN174_forward_sum_0__1__9
XFE_OFC2760_n57 INV1S $PINS O=n55 I=n57
XU85 AN2 $PINS O=SUM[0] I1=n118 I2=n57
XU86 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU87 ND2 $PINS O=n57 I1=A[0] I2=B[0]
XU88 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU89 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU90 OR2 $PINS O=n114 I1=B[3] I2=A[3]
XU91 OR2S $PINS O=n113 I1=B[1] I2=A[1]
XU92 OR2S $PINS O=n118 I1=B[0] I2=A[0]
XU93 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU94 ND2 $PINS O=n11 I1=n113 I2=n54
XU95 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU96 ND2 $PINS O=n9 I1=n114 I2=n46
XU97 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU98 ND2 $PINS O=n10 I1=n67 I2=n49
XU99 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU100 ND2 $PINS O=n8 I1=n65 I2=n41
XU101 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU102 ND2 $PINS O=n7 I1=n115 I2=n38
XU103 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU104 ND2 $PINS O=n3 I1=n119 I2=n22
XU105 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU106 ND2 $PINS O=n2 I1=n59 I2=n17
XU107 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU108 ND2 $PINS O=n1 I1=n116 I2=n14
XU109 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU110 ND2 $PINS O=n4 I1=n61 I2=n25
XU112 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU113 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU114 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU115 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU116 AOI12HS $PINS O=n50 A1=n52 B1=n113 B2=n55
XU117 INV1S $PINS O=n52 I=n54
XU118 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n114
XU119 INV1S $PINS O=n44 I=n46
XU120 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n115
XU121 INV1S $PINS O=n36 I=n38
XU122 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n119
XU123 INV1S $PINS O=n20 I=n22
XU124 AOI12HP $PINS O=n26 A1=n28 B1=n31 B2=n117
XU125 INV1S $PINS O=n28 I=n30
XU126 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU127 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU128 ND2 $PINS O=n6 I1=n63 I2=n33
XU129 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU130 ND2 $PINS O=n5 I1=n117 I2=n30
XU131 INV1S $PINS O=n67 I=n48
XU132 INV1S $PINS O=n65 I=n40
XU133 INV1S $PINS O=n59 I=n16
XU134 INV1S $PINS O=n63 I=n32
XU135 INV1S $PINS O=n61 I=n24
XU136 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU137 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU138 OR2 $PINS O=n115 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU143 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU144 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU145 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU146 OR2 $PINS O=n116 I1=B[11] I2=A[11]
XU147 OR2 $PINS O=n117 I1=B[7] I2=A[7]
XU148 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU150 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU151 ND2 $PINS O=n22 I1=FE_OFN174_forward_sum_0__1__9 I2=B[9]
XU152 OR2 $PINS O=n119 I1=B[9] I2=A[9]
.ENDS

.SUBCKT Siso_DW01_add_255 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN184_forward_sum_0__6__9 FE_OFN185_forward_sum_0__6__0
XU85 AN2 $PINS O=SUM[0] I1=n118 I2=n57
XU86 ND2S $PINS O=n49 I1=A[2] I2=B[2]
XU87 ND2S $PINS O=n57 I1=FE_OFN185_forward_sum_0__6__0 I2=B[0]
XU88 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU89 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU90 OR2S $PINS O=n113 I1=B[3] I2=A[3]
XU91 OR2S $PINS O=n116 I1=B[1] I2=A[1]
XU92 OR2S $PINS O=n118 I1=B[0] I2=A[0]
XU93 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU94 ND2 $PINS O=n11 I1=n116 I2=n54
XU95 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU96 ND2 $PINS O=n9 I1=n113 I2=n46
XU97 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU98 ND2 $PINS O=n10 I1=n67 I2=n49
XU99 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU100 ND2 $PINS O=n8 I1=n65 I2=n41
XU101 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU102 ND2 $PINS O=n7 I1=n114 I2=n38
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 ND2 $PINS O=n6 I1=n63 I2=n33
XU105 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU106 ND2 $PINS O=n4 I1=n61 I2=n25
XU107 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU108 ND2 $PINS O=n5 I1=n115 I2=n30
XU109 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU110 ND2 $PINS O=n3 I1=n119 I2=n22
XU111 INV1S $PINS O=n55 I=n57
XU112 OAI12HS $PINS O=n31 A1=n33 B1=n34 B2=n32
XU113 OAI12HS $PINS O=n23 A1=n25 B1=n26 B2=n24
XU114 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU115 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU116 AOI12HS $PINS O=n50 A1=n52 B1=n116 B2=n55
XU117 INV1S $PINS O=n52 I=n54
XU118 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n113
XU119 INV1S $PINS O=n44 I=n46
XU120 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n114
XU121 INV1S $PINS O=n36 I=n38
XU122 AOI12HS $PINS O=n26 A1=n28 B1=n31 B2=n115
XU123 INV1S $PINS O=n28 I=n30
XU124 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n119
XU125 INV1S $PINS O=n20 I=n22
XU126 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU127 ND2 $PINS O=n2 I1=n59 I2=n17
XU128 INV1S $PINS O=n59 I=n16
XU129 INV1S $PINS O=n67 I=n48
XU130 INV1S $PINS O=n65 I=n40
XU131 INV1S $PINS O=n63 I=n32
XU132 INV1S $PINS O=n61 I=n24
XU133 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU134 ND2 $PINS O=n1 I1=n117 I2=n14
XU135 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU136 ND2 $PINS O=n14 I1=A[11] I2=B[11]
XU137 OR2 $PINS O=n114 I1=B[5] I2=A[5]
XU138 OR2 $PINS O=n115 I1=B[7] I2=A[7]
XU139 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU140 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU141 NR2 $PINS O=n48 I1=B[2] I2=A[2]
XU142 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU143 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU144 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU145 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU146 OR2 $PINS O=n117 I1=B[11] I2=A[11]
XU147 OR2 $PINS O=n119 I1=B[9] I2=A[9]
XU148 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU149 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU150 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU151 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU152 ND2 $PINS O=n22 I1=FE_OFN184_forward_sum_0__6__9 I2=B[9]
.ENDS

.SUBCKT Siso_DW01_add_256 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_236_0 OAI12HP $PINS O=n51 A1=n53 B1=n52 B2=n55
XFE_OFC3045_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2998_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2997_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2518_n51 INV2 $PINS O=n50 I=n51
XU83 AN2 $PINS O=SUM[0] I1=n115 I2=n55
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 OR2 $PINS O=n113 I1=A[9] I2=B[9]
XU87 OA12 $PINS O=n114 A1=n17 B1=n18 B2=n16
XU88 XOR2HS $PINS O=SUM[11] I1=n1 I2=n114
XU89 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU90 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU91 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU92 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU93 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU94 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU95 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU96 OR2S $PINS O=n115 I1=A[0] I2=B[0]
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 ND2 $PINS O=n11 I1=n66 I2=n53
XU101 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU102 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU105 ND2 $PINS O=n10 I1=n65 I2=n49
XU107 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU108 ND2 $PINS O=n8 I1=n63 I2=n41
XU110 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU111 ND2 $PINS O=n6 I1=n61 I2=n33
XU112 INV1S $PINS O=n61 I=n32
XU113 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU114 ND2 $PINS O=n2 I1=n57 I2=n17
XU115 INV1S $PINS O=n57 I=n16
XU116 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU117 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 INV1S $PINS O=n59 I=n24
XU119 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU120 ND2 $PINS O=n9 I1=n64 I2=n46
XU121 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU122 INV1S $PINS O=n64 I=n45
XU123 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU124 ND2 $PINS O=n7 I1=n111 I2=n38
XU125 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n112 I2=n30
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 ND2 $PINS O=n3 I1=n113 I2=n22
XU130 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU133 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12HP $PINS O=n26 A1=n28 B1=n31 B2=n112
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n113
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n116 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n116 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_257 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_237_0 AOI12HP $PINS O=n47 A1=n49 B1=n52 B2=n113
XFE_RC_235_0 AOI12HP $PINS O=n23 A1=n25 B1=n28 B2=n114
XFE_OFC2721_n51 INV1S $PINS O=n49 I=n51
XU84 AN2 $PINS O=SUM[0] I1=n118 I2=n56
XU85 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU86 OR2 $PINS O=n113 I1=A[2] I2=B[2]
XU87 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU88 OR2 $PINS O=n115 I1=A[6] I2=B[6]
XU89 OR2 $PINS O=n116 I1=A[10] I2=B[10]
XU90 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU91 AO12S $PINS O=n117 A1=n17 B1=n20 B2=n116
XU92 OR2S $PINS O=n118 I1=A[0] I2=B[0]
XU93 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU94 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU95 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU96 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU97 ND2 $PINS O=n51 I1=B[2] I2=A[2]
XU98 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU99 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU100 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU101 ND2 $PINS O=n11 I1=n67 I2=n54
XU102 INV1S $PINS O=n67 I=n53
XU103 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU104 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU105 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU106 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU107 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU108 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU109 ND2 $PINS O=n2 I1=n116 I2=n19
XU110 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU111 ND2 $PINS O=n9 I1=n65 I2=n46
XU112 INV1S $PINS O=n65 I=n45
XU113 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU114 ND2 $PINS O=n7 I1=n63 I2=n38
XU115 INV1S $PINS O=n63 I=n37
XU116 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU117 ND2 $PINS O=n5 I1=n61 I2=n30
XU118 INV1S $PINS O=n61 I=n29
XU119 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU120 ND2 $PINS O=n3 I1=n59 I2=n22
XU121 INV1S $PINS O=n59 I=n21
XU122 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU123 ND2 $PINS O=n10 I1=n113 I2=n51
XU124 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU125 ND2 $PINS O=n6 I1=n115 I2=n35
XU126 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU127 ND2 $PINS O=n8 I1=n112 I2=n43
XU128 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU129 ND2 $PINS O=n4 I1=n114 I2=n27
XU132 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n112
XU133 INV1S $PINS O=n41 I=n43
XU134 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n115
XU135 INV1S $PINS O=n33 I=n35
XU137 INV1S $PINS O=n25 I=n27
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU145 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_258 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN209_backward_metrics_5__2__10
+ FE_OFN210_backward_metrics_5__2__9
XFE_OFC2912_n29 INV1S $PINS O=n27 I=n29
XU83 OR2 $PINS O=n110 I1=B[2] I2=A[2]
XU84 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU85 ND2S $PINS O=n10 I1=n110 I2=n50
XU86 ND2S $PINS O=n8 I1=n63 I2=n41
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU93 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU94 ND2S $PINS O=n22 I1=A[9] I2=FE_OFN210_backward_metrics_5__2__9
XU95 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU96 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU97 XOR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU98 OA12 $PINS O=n113 A1=n17 B1=n18 B2=n16
XU99 OR2S $PINS O=n114 I1=B[11] I2=A[11]
XU100 INV1S $PINS O=n42 I=n43
XU101 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU102 ND2 $PINS O=n9 I1=n64 I2=n45
XU103 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU104 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU105 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU106 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU107 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU108 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU109 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU110 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU111 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU112 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU113 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU114 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU115 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU116 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU117 NR2 $PINS O=n35 I1=n40 I2=n37
XU118 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU119 INV1S $PINS O=n28 I=n30
XU121 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU122 INV1S $PINS O=n20 I=n22
XU123 INV1S $PINS O=n19 I=n21
XU124 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n110
XU125 INV1S $PINS O=n48 I=n50
XU126 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU127 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU128 ND2 $PINS O=n2 I1=n57 I2=n17
XU129 INV1S $PINS O=n57 I=n16
XU130 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU131 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU132 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU133 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU134 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU135 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU136 INV1S $PINS O=n63 I=n40
XU137 INV1S $PINS O=n64 I=n44
XU138 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU139 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU140 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n16 I1=FE_OFN209_backward_metrics_5__2__10 I2=A[10]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 ND2 $PINS O=n1 I1=n114 I2=n14
XU150 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_259 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2534_n43 INV2 $PINS O=n42 I=n43
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU85 ND2 $PINS O=n50 I1=A[2] I2=B[2]
XU86 ND2 $PINS O=n1 I1=n112 I2=n113
XU87 ND2S $PINS O=n113 I1=A[11] I2=B[11]
XU88 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU91 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU92 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU93 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU94 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU95 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU96 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU97 OR2S $PINS O=n112 I1=B[11] I2=A[11]
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU102 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU103 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU104 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU105 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU106 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU107 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU108 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU109 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU110 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU111 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU112 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU115 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU116 INV1S $PINS O=n20 I=n22
XU117 INV1S $PINS O=n19 I=n21
XU118 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU119 INV1S $PINS O=n28 I=n30
XU120 INV1S $PINS O=n27 I=n29
XU121 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU122 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU123 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU124 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU125 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU126 OR2B1S $PINS O=n2 I1=n16 B1=n17
XU127 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU128 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU129 AOI12H $PINS O=n46 A1=n48 B1=n47 B2=n51
XU130 INV1S $PINS O=n48 I=n50
XU131 INV1S $PINS O=n47 I=n49
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU134 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU135 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU136 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU137 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU138 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU139 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU140 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU143 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_260 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN160_branch_metrics_2__2__9
XFE_OFC2940_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2899_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2861_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2563_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[7] I2=B[7]
XU85 OR2 $PINS O=n112 I1=A[9] I2=FE_OFN160_branch_metrics_2__2__9
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU88 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU89 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU92 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU93 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2 $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU103 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU104 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU105 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU106 ND2 $PINS O=n10 I1=n65 I2=n49
XU108 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU109 ND2 $PINS O=n8 I1=n63 I2=n41
XU111 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU112 ND2 $PINS O=n6 I1=n61 I2=n33
XU113 INV1S $PINS O=n61 I=n32
XU114 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU115 ND2 $PINS O=n4 I1=n59 I2=n25
XU116 INV1S $PINS O=n59 I=n24
XU117 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU118 ND2 $PINS O=n2 I1=n57 I2=n17
XU119 INV1S $PINS O=n57 I=n16
XU120 ND2 $PINS O=n9 I1=n64 I2=n46
XU121 INV1S $PINS O=n64 I=n45
XU122 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU123 ND2 $PINS O=n7 I1=n110 I2=n38
XU124 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU125 ND2 $PINS O=n5 I1=n111 I2=n30
XU126 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU127 ND2 $PINS O=n3 I1=n112 I2=n22
XU128 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU129 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU130 NR2 $PINS O=n43 I1=n45 I2=n48
XU131 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU132 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU133 INV1S $PINS O=n36 I=n38
XU134 AOI12HS $PINS O=n26 A1=n28 B1=n31 B2=n111
XU135 INV1S $PINS O=n28 I=n30
XU136 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU137 INV1S $PINS O=n20 I=n22
XU138 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU141 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU142 ND2 $PINS O=n1 I1=n117 I2=n14
XU143 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU144 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU145 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU146 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU147 ND2 $PINS O=n33 I1=B[6] I2=A[6]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_261 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2907_n51 INV1S $PINS O=n49 I=n51
XU84 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU85 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU86 OR2 $PINS O=n113 I1=A[8] I2=B[8]
XU87 OR2 $PINS O=n114 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 AN2 $PINS O=SUM[0] I1=n118 I2=n56
XU90 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU91 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU92 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU96 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU97 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU98 OR2S $PINS O=n118 I1=A[0] I2=B[0]
XU99 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU100 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU101 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU102 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU103 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU104 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU105 ND2 $PINS O=n9 I1=n65 I2=n46
XU106 INV1S $PINS O=n65 I=n45
XU107 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU108 ND2 $PINS O=n7 I1=n63 I2=n38
XU109 INV1S $PINS O=n63 I=n37
XU110 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU111 ND2 $PINS O=n5 I1=n61 I2=n30
XU112 INV1S $PINS O=n61 I=n29
XU113 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU114 ND2 $PINS O=n3 I1=n59 I2=n22
XU115 INV1S $PINS O=n59 I=n21
XU116 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU117 ND2 $PINS O=n10 I1=n111 I2=n51
XU118 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU119 ND2 $PINS O=n6 I1=n114 I2=n35
XU120 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU121 ND2 $PINS O=n8 I1=n112 I2=n43
XU122 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU123 ND2 $PINS O=n4 I1=n113 I2=n27
XU124 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU125 ND2 $PINS O=n2 I1=n115 I2=n19
XU126 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n111
XU128 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n112
XU129 INV1S $PINS O=n41 I=n43
XU130 AOI12HS $PINS O=n31 A1=n33 B1=n36 B2=n114
XU131 INV1S $PINS O=n33 I=n35
XU132 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n113
XU133 INV1S $PINS O=n25 I=n27
XU134 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU135 ND2 $PINS O=n11 I1=n67 I2=n54
XU136 INV1S $PINS O=n67 I=n53
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2 $PINS O=n1 I1=n119 I2=n14
XU141 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU142 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU143 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU146 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU147 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_262 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC3059_n22 INV1S $PINS O=n20 I=n22
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU88 ND2S $PINS O=n10 I1=n112 I2=n50
XU89 ND2S $PINS O=n8 I1=n63 I2=n41
XU90 XOR2HS $PINS O=SUM[5] I1=n7 I2=n115
XU91 OA12S $PINS O=n115 A1=n41 B1=n42 B2=n40
XU92 ND2S $PINS O=n6 I1=n61 I2=n33
XU93 ND2S $PINS O=n4 I1=n59 I2=n25
XU94 XOR2HS $PINS O=SUM[11] I1=n1 I2=n116
XU95 OA12 $PINS O=n116 A1=n17 B1=n18 B2=n16
XU96 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU97 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU98 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU99 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU100 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU101 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU102 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU103 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU104 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU105 OR2S $PINS O=n117 I1=B[11] I2=A[11]
XU106 INV1S $PINS O=n42 I=n43
XU107 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU108 ND2 $PINS O=n11 I1=n66 I2=n53
XU109 INV1S $PINS O=n66 I=n52
XU110 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU111 ND2 $PINS O=n9 I1=n64 I2=n45
XU112 INV1S $PINS O=n64 I=n44
XU113 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU114 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU115 INV1S $PINS O=n63 I=n40
XU116 ND2 $PINS O=n7 I1=n62 I2=n38
XU117 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU118 INV1S $PINS O=n61 I=n32
XU119 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU120 ND2 $PINS O=n5 I1=n110 I2=n30
XU121 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU122 INV1S $PINS O=n59 I=n24
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n111 I2=n22
XU125 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU126 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU127 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU128 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU129 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU130 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU131 NR2 $PINS O=n35 I1=n40 I2=n37
XU132 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU133 INV1S $PINS O=n28 I=n30
XU134 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU136 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n112
XU137 INV1S $PINS O=n48 I=n50
XU138 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU139 ND2 $PINS O=n2 I1=n57 I2=n17
XU140 INV1S $PINS O=n57 I=n16
XU141 INV1S $PINS O=n62 I=n37
XU142 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU143 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU144 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU145 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU146 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU147 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU148 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU149 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU150 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU151 ND2 $PINS O=n1 I1=n117 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_263 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN199_backward_metrics_4__0__8
+ FE_OFN200_backward_metrics_4__0__3
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2 $PINS O=n1 I1=n112 I2=n113
XU85 ND2S $PINS O=n113 I1=A[11] I2=B[11]
XU86 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU87 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU88 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU89 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU90 ND2S $PINS O=n25 I1=A[8] I2=FE_OFN199_backward_metrics_4__0__8
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU93 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU96 OR2S $PINS O=n112 I1=B[11] I2=A[11]
XU97 INV1S $PINS O=n42 I=n43
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU101 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU102 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU103 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU104 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU105 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU106 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU107 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU108 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU111 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU112 NR2 $PINS O=n35 I1=n40 I2=n37
XU113 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU114 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU115 INV1S $PINS O=n20 I=n22
XU116 INV1S $PINS O=n19 I=n21
XU117 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU118 INV1S $PINS O=n28 I=n30
XU119 INV1S $PINS O=n27 I=n29
XU120 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU121 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU122 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU123 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU124 OR2B1S $PINS O=n2 I1=n16 B1=n17
XU125 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU126 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU127 AOI12H $PINS O=n46 A1=n48 B1=n47 B2=n51
XU128 INV1S $PINS O=n48 I=n50
XU129 INV1S $PINS O=n47 I=n49
XU130 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU131 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU132 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU133 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU134 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU135 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU136 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=FE_OFN200_backward_metrics_4__0__3 I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_264 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN163_branch_metrics_3__2__7
XFE_OFC2882_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2881_n45 INV1S $PINS O=n64 I=n45
XFE_OFC2754_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 AN2 $PINS O=SUM[0] I1=n115 I2=n55
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12S $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 OR2S $PINS O=n115 I1=A[0] I2=B[0]
XU90 ND2 $PINS O=n55 I1=B[0] I2=A[0]
XU91 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU92 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU93 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU94 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU96 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU99 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU100 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU101 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU102 ND2 $PINS O=n10 I1=n65 I2=n49
XU103 INV1S $PINS O=n65 I=n48
XU104 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU105 ND2 $PINS O=n2 I1=n57 I2=n17
XU106 INV1S $PINS O=n57 I=n16
XU107 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU108 ND2 $PINS O=n6 I1=n61 I2=n33
XU109 INV1S $PINS O=n61 I=n32
XU110 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU111 ND2 $PINS O=n4 I1=n59 I2=n25
XU112 INV1S $PINS O=n59 I=n24
XU113 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU114 ND2 $PINS O=n8 I1=n63 I2=n41
XU115 INV1S $PINS O=n63 I=n40
XU116 ND2 $PINS O=n9 I1=n64 I2=n46
XU118 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU119 ND2 $PINS O=n5 I1=n112 I2=n30
XU120 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU121 ND2 $PINS O=n7 I1=n110 I2=n38
XU122 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU123 ND2 $PINS O=n3 I1=n111 I2=n22
XU124 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU125 AOI12HS $PINS O=n42 A1=n44 B1=n43 B2=n51
XU126 NR2 $PINS O=n43 I1=n45 I2=n48
XU127 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU128 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU129 INV1S $PINS O=n36 I=n38
XU130 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU131 INV1S $PINS O=n28 I=n30
XU132 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU133 INV1S $PINS O=n20 I=n22
XU134 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU135 ND2 $PINS O=n11 I1=n66 I2=n53
XU137 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU140 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU141 ND2 $PINS O=n1 I1=n116 I2=n14
XU142 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU143 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU144 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=FE_OFN163_branch_metrics_3__2__7 I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n116 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_265 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_268_0 AOI12HP $PINS O=n42 A1=n44 B1=n51 B2=n43
XFE_OFC2909_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2689_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU90 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU91 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU92 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 INV1S $PINS O=n66 I=n52
XU103 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU109 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU110 ND2 $PINS O=n2 I1=n57 I2=n17
XU111 INV1S $PINS O=n57 I=n16
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU116 ND2 $PINS O=n8 I1=n63 I2=n41
XU117 INV1S $PINS O=n63 I=n40
XU118 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU119 ND2 $PINS O=n4 I1=n59 I2=n25
XU120 INV1S $PINS O=n59 I=n24
XU121 ND2 $PINS O=n9 I1=n64 I2=n46
XU122 INV1S $PINS O=n64 I=n45
XU123 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU124 ND2 $PINS O=n7 I1=n110 I2=n38
XU125 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n112 I2=n30
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 ND2 $PINS O=n3 I1=n111 I2=n22
XU129 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU133 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_266 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_220_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC2517_n43 INV1S $PINS O=n42 I=n43
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[2] I2=A[2]
XU85 OR2 $PINS O=n112 I1=B[9] I2=A[9]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2S $PINS O=n9 I1=n64 I2=n45
XU88 ND2S $PINS O=n8 I1=n63 I2=n41
XU89 XOR2HS $PINS O=SUM[5] I1=n7 I2=n114
XU90 OA12S $PINS O=n114 A1=n41 B1=n42 B2=n40
XU91 ND2S $PINS O=n3 I1=n112 I2=n22
XU92 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU93 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU94 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU95 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU96 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU97 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU98 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU99 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU100 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU101 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU102 OR2S $PINS O=n116 I1=B[11] I2=A[11]
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU107 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU108 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU109 NR2 $PINS O=n35 I1=n40 I2=n37
XU110 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU111 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU112 INV1S $PINS O=n28 I=n30
XU113 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU114 INV1S $PINS O=n20 I=n22
XU115 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU116 ND2 $PINS O=n10 I1=n111 I2=n50
XU117 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU118 INV1S $PINS O=n64 I=n44
XU119 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU120 INV1S $PINS O=n63 I=n40
XU121 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU122 ND2 $PINS O=n2 I1=n57 I2=n17
XU123 INV1S $PINS O=n57 I=n16
XU124 ND2 $PINS O=n7 I1=n62 I2=n38
XU125 INV1S $PINS O=n62 I=n37
XU126 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU127 AOI12H $PINS O=n46 A1=n48 B1=n111 B2=n51
XU128 INV1S $PINS O=n48 I=n50
XU129 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU130 ND2 $PINS O=n11 I1=n66 I2=n53
XU131 INV1S $PINS O=n66 I=n52
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 ND2 $PINS O=n6 I1=n61 I2=n33
XU134 INV1S $PINS O=n61 I=n32
XU135 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU136 ND2 $PINS O=n4 I1=n59 I2=n25
XU137 INV1S $PINS O=n59 I=n24
XU138 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU139 ND2 $PINS O=n5 I1=n110 I2=n30
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU142 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU143 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU144 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU145 NR2P $PINS O=n16 I1=B[10] I2=A[10]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n1 I1=n116 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_267 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU83 OR2 $PINS O=n110 I1=B[9] I2=A[9]
XU84 OR2 $PINS O=n111 I1=B[7] I2=A[7]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2S $PINS O=n8 I1=n63 I2=n41
XU88 XOR2HS $PINS O=SUM[5] I1=n7 I2=n114
XU89 OA12S $PINS O=n114 A1=n41 B1=n42 B2=n40
XU90 ND2S $PINS O=n3 I1=n110 I2=n22
XU91 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU92 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU93 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU94 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU95 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU96 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU97 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU98 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU99 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU100 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU101 OR2S $PINS O=n116 I1=B[11] I2=A[11]
XU102 INV1S $PINS O=n42 I=n43
XU103 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU104 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU105 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU106 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU107 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU108 NR2 $PINS O=n35 I1=n40 I2=n37
XU109 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU110 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU111 INV1S $PINS O=n28 I=n30
XU112 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n110
XU113 INV1S $PINS O=n20 I=n22
XU114 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU115 ND2 $PINS O=n10 I1=n112 I2=n50
XU116 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU117 ND2 $PINS O=n9 I1=n64 I2=n45
XU118 INV1S $PINS O=n64 I=n44
XU119 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU120 INV1S $PINS O=n63 I=n40
XU121 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU122 ND2 $PINS O=n2 I1=n57 I2=n17
XU123 INV1S $PINS O=n57 I=n16
XU124 ND2 $PINS O=n7 I1=n62 I2=n38
XU125 INV1S $PINS O=n62 I=n37
XU126 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU127 AOI12HS $PINS O=n46 A1=n48 B1=n112 B2=n51
XU128 INV1S $PINS O=n48 I=n50
XU129 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU130 ND2 $PINS O=n11 I1=n66 I2=n53
XU131 INV1S $PINS O=n66 I=n52
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 ND2 $PINS O=n6 I1=n61 I2=n33
XU134 INV1S $PINS O=n61 I=n32
XU135 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU136 ND2 $PINS O=n4 I1=n59 I2=n25
XU137 INV1S $PINS O=n59 I=n24
XU138 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU139 ND2 $PINS O=n5 I1=n111 I2=n30
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU142 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU143 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU144 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU145 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 ND2 $PINS O=n1 I1=n116 I2=n14
XU151 OAI12H $PINS O=n15 A1=n17 B1=n18 B2=n16
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_268 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_219_0 OAI12H $PINS O=n51 A1=n53 B1=n55 B2=n52
XFE_OFC3008_n45 INV1S $PINS O=n64 I=n45
XFE_OFC3007_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2865_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2750_n38 INV1S $PINS O=n36 I=n38
XFE_OFC2523_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU92 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU93 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2 $PINS O=n38 I1=B[5] I2=A[5]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU108 INV1S $PINS O=n65 I=n48
XU109 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU110 ND2 $PINS O=n8 I1=n63 I2=n41
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU117 INV1S $PINS O=n59 I=n24
XU118 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU119 ND2 $PINS O=n2 I1=n57 I2=n17
XU120 INV1S $PINS O=n57 I=n16
XU121 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU122 ND2 $PINS O=n7 I1=n110 I2=n38
XU123 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU124 ND2 $PINS O=n5 I1=n112 I2=n30
XU125 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU126 ND2 $PINS O=n3 I1=n111 I2=n22
XU128 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU129 NR2 $PINS O=n43 I1=n45 I2=n48
XU130 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU131 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU133 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU134 INV1S $PINS O=n28 I=n30
XU135 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n111
XU136 INV1S $PINS O=n20 I=n22
XU137 ND2 $PINS O=n9 I1=n64 I2=n46
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_269 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2730_n51 INV2 $PINS O=n50 I=n51
XFE_OFC2712_n48 INV1S $PINS O=n65 I=n48
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 AN2 $PINS O=SUM[0] I1=n115 I2=n55
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 OR2S $PINS O=n115 I1=A[0] I2=B[0]
XU90 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU91 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU92 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU96 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 ND2 $PINS O=n11 I1=n66 I2=n53
XU100 INV1S $PINS O=n66 I=n52
XU101 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU105 ND2 $PINS O=n2 I1=n57 I2=n17
XU106 INV1S $PINS O=n57 I=n16
XU107 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU108 ND2 $PINS O=n10 I1=n65 I2=n49
XU110 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU111 ND2 $PINS O=n6 I1=n61 I2=n33
XU112 INV1S $PINS O=n61 I=n32
XU113 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU114 ND2 $PINS O=n8 I1=n63 I2=n41
XU115 INV1S $PINS O=n63 I=n40
XU116 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU117 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 INV1S $PINS O=n59 I=n24
XU119 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU120 ND2 $PINS O=n7 I1=n110 I2=n38
XU121 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU122 ND2 $PINS O=n5 I1=n112 I2=n30
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n111 I2=n22
XU125 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU126 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU127 NR2 $PINS O=n43 I1=n45 I2=n48
XU128 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU129 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n110
XU130 INV1S $PINS O=n36 I=n38
XU131 AOI12HS $PINS O=n26 A1=n28 B1=n31 B2=n112
XU132 INV1S $PINS O=n28 I=n30
XU133 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU134 INV1S $PINS O=n20 I=n22
XU135 ND2 $PINS O=n9 I1=n64 I2=n46
XU136 INV1S $PINS O=n64 I=n45
XU137 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU140 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU141 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU142 ND2 $PINS O=n1 I1=n116 I2=n14
XU143 OAI12H $PINS O=n15 A1=n17 B1=n18 B2=n16
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n116 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_270 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2943_n30 INV1S $PINS O=n28 I=n30
XFE_OFC2908_n16 INV1S $PINS O=n57 I=n16
XFE_OFC2900_n24 INV1S $PINS O=n59 I=n24
XFE_OFC2724_n43 INV1S $PINS O=n42 I=n43
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 AN2 $PINS O=SUM[0] I1=n114 I2=n55
XU86 ND2S $PINS O=n3 I1=n111 I2=n22
XU87 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU88 ND2 $PINS O=n17 I1=A[10] I2=B[10]
XU89 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU90 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU93 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n114 I1=B[0] I2=A[0]
XU97 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU103 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU104 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU105 ND2 $PINS O=n7 I1=n62 I2=n38
XU106 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU107 ND2 $PINS O=n6 I1=n61 I2=n33
XU108 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU109 ND2 $PINS O=n5 I1=n110 I2=n30
XU110 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU111 ND2 $PINS O=n4 I1=n59 I2=n25
XU112 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU113 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU114 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU115 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU116 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU117 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU118 NR2 $PINS O=n35 I1=n40 I2=n37
XU119 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU120 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU122 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU123 INV1S $PINS O=n20 I=n22
XU124 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU125 INV1S $PINS O=n48 I=n50
XU126 INV1S $PINS O=n47 I=n49
XU127 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU128 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU129 ND2 $PINS O=n2 I1=n57 I2=n17
XU131 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU132 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU133 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU134 INV1S $PINS O=n62 I=n37
XU136 INV1S $PINS O=n66 I=n52
XU137 INV1S $PINS O=n61 I=n32
XU138 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU139 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU140 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU144 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU149 OAI12H $PINS O=n15 A1=n17 B1=n18 B2=n16
XU150 ND2 $PINS O=n1 I1=n113 I2=n14
XU151 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_271 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_199_0 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XFE_OFC2557_n43 INV2 $PINS O=n42 I=n43
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[2] I2=A[2]
XU85 OR2 $PINS O=n112 I1=B[9] I2=A[9]
XU86 ND2 $PINS O=n1 I1=n114 I2=n115
XU87 ND2S $PINS O=n115 I1=A[11] I2=B[11]
XU88 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU89 ND2S $PINS O=n8 I1=n63 I2=n41
XU90 ND2S $PINS O=n3 I1=n112 I2=n22
XU91 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU92 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU93 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU94 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU95 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU96 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU97 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU98 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU99 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU100 OR2S $PINS O=n116 I1=B[0] I2=A[0]
XU101 OR2S $PINS O=n114 I1=B[11] I2=A[11]
XU103 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU104 ND2 $PINS O=n11 I1=n66 I2=n53
XU105 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU106 ND2 $PINS O=n9 I1=n64 I2=n45
XU107 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU108 ND2 $PINS O=n10 I1=n111 I2=n50
XU109 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU110 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU111 ND2 $PINS O=n7 I1=n62 I2=n38
XU112 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU113 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU114 ND2 $PINS O=n2 I1=n57 I2=n17
XU115 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU116 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU117 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU118 ND2 $PINS O=n4 I1=n59 I2=n25
XU120 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU121 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU122 OAI12HP $PINS O=n43 A1=n45 B1=n46 B2=n44
XU123 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU124 NR2 $PINS O=n35 I1=n40 I2=n37
XU125 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU126 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n112
XU127 INV1S $PINS O=n20 I=n22
XU128 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU129 INV1S $PINS O=n28 I=n30
XU130 AOI12H $PINS O=n46 A1=n48 B1=n111 B2=n51
XU131 INV1S $PINS O=n48 I=n50
XU132 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU133 INV1S $PINS O=n64 I=n44
XU134 INV1S $PINS O=n57 I=n16
XU135 INV1S $PINS O=n59 I=n24
XU136 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU137 ND2 $PINS O=n6 I1=n61 I2=n33
XU138 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU139 ND2 $PINS O=n5 I1=n110 I2=n30
XU140 INV1S $PINS O=n63 I=n40
XU141 INV1S $PINS O=n62 I=n37
XU142 INV1S $PINS O=n61 I=n32
XU143 INV1S $PINS O=n66 I=n52
XU144 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU145 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU146 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU147 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU148 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU149 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU150 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU151 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU152 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_272 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_217_0 OAI12HP $PINS O=n44 A1=n46 B1=n47 B2=n45
XU84 OR2 $PINS O=n111 I1=A[4] I2=B[4]
XU85 OR2 $PINS O=n112 I1=A[2] I2=B[2]
XU86 OR2 $PINS O=n113 I1=A[8] I2=B[8]
XU87 OR2 $PINS O=n114 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 AN2 $PINS O=SUM[0] I1=n118 I2=n56
XU90 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU91 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU92 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU96 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU97 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU98 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU99 OR2S $PINS O=n118 I1=A[0] I2=B[0]
XU100 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU102 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU103 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU104 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU105 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU106 ND2 $PINS O=n9 I1=n65 I2=n46
XU107 INV1S $PINS O=n65 I=n45
XU108 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU109 ND2 $PINS O=n7 I1=n63 I2=n38
XU110 INV1S $PINS O=n63 I=n37
XU111 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU112 ND2 $PINS O=n5 I1=n61 I2=n30
XU113 INV1S $PINS O=n61 I=n29
XU114 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU115 ND2 $PINS O=n3 I1=n59 I2=n22
XU116 INV1S $PINS O=n59 I=n21
XU117 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU118 ND2 $PINS O=n10 I1=n112 I2=n51
XU119 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU120 ND2 $PINS O=n8 I1=n111 I2=n43
XU121 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU122 ND2 $PINS O=n6 I1=n114 I2=n35
XU123 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU124 ND2 $PINS O=n2 I1=n115 I2=n19
XU125 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU126 ND2 $PINS O=n4 I1=n113 I2=n27
XU127 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n112
XU128 INV1S $PINS O=n49 I=n51
XU129 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n111
XU130 INV1S $PINS O=n41 I=n43
XU131 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n114
XU132 INV1S $PINS O=n33 I=n35
XU133 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n113
XU134 INV1S $PINS O=n25 I=n27
XU135 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU136 ND2 $PINS O=n11 I1=n67 I2=n54
XU137 INV1S $PINS O=n67 I=n53
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU145 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_273 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC3062_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2787_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[7] I2=B[7]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12S $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU90 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU91 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU92 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU95 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU99 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU100 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU101 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU102 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU103 ND2 $PINS O=n2 I1=n57 I2=n17
XU104 INV1S $PINS O=n57 I=n16
XU105 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU106 ND2 $PINS O=n10 I1=n65 I2=n49
XU107 INV1S $PINS O=n65 I=n48
XU108 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU109 ND2 $PINS O=n6 I1=n61 I2=n33
XU110 INV1S $PINS O=n61 I=n32
XU111 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU112 ND2 $PINS O=n8 I1=n63 I2=n41
XU113 INV1S $PINS O=n63 I=n40
XU114 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU115 ND2 $PINS O=n4 I1=n59 I2=n25
XU116 INV1S $PINS O=n59 I=n24
XU117 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU118 ND2 $PINS O=n9 I1=n64 I2=n46
XU119 INV1S $PINS O=n64 I=n45
XU120 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU121 ND2 $PINS O=n7 I1=n110 I2=n38
XU122 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU123 ND2 $PINS O=n5 I1=n111 I2=n30
XU124 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU125 ND2 $PINS O=n3 I1=n112 I2=n22
XU126 AOI12HS $PINS O=n42 A1=n44 B1=n43 B2=n51
XU127 NR2 $PINS O=n43 I1=n45 I2=n48
XU128 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU129 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU130 INV1S $PINS O=n36 I=n38
XU131 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU132 INV1S $PINS O=n28 I=n30
XU133 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU134 INV1S $PINS O=n20 I=n22
XU135 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU136 ND2 $PINS O=n11 I1=n66 I2=n53
XU138 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU141 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU142 ND2 $PINS O=n1 I1=n117 I2=n14
XU143 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU144 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU145 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU146 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU147 ND2 $PINS O=n33 I1=B[6] I2=A[6]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_274 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU83 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU84 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU85 XOR2HS $PINS O=SUM[11] I1=n1 I2=n111
XU86 OA12 $PINS O=n111 A1=n17 B1=n18 B2=n16
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU92 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU93 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU94 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU95 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU96 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU97 OR2 $PINS O=n113 I1=B[11] I2=A[11]
XU98 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU99 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU100 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU101 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU102 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU103 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU104 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU105 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU106 INV1S $PINS O=n42 I=n43
XU107 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU108 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU109 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU110 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU111 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU112 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU115 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU116 INV1S $PINS O=n28 I=n30
XU117 INV1S $PINS O=n27 I=n29
XU118 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU119 INV1S $PINS O=n20 I=n22
XU120 INV1S $PINS O=n19 I=n21
XU121 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU122 INV1S $PINS O=n48 I=n50
XU123 INV1S $PINS O=n47 I=n49
XU124 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU125 ND2 $PINS O=n2 I1=n57 I2=n17
XU126 INV1S $PINS O=n57 I=n16
XU127 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU128 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU129 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU130 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU131 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU132 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU133 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU134 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU135 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU136 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU142 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU143 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_275 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN186_backward_metrics_1__0__1
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU85 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU86 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU87 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU88 ND2S $PINS O=n53 I1=A[1] I2=FE_OFN186_backward_metrics_1__0__1
XU89 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU90 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU91 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU92 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU93 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU94 ND2 $PINS O=n1 I1=n112 I2=n113
XU95 OR2S $PINS O=n112 I1=B[11] I2=A[11]
XU96 ND2 $PINS O=n113 I1=A[11] I2=B[11]
XU97 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU98 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU101 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU102 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU103 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU104 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU105 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU106 INV1S $PINS O=n42 I=n43
XU107 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU108 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU109 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU110 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU111 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU112 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU113 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU114 NR2 $PINS O=n35 I1=n40 I2=n37
XU115 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU116 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU117 INV1S $PINS O=n20 I=n22
XU118 INV1S $PINS O=n19 I=n21
XU119 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU120 INV1S $PINS O=n28 I=n30
XU121 INV1S $PINS O=n27 I=n29
XU122 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU123 INV1S $PINS O=n48 I=n50
XU124 INV1S $PINS O=n47 I=n49
XU125 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU126 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU127 OR2B1S $PINS O=n2 I1=n16 B1=n17
XU128 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU129 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU130 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU131 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU132 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU133 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU134 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU135 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU136 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=FE_OFN186_backward_metrics_1__0__1 I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_276 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN153_branch_metrics_1__2__11
+ FE_OFN154_branch_metrics_1__2__6
XFE_RC_255_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n112
XFE_RC_175_0 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XFE_OFC2888_n51 INV1S $PINS O=n49 I=n51
XU84 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU85 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU86 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU87 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU88 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU89 OR2 $PINS O=n113 I1=A[6] I2=FE_OFN154_branch_metrics_1__2__6
XU90 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU91 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU92 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU93 OAI12HP $PINS O=n36 A1=n38 B1=n39 B2=n37
XU94 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU95 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU96 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU97 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU98 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU99 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU100 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU101 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU102 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU103 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU105 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU106 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU107 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU108 ND2 $PINS O=n9 I1=n65 I2=n46
XU109 INV1S $PINS O=n65 I=n45
XU110 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU111 ND2 $PINS O=n7 I1=n63 I2=n38
XU112 INV1S $PINS O=n63 I=n37
XU113 ND2 $PINS O=n3 I1=n59 I2=n22
XU114 INV1S $PINS O=n59 I=n21
XU115 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU116 ND2 $PINS O=n5 I1=n61 I2=n30
XU117 INV1S $PINS O=n61 I=n29
XU118 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU119 ND2 $PINS O=n10 I1=n111 I2=n51
XU120 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU121 ND2 $PINS O=n8 I1=n112 I2=n43
XU122 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU123 ND2 $PINS O=n6 I1=n113 I2=n35
XU124 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU125 ND2 $PINS O=n2 I1=n115 I2=n19
XU126 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU127 ND2 $PINS O=n4 I1=n114 I2=n27
XU128 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n111
XU131 INV1S $PINS O=n41 I=n43
XU132 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n113
XU133 INV1S $PINS O=n33 I=n35
XU134 INV1S $PINS O=n25 I=n27
XU135 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU136 ND2 $PINS O=n11 I1=n67 I2=n54
XU137 INV1S $PINS O=n67 I=n53
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=FE_OFN153_branch_metrics_1__2__11 I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_277 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN233_branch_metrics_1__1__3
XFE_RC_259_0 AOI12HP $PINS O=n23 A1=n25 B1=n28 B2=n113
XFE_RC_200_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n112
XFE_RC_170_0 OAI12HT $PINS O=n44 A1=n46 B1=n47 B2=n45
XFE_RC_122_0 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XFE_OFC2779_n43 INV1S $PINS O=n41 I=n43
XFE_OFC2737_n53 INV1S $PINS O=n67 I=n53
XU84 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU85 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU86 OR2 $PINS O=n113 I1=A[8] I2=B[8]
XU87 OR2 $PINS O=n114 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU91 ND2P $PINS O=n56 I1=B[0] I2=A[0]
XU92 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU93 AO12S $PINS O=n117 A1=n17 B1=n20 B2=n115
XU94 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU95 ND2S $PINS O=n46 I1=FE_OFN233_branch_metrics_1__1__3 I2=A[3]
XU96 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 ND2 $PINS O=n43 I1=B[4] I2=A[4]
XU99 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU100 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU101 ND2 $PINS O=n11 I1=n67 I2=n54
XU103 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU105 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU106 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU107 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU108 ND2 $PINS O=n2 I1=n115 I2=n19
XU109 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU110 ND2 $PINS O=n9 I1=n65 I2=n46
XU111 INV1S $PINS O=n65 I=n45
XU112 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU113 ND2 $PINS O=n7 I1=n63 I2=n38
XU114 INV1S $PINS O=n63 I=n37
XU115 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU116 ND2 $PINS O=n5 I1=n61 I2=n30
XU117 INV1S $PINS O=n61 I=n29
XU118 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU119 ND2 $PINS O=n3 I1=n59 I2=n22
XU120 INV1S $PINS O=n59 I=n21
XU121 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU122 ND2 $PINS O=n10 I1=n111 I2=n51
XU123 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU124 ND2 $PINS O=n6 I1=n114 I2=n35
XU125 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU126 ND2 $PINS O=n8 I1=n112 I2=n43
XU127 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU128 ND2 $PINS O=n4 I1=n113 I2=n27
XU129 AOI12HP $PINS O=n47 A1=n49 B1=n52 B2=n111
XU130 INV1S $PINS O=n49 I=n51
XU133 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n114
XU134 INV1S $PINS O=n33 I=n35
XU136 INV1S $PINS O=n25 I=n27
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2 $PINS O=n1 I1=n119 I2=n14
XU141 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU142 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU143 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU146 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU147 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_278 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN212_backward_metrics_5__3__10
+ FE_OFN213_backward_metrics_5__3__5 FE_OFN214_backward_metrics_5__3__4
+ FE_OFN216_backward_metrics_5__3__2
XFE_RC_202_0 OAI12HT $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC3052_n22 INV1S $PINS O=n20 I=n22
XFE_OFC3019_n43 INV1S $PINS O=n42 I=n43
XFE_OFC2795_n21 INV1S $PINS O=n19 I=n21
XU83 OR2 $PINS O=n110 I1=B[2] I2=A[2]
XU84 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU85 ND2S $PINS O=n8 I1=n63 I2=n41
XU86 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU87 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU88 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU91 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU92 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU93 ND2 $PINS O=n22 I1=A[9] I2=B[9]
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU96 XOR2HS $PINS O=SUM[11] I1=n1 I2=n113
XU97 OA12S $PINS O=n113 A1=n17 B1=n18 B2=n16
XU98 OR2S $PINS O=n114 I1=B[11] I2=A[11]
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 ND2 $PINS O=n9 I1=n64 I2=n45
XU102 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU103 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU104 ND2 $PINS O=n10 I1=n110 I2=n50
XU105 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU106 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU107 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU108 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU109 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU110 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU111 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU113 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU114 OAI12HS $PINS O=n43 A1=n45 B1=n46 B2=n44
XU115 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU116 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU117 NR2 $PINS O=n35 I1=n40 I2=n37
XU118 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU119 INV1S $PINS O=n28 I=n30
XU120 INV1S $PINS O=n27 I=n29
XU121 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU124 AOI12H $PINS O=n46 A1=n48 B1=n51 B2=n110
XU125 INV1S $PINS O=n48 I=n50
XU126 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU127 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU128 ND2 $PINS O=n2 I1=n57 I2=n17
XU129 INV1S $PINS O=n57 I=n16
XU130 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU131 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU132 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU133 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU134 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU135 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU136 INV1S $PINS O=n63 I=n40
XU137 INV1S $PINS O=n64 I=n44
XU138 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU139 NR2 $PINS O=n37 I1=FE_OFN213_backward_metrics_5__3__5 I2=A[5]
XU140 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n16 I1=FE_OFN212_backward_metrics_5__3__10 I2=A[10]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=FE_OFN214_backward_metrics_5__3__4
XU149 ND2 $PINS O=n1 I1=n114 I2=n14
XU150 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_279 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN234_backward_metrics_5__1__1
XFE_RC_121_0 AOI12HP $PINS O=n34 A1=n36 B1=n35 B2=n43
XFE_OFC2552_n43 INV2 $PINS O=n42 I=n43
XU83 OR2 $PINS O=n110 I1=B[2] I2=A[2]
XU84 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU85 ND2S $PINS O=n10 I1=n110 I2=n50
XU86 ND2S $PINS O=n2 I1=n57 I2=n17
XU87 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU88 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU89 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU90 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU91 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU92 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU93 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU94 ND2S $PINS O=n53 I1=A[1] I2=FE_OFN234_backward_metrics_5__1__1
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU97 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 ND2 $PINS O=n9 I1=n64 I2=n45
XU102 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU103 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU104 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU105 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU106 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU107 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU108 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU112 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU115 INV1S $PINS O=n28 I=n30
XU116 INV1S $PINS O=n27 I=n29
XU117 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU118 INV1S $PINS O=n20 I=n22
XU119 INV1S $PINS O=n19 I=n21
XU120 AOI12H $PINS O=n46 A1=n48 B1=n51 B2=n110
XU121 INV1S $PINS O=n48 I=n50
XU122 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU123 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU124 INV1S $PINS O=n57 I=n16
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU127 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU128 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU129 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU130 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU131 INV1S $PINS O=n64 I=n44
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU134 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU135 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU136 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU137 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU138 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU139 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU140 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU141 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU142 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU143 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU144 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 OR2 $PINS O=n113 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_280 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_218_0 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XFE_RC_196_0 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n112
XFE_RC_165_0 AOI12HP $PINS O=n31 A1=n33 B1=n36 B2=n113
XFE_OFC2877_n51 INV1S $PINS O=n49 I=n51
XU84 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU85 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU86 OR2 $PINS O=n113 I1=A[6] I2=B[6]
XU87 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU90 OAI12HP $PINS O=n36 A1=n38 B1=n39 B2=n37
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU94 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU98 ND2 $PINS O=n51 I1=B[2] I2=A[2]
XU99 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU100 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU101 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU103 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU104 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU105 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU106 ND2 $PINS O=n9 I1=n65 I2=n46
XU107 INV1S $PINS O=n65 I=n45
XU108 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU109 ND2 $PINS O=n7 I1=n63 I2=n38
XU110 INV1S $PINS O=n63 I=n37
XU111 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU112 ND2 $PINS O=n3 I1=n59 I2=n22
XU113 INV1S $PINS O=n59 I=n21
XU114 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU115 ND2 $PINS O=n5 I1=n61 I2=n30
XU116 INV1S $PINS O=n61 I=n29
XU117 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU118 ND2 $PINS O=n10 I1=n111 I2=n51
XU119 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU120 ND2 $PINS O=n8 I1=n112 I2=n43
XU121 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU122 ND2 $PINS O=n6 I1=n113 I2=n35
XU123 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU124 ND2 $PINS O=n2 I1=n115 I2=n19
XU125 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU126 ND2 $PINS O=n4 I1=n114 I2=n27
XU127 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n111
XU130 INV1S $PINS O=n41 I=n43
XU132 INV1S $PINS O=n33 I=n35
XU133 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU134 INV1S $PINS O=n25 I=n27
XU135 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU136 ND2 $PINS O=n11 I1=n67 I2=n54
XU137 INV1S $PINS O=n67 I=n53
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_281 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_267_0 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n114
XFE_RC_208_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n112
XFE_RC_204_0 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XFE_RC_177_0 AOI12HP $PINS O=n47 A1=n49 B1=n52 B2=n111
XFE_RC_144_0 OAI12HP $PINS O=n44 A1=n46 B1=n47 B2=n45
XFE_RC_126_0 INV1S $PINS O=FE_RN_31_0 I=n7
XFE_RC_124_0 ND2 $PINS O=FE_RN_33_0 I1=n39 I2=FE_RN_31_0
XFE_RC_123_0 OAI12H $PINS O=SUM[5] A1=FE_RN_33_0 B1=n39 B2=FE_RN_31_0
XFE_OFC2794_n43 INV1S $PINS O=n41 I=n43
XFE_OFC2748_n51 INV1S $PINS O=n49 I=n51
XU84 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU85 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU86 OR2 $PINS O=n113 I1=A[8] I2=B[8]
XU87 OR2 $PINS O=n114 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU90 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU96 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU97 ND2 $PINS O=n51 I1=B[2] I2=A[2]
XU98 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU99 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU101 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU103 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU104 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU105 ND2 $PINS O=n9 I1=n65 I2=n46
XU106 INV1S $PINS O=n65 I=n45
XU108 ND2 $PINS O=n7 I1=n63 I2=n38
XU109 INV1S $PINS O=n63 I=n37
XU110 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU111 ND2 $PINS O=n5 I1=n61 I2=n30
XU112 INV1S $PINS O=n61 I=n29
XU113 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU114 ND2 $PINS O=n3 I1=n59 I2=n22
XU115 INV1S $PINS O=n59 I=n21
XU116 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU117 ND2 $PINS O=n10 I1=n111 I2=n51
XU118 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU119 ND2 $PINS O=n6 I1=n114 I2=n35
XU120 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU121 ND2 $PINS O=n8 I1=n112 I2=n43
XU122 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU123 ND2 $PINS O=n4 I1=n113 I2=n27
XU124 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU125 ND2 $PINS O=n2 I1=n115 I2=n19
XU131 INV1S $PINS O=n33 I=n35
XU132 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n113
XU133 INV1S $PINS O=n25 I=n27
XU134 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU135 ND2 $PINS O=n11 I1=n67 I2=n54
XU136 INV1S $PINS O=n67 I=n53
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2 $PINS O=n1 I1=n119 I2=n14
XU141 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU142 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU143 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU146 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU147 ND2 $PINS O=n35 I1=B[6] I2=A[6]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_282 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN206_backward_metrics_4__3__9
+ FE_OFN207_backward_metrics_4__3__4
XFE_RC_260_0 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XFE_RC_234_0 AOI12HP $PINS O=n18 A1=n20 B1=n23 B2=n19
XFE_RC_233_0 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XFE_RC_198_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_RC_176_0 AOI12H $PINS O=n34 A1=n36 B1=n43 B2=n35
XFE_OFC3055_n21 INV1S $PINS O=n19 I=n21
XFE_OFC3054_n29 INV1S $PINS O=n27 I=n29
XFE_OFC3051_n22 INV1S $PINS O=n20 I=n22
XU83 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU84 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU85 XOR2HS $PINS O=SUM[11] I1=n1 I2=n111
XU86 OA12 $PINS O=n111 A1=n17 B1=n18 B2=n16
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU89 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU90 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU91 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU92 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU93 ND2 $PINS O=n22 I1=A[9] I2=FE_OFN206_backward_metrics_4__3__9
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU97 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU98 INV1S $PINS O=n42 I=n43
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU102 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU103 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU104 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU105 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU106 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU107 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU110 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU113 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU114 NR2 $PINS O=n35 I1=n40 I2=n37
XU115 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU116 INV1S $PINS O=n28 I=n30
XU121 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU122 INV1S $PINS O=n48 I=n50
XU123 INV1S $PINS O=n47 I=n49
XU124 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU125 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU126 ND2 $PINS O=n2 I1=n57 I2=n17
XU127 INV1S $PINS O=n57 I=n16
XU128 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU129 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU130 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU131 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU132 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU133 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU134 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU135 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU136 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU137 NR2 $PINS O=n40 I1=FE_OFN207_backward_metrics_4__3__4 I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU142 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU143 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_283 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2930_n30 INV1S $PINS O=n28 I=n30
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2S $PINS O=n2 I1=n57 I2=n17
XU85 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU86 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU87 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU88 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU93 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU94 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU97 INV1S $PINS O=n42 I=n43
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU101 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU102 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU103 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU104 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU105 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU106 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU107 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU108 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU109 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU110 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU111 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU112 NR2 $PINS O=n35 I1=n40 I2=n37
XU113 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU115 INV1S $PINS O=n27 I=n29
XU116 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU117 INV1S $PINS O=n20 I=n22
XU118 INV1S $PINS O=n19 I=n21
XU119 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU120 INV1S $PINS O=n48 I=n50
XU121 INV1S $PINS O=n47 I=n49
XU122 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU123 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU124 INV1S $PINS O=n57 I=n16
XU125 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU126 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU127 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU128 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU129 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU130 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU131 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU134 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU135 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU136 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU137 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU138 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU139 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU140 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU141 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU142 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU148 ND2 $PINS O=n1 I1=n112 I2=n14
XU149 OR2 $PINS O=n112 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_284 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_159_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC3046_n52 INV1S $PINS O=n66 I=n52
XFE_OFC3018_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2547_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[7] I2=B[7]
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU93 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU94 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU95 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU96 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU108 INV1S $PINS O=n65 I=n48
XU109 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU110 ND2 $PINS O=n2 I1=n57 I2=n17
XU111 INV1S $PINS O=n57 I=n16
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU117 INV1S $PINS O=n59 I=n24
XU118 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU119 ND2 $PINS O=n8 I1=n63 I2=n41
XU121 ND2 $PINS O=n9 I1=n64 I2=n46
XU122 INV1S $PINS O=n64 I=n45
XU123 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU124 ND2 $PINS O=n5 I1=n110 I2=n30
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n111 I2=n38
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 ND2 $PINS O=n3 I1=n112 I2=n22
XU129 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU130 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU133 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_285 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_211_0 OAI12H $PINS O=n51 A1=n53 B1=n55 B2=n52
XFE_RC_153_0 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12S $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU99 INV1S $PINS O=n50 I=n51
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 INV1S $PINS O=n66 I=n52
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU108 INV1S $PINS O=n65 I=n48
XU109 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU110 ND2 $PINS O=n2 I1=n57 I2=n17
XU111 INV1S $PINS O=n57 I=n16
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU116 ND2 $PINS O=n8 I1=n63 I2=n41
XU117 INV1S $PINS O=n63 I=n40
XU118 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU119 ND2 $PINS O=n4 I1=n59 I2=n25
XU120 INV1S $PINS O=n59 I=n24
XU121 ND2 $PINS O=n9 I1=n64 I2=n46
XU122 INV1S $PINS O=n64 I=n45
XU123 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU124 ND2 $PINS O=n7 I1=n110 I2=n38
XU125 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n112 I2=n30
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 ND2 $PINS O=n3 I1=n111 I2=n22
XU130 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU133 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_286 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_253_0 AOI12HP $PINS O=n18 A1=n20 B1=n23 B2=n111
XFE_RC_213_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2S $PINS O=n8 I1=n63 I2=n41
XU88 XOR2HS $PINS O=SUM[5] I1=n7 I2=n114
XU89 OA12S $PINS O=n114 A1=n41 B1=n42 B2=n40
XU90 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU91 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU92 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU93 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU94 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU95 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU96 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU97 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU98 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU99 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU100 OR2 $PINS O=n116 I1=B[11] I2=A[11]
XU101 INV1S $PINS O=n42 I=n43
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU104 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU105 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU106 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU107 NR2 $PINS O=n35 I1=n40 I2=n37
XU108 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU109 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU110 INV1S $PINS O=n28 I=n30
XU112 INV1S $PINS O=n20 I=n22
XU113 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU114 ND2 $PINS O=n10 I1=n112 I2=n50
XU115 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU116 ND2 $PINS O=n9 I1=n64 I2=n45
XU117 INV1S $PINS O=n64 I=n44
XU118 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU119 INV1S $PINS O=n63 I=n40
XU120 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU121 ND2 $PINS O=n2 I1=n57 I2=n17
XU122 INV1S $PINS O=n57 I=n16
XU123 ND2 $PINS O=n7 I1=n62 I2=n38
XU124 INV1S $PINS O=n62 I=n37
XU125 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU126 ND2 $PINS O=n3 I1=n111 I2=n22
XU127 AOI12HS $PINS O=n46 A1=n48 B1=n112 B2=n51
XU128 INV1S $PINS O=n48 I=n50
XU129 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU130 ND2 $PINS O=n11 I1=n66 I2=n53
XU131 INV1S $PINS O=n66 I=n52
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 ND2 $PINS O=n6 I1=n61 I2=n33
XU134 INV1S $PINS O=n61 I=n32
XU135 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU136 ND2 $PINS O=n4 I1=n59 I2=n25
XU137 INV1S $PINS O=n59 I=n24
XU138 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU139 ND2 $PINS O=n5 I1=n110 I2=n30
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU142 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU143 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU144 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU145 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 ND2 $PINS O=n1 I1=n116 I2=n14
XU151 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_287 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2535_n43 INV1S $PINS O=n42 I=n43
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2S $PINS O=n9 I1=n64 I2=n45
XU88 ND2S $PINS O=n8 I1=n63 I2=n41
XU89 ND2S $PINS O=n3 I1=n111 I2=n22
XU90 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU91 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU92 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU93 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU94 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU95 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU96 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU97 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU98 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU99 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU100 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU101 OR2S $PINS O=n115 I1=B[11] I2=A[11]
XU103 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU104 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU105 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU106 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU107 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU108 NR2 $PINS O=n35 I1=n40 I2=n37
XU109 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU110 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU111 INV1S $PINS O=n28 I=n30
XU112 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU113 INV1S $PINS O=n20 I=n22
XU114 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU115 ND2 $PINS O=n10 I1=n112 I2=n50
XU116 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU117 INV1S $PINS O=n64 I=n44
XU118 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU119 INV1S $PINS O=n63 I=n40
XU120 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU121 ND2 $PINS O=n2 I1=n57 I2=n17
XU122 INV1S $PINS O=n57 I=n16
XU123 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU124 ND2 $PINS O=n7 I1=n62 I2=n38
XU125 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU126 INV1S $PINS O=n62 I=n37
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 AOI12HS $PINS O=n46 A1=n48 B1=n112 B2=n51
XU129 INV1S $PINS O=n48 I=n50
XU130 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU131 ND2 $PINS O=n11 I1=n66 I2=n53
XU132 INV1S $PINS O=n66 I=n52
XU133 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU134 ND2 $PINS O=n6 I1=n61 I2=n33
XU135 INV1S $PINS O=n61 I=n32
XU136 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU137 ND2 $PINS O=n4 I1=n59 I2=n25
XU138 INV1S $PINS O=n59 I=n24
XU139 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU140 ND2 $PINS O=n5 I1=n110 I2=n30
XU141 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU142 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU143 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU144 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU145 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU146 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU147 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n1 I1=n115 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_288 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN168_branch_metrics_4__2__9
+ FE_OFN169_branch_metrics_4__2__7
XFE_RC_162_0 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XFE_RC_105_0 AOI12HP $PINS O=n34 A1=n36 B1=n39 B2=n110
XFE_OFC3001_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2932_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2519_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=FE_OFN169_branch_metrics_4__2__7
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 ND2 $PINS O=n55 I1=B[0] I2=A[0]
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU108 INV1S $PINS O=n65 I=n48
XU109 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU110 ND2 $PINS O=n8 I1=n63 I2=n41
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU117 INV1S $PINS O=n59 I=n24
XU118 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU119 ND2 $PINS O=n2 I1=n57 I2=n17
XU120 INV1S $PINS O=n57 I=n16
XU121 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU122 ND2 $PINS O=n7 I1=n110 I2=n38
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n111 I2=n22
XU125 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n112 I2=n30
XU127 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU128 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU129 NR2 $PINS O=n43 I1=n45 I2=n48
XU130 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU132 INV1S $PINS O=n36 I=n38
XU133 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU134 INV1S $PINS O=n28 I=n30
XU135 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n111
XU136 INV1S $PINS O=n20 I=n22
XU137 ND2 $PINS O=n9 I1=n64 I2=n46
XU138 INV1S $PINS O=n64 I=n45
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=FE_OFN168_branch_metrics_4__2__9 I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_289 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN167_branch_metrics_4__1__7
XFE_RC_227_0 INV2CK $PINS O=n51 I=FE_RN_60_0
XFE_RC_226_0 OA12 $PINS O=FE_RN_60_0 A1=n53 B1=n55 B2=n52
XFE_OFC3010_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2999_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2556_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=FE_OFN167_branch_metrics_4__1__7
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12S $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU90 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU91 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU92 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU96 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 ND2 $PINS O=n11 I1=n66 I2=n53
XU101 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU105 ND2 $PINS O=n2 I1=n57 I2=n17
XU106 INV1S $PINS O=n57 I=n16
XU107 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU108 ND2 $PINS O=n10 I1=n65 I2=n49
XU109 INV1S $PINS O=n65 I=n48
XU110 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU111 ND2 $PINS O=n6 I1=n61 I2=n33
XU112 INV1S $PINS O=n61 I=n32
XU113 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU114 ND2 $PINS O=n8 I1=n63 I2=n41
XU116 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU117 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 INV1S $PINS O=n59 I=n24
XU119 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU120 ND2 $PINS O=n7 I1=n110 I2=n38
XU121 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU122 ND2 $PINS O=n5 I1=n112 I2=n30
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n111 I2=n22
XU126 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU127 NR2 $PINS O=n43 I1=n45 I2=n48
XU128 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU129 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU130 INV1S $PINS O=n36 I=n38
XU131 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU132 INV1S $PINS O=n28 I=n30
XU133 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU134 INV1S $PINS O=n20 I=n22
XU135 ND2 $PINS O=n9 I1=n64 I2=n46
XU136 INV1S $PINS O=n64 I=n45
XU137 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU140 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU141 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU142 ND2 $PINS O=n1 I1=n116 I2=n14
XU143 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n116 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_290 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU83 OR2 $PINS O=n110 I1=B[9] I2=A[9]
XU84 OR2 $PINS O=n111 I1=B[7] I2=A[7]
XU85 AN2 $PINS O=SUM[0] I1=n114 I2=n55
XU86 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU89 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU90 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU91 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU92 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU93 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU94 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU95 OR2S $PINS O=n114 I1=B[0] I2=A[0]
XU96 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU97 INV1S $PINS O=n42 I=n43
XU98 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 ND2 $PINS O=n11 I1=n66 I2=n53
XU101 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU102 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU103 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU104 ND2 $PINS O=n7 I1=n62 I2=n38
XU105 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU106 ND2 $PINS O=n6 I1=n61 I2=n33
XU107 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU108 ND2 $PINS O=n4 I1=n59 I2=n25
XU109 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU110 ND2 $PINS O=n5 I1=n111 I2=n30
XU111 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU112 ND2 $PINS O=n3 I1=n110 I2=n22
XU113 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU114 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU115 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU116 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU117 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU118 NR2 $PINS O=n35 I1=n40 I2=n37
XU119 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU120 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU121 INV1S $PINS O=n28 I=n30
XU122 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n110
XU123 INV1S $PINS O=n20 I=n22
XU124 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU125 INV1S $PINS O=n48 I=n50
XU126 INV1S $PINS O=n47 I=n49
XU127 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU128 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU129 ND2 $PINS O=n2 I1=n57 I2=n17
XU130 INV1S $PINS O=n57 I=n16
XU131 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU132 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU133 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU134 INV1S $PINS O=n59 I=n24
XU135 INV1S $PINS O=n62 I=n37
XU136 INV1S $PINS O=n61 I=n32
XU137 INV1S $PINS O=n66 I=n52
XU138 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU139 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU140 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU144 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU149 ND2 $PINS O=n1 I1=n113 I2=n14
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_291 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN237_backward_metrics_2__1__0
XFE_RC_257_0 AOI12HP $PINS O=n34 A1=n36 B1=n43 B2=n35
XFE_OFC3058_n22 INV1S $PINS O=n20 I=n22
XFE_OFC3038_n24 INV1S $PINS O=n59 I=n24
XFE_OFC2540_n43 INV1S $PINS O=n42 I=n43
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 AN2 $PINS O=SUM[0] I1=n114 I2=n55
XU86 ND2S $PINS O=n3 I1=n111 I2=n22
XU87 ND2S $PINS O=n8 I1=n63 I2=n41
XU88 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU91 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU92 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU93 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU94 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU95 ND2 $PINS O=n22 I1=A[9] I2=B[9]
XU96 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU97 OR2S $PINS O=n114 I1=FE_OFN237_backward_metrics_2__1__0 I2=A[0]
XU98 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU103 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU104 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU105 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU106 ND2 $PINS O=n5 I1=n110 I2=n30
XU107 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU108 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU109 ND2 $PINS O=n4 I1=n59 I2=n25
XU110 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU111 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU112 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU113 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU115 NR2 $PINS O=n35 I1=n40 I2=n37
XU116 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU117 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU118 INV1S $PINS O=n28 I=n30
XU119 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU121 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU122 INV1S $PINS O=n48 I=n50
XU123 INV1S $PINS O=n47 I=n49
XU124 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n62 I2=n38
XU127 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU128 ND2 $PINS O=n2 I1=n57 I2=n17
XU129 INV1S $PINS O=n57 I=n16
XU130 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU131 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 ND2 $PINS O=n6 I1=n61 I2=n33
XU134 INV1S $PINS O=n63 I=n40
XU135 INV1S $PINS O=n62 I=n37
XU136 INV1S $PINS O=n61 I=n32
XU138 INV1S $PINS O=n66 I=n52
XU139 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU140 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU141 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU142 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU143 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU144 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU145 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n1 I1=n113 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_292 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN173_branch_metrics_5__2__8
XFE_OFC2929_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2562_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[7] I2=B[7]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU90 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU91 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU92 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU93 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU94 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU95 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU96 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU107 ND2 $PINS O=n2 I1=n57 I2=n17
XU108 INV1S $PINS O=n57 I=n16
XU109 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU110 ND2 $PINS O=n10 I1=n65 I2=n49
XU111 INV1S $PINS O=n65 I=n48
XU112 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU113 ND2 $PINS O=n8 I1=n63 I2=n41
XU114 INV1S $PINS O=n63 I=n40
XU115 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU116 ND2 $PINS O=n6 I1=n61 I2=n33
XU117 INV1S $PINS O=n61 I=n32
XU118 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU119 ND2 $PINS O=n4 I1=n59 I2=n25
XU120 INV1S $PINS O=n59 I=n24
XU121 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU122 ND2 $PINS O=n9 I1=n64 I2=n46
XU123 INV1S $PINS O=n64 I=n45
XU124 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU125 ND2 $PINS O=n7 I1=n110 I2=n38
XU126 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU127 ND2 $PINS O=n3 I1=n112 I2=n22
XU128 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU129 ND2 $PINS O=n5 I1=n111 I2=n30
XU130 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU133 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=FE_OFN173_branch_metrics_5__2__8 I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_293 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_248_0 INV3 $PINS O=n52 I=FE_RN_65_0
XFE_RC_247_0 OA12 $PINS O=FE_RN_65_0 A1=n54 B1=n56 B2=n53
XFE_RC_228_0 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n113
XFE_RC_169_0 INV1S $PINS O=FE_RN_50_0 I=n7
XFE_RC_167_0 ND2 $PINS O=FE_RN_52_0 I1=n39 I2=FE_RN_50_0
XFE_RC_166_0 OAI12H $PINS O=SUM[5] A1=FE_RN_52_0 B1=n39 B2=FE_RN_50_0
XFE_RC_116_0 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XFE_RC_94_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n112
XFE_OFC2762_n37 INV1S $PINS O=n63 I=n37
XFE_OFC2756_n43 INV1S $PINS O=n41 I=n43
XFE_OFC2723_n51 INV1S $PINS O=n49 I=n51
XU84 OR2 $PINS O=n111 I1=A[6] I2=B[6]
XU85 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU86 OR2 $PINS O=n113 I1=A[2] I2=B[2]
XU87 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU90 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU91 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU92 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU93 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU94 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU97 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU98 ND2 $PINS O=n43 I1=B[4] I2=A[4]
XU99 ND2 $PINS O=n51 I1=B[2] I2=A[2]
XU100 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU102 OAI12HP $PINS O=n44 A1=n46 B1=n47 B2=n45
XU103 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XU105 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU106 ND2 $PINS O=n2 I1=n115 I2=n19
XU107 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU108 ND2 $PINS O=n9 I1=n65 I2=n46
XU109 INV1S $PINS O=n65 I=n45
XU111 ND2 $PINS O=n7 I1=n63 I2=n38
XU113 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU114 ND2 $PINS O=n5 I1=n61 I2=n30
XU115 INV1S $PINS O=n61 I=n29
XU116 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU117 ND2 $PINS O=n3 I1=n59 I2=n22
XU118 INV1S $PINS O=n59 I=n21
XU119 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU120 ND2 $PINS O=n10 I1=n113 I2=n51
XU121 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU122 ND2 $PINS O=n6 I1=n111 I2=n35
XU123 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU124 ND2 $PINS O=n8 I1=n112 I2=n43
XU125 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU126 ND2 $PINS O=n4 I1=n114 I2=n27
XU131 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n111
XU132 INV1S $PINS O=n33 I=n35
XU133 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU134 INV1S $PINS O=n25 I=n27
XU135 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU136 ND2 $PINS O=n11 I1=n67 I2=n54
XU137 INV1S $PINS O=n67 I=n53
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU145 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_294 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN190_backward_metrics_1__3__9
XU83 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU84 OA12S $PINS O=n111 A1=n17 B1=n18 B2=n16
XU85 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU86 XOR2HS $PINS O=SUM[11] I1=n1 I2=n111
XU87 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU88 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU89 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU90 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU91 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU92 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU93 ND2S $PINS O=n22 I1=A[9] I2=FE_OFN190_backward_metrics_1__3__9
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU97 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU98 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU99 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU102 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU105 INV1S $PINS O=n42 I=n43
XU106 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU107 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU108 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12HS $PINS O=n43 A1=n45 B1=n46 B2=n44
XU111 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU112 NR2 $PINS O=n35 I1=n40 I2=n37
XU113 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU114 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU115 INV1S $PINS O=n28 I=n30
XU116 INV1S $PINS O=n27 I=n29
XU117 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU118 INV1S $PINS O=n20 I=n22
XU119 INV1S $PINS O=n19 I=n21
XU120 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU121 INV1S $PINS O=n48 I=n50
XU122 INV1S $PINS O=n47 I=n49
XU123 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU124 ND2 $PINS O=n2 I1=n57 I2=n17
XU125 INV1S $PINS O=n57 I=n16
XU126 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU127 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU128 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU129 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU130 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU131 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU132 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU133 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU134 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU135 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU136 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU137 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU138 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU139 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU140 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU141 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU142 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_295 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC3025_n21 INV1S $PINS O=n19 I=n21
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU85 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU86 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU87 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU88 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU89 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU90 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU91 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU92 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU93 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU94 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU95 OR2S $PINS O=n112 I1=B[11] I2=A[11]
XU96 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU97 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU98 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU99 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU100 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU101 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU102 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 INV1S $PINS O=n42 I=n43
XU105 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU106 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU107 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU108 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU109 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU110 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU111 NR2 $PINS O=n35 I1=n40 I2=n37
XU112 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU113 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU114 INV1S $PINS O=n20 I=n22
XU116 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU117 INV1S $PINS O=n28 I=n30
XU118 INV1S $PINS O=n27 I=n29
XU119 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU120 INV1S $PINS O=n48 I=n50
XU121 INV1S $PINS O=n47 I=n49
XU122 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU123 ND2 $PINS O=n2 I1=n57 I2=n17
XU124 INV1S $PINS O=n57 I=n16
XU125 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU126 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU127 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU128 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU129 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU130 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU131 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU132 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU133 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU134 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU135 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU136 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU137 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU138 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU139 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU140 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU141 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU142 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 OAI12H $PINS O=n15 A1=n17 B1=n18 B2=n16
XU148 ND2 $PINS O=n1 I1=n112 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_296 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN151_branch_metrics_1__0__0
XFE_RC_185_0 OAI12HP $PINS O=n51 A1=n53 B1=n55 B2=n52
XFE_RC_171_0 AOI12H $PINS O=n42 A1=n44 B1=n51 B2=n43
XFE_OFC3009_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2902_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2887_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2548_n51 INV2 $PINS O=n50 I=n51
XU83 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 OR2 $PINS O=n113 I1=A[9] I2=B[9]
XU87 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU90 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU91 ND2S $PINS O=n55 I1=FE_OFN151_branch_metrics_1__0__0 I2=A[0]
XU92 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU93 ND2P $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU109 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU110 ND2 $PINS O=n6 I1=n61 I2=n33
XU111 INV1S $PINS O=n61 I=n32
XU112 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU113 ND2 $PINS O=n8 I1=n63 I2=n41
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU117 INV1S $PINS O=n59 I=n24
XU118 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU119 ND2 $PINS O=n2 I1=n57 I2=n17
XU120 INV1S $PINS O=n57 I=n16
XU121 ND2 $PINS O=n9 I1=n64 I2=n46
XU122 INV1S $PINS O=n64 I=n45
XU123 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU124 ND2 $PINS O=n7 I1=n111 I2=n38
XU125 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n112 I2=n30
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 ND2 $PINS O=n3 I1=n113 I2=n22
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU133 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n113
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2P $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_297 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN157_branch_metrics_1__3__5
XFE_RC_276_0 AOI12HP $PINS O=n31 A1=n33 B1=n36 B2=n114
XFE_RC_275_0 OAI12H $PINS O=n52 A1=n54 B1=n56 B2=n53
XFE_RC_243_0 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XFE_OFC2879_n51 INV1S $PINS O=n49 I=n51
XU85 AN2 $PINS O=SUM[0] I1=n118 I2=n56
XU86 OR2 $PINS O=n112 I1=A[2] I2=B[2]
XU87 OR2 $PINS O=n113 I1=A[4] I2=B[4]
XU88 OR2 $PINS O=n114 I1=A[6] I2=B[6]
XU89 OR2 $PINS O=n115 I1=A[8] I2=B[8]
XU90 OR2 $PINS O=n116 I1=A[10] I2=B[10]
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n116
XU93 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU94 OR2S $PINS O=n118 I1=A[0] I2=B[0]
XU95 ND2S $PINS O=n38 I1=FE_OFN157_branch_metrics_1__3__5 I2=A[5]
XU96 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU97 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU98 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU99 ND2 $PINS O=n51 I1=B[2] I2=A[2]
XU100 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU102 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU103 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU104 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU105 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU106 ND2 $PINS O=n9 I1=n65 I2=n46
XU107 INV1S $PINS O=n65 I=n45
XU108 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU109 ND2 $PINS O=n7 I1=n63 I2=n38
XU110 INV1S $PINS O=n63 I=n37
XU111 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU112 ND2 $PINS O=n3 I1=n59 I2=n22
XU113 INV1S $PINS O=n59 I=n21
XU114 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU115 ND2 $PINS O=n5 I1=n61 I2=n30
XU116 INV1S $PINS O=n61 I=n29
XU117 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU118 ND2 $PINS O=n10 I1=n112 I2=n51
XU119 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU120 ND2 $PINS O=n8 I1=n113 I2=n43
XU121 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU122 ND2 $PINS O=n6 I1=n114 I2=n35
XU123 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU124 ND2 $PINS O=n2 I1=n116 I2=n19
XU125 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU126 ND2 $PINS O=n4 I1=n115 I2=n27
XU127 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n112
XU129 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n113
XU130 INV1S $PINS O=n41 I=n43
XU132 INV1S $PINS O=n33 I=n35
XU133 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n115
XU134 INV1S $PINS O=n25 I=n27
XU135 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU136 ND2 $PINS O=n11 I1=n67 I2=n54
XU137 INV1S $PINS O=n67 I=n53
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=FE_OFN157_branch_metrics_1__3__5
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_298 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC3004_n43 INV2 $PINS O=n42 I=n43
XU83 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU84 ND2 $PINS O=n1 I1=n111 I2=n112
XU85 OR2 $PINS O=n111 I1=B[11] I2=A[11]
XU86 ND2S $PINS O=n112 I1=A[11] I2=B[11]
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU91 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU92 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU93 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU94 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU95 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU96 OR2S $PINS O=n113 I1=B[0] I2=A[0]
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU101 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU102 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU105 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU106 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU107 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU108 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU109 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU110 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU111 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU112 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU115 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU116 INV1S $PINS O=n28 I=n30
XU117 INV1S $PINS O=n27 I=n29
XU118 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU119 INV1S $PINS O=n20 I=n22
XU120 INV1S $PINS O=n19 I=n21
XU121 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU122 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU123 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU124 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU125 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU126 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU127 OR2B1S $PINS O=n2 I1=n16 B1=n17
XU128 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU129 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU130 INV1S $PINS O=n48 I=n50
XU131 INV1S $PINS O=n47 I=n49
XU132 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU133 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU134 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU135 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU136 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU142 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU143 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_299 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_279_0 NR2 $PINS O=FE_RN_68_0 I1=n55 I2=n52
XFE_RC_278_0 OR2B1 $PINS O=n51 I1=FE_RN_68_0 B1=n53
XFE_OFC2938_n50 INV1S $PINS O=n48 I=n50
XFE_OFC2925_n30 INV1S $PINS O=n28 I=n30
XU83 OR2 $PINS O=n110 I1=B[2] I2=A[2]
XU84 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU85 ND2 $PINS O=n2 I1=n57 I2=n17
XU86 ND2S $PINS O=n1 I1=n113 I2=n14
XU87 ND2S $PINS O=n8 I1=n63 I2=n41
XU88 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU89 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU90 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU91 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU92 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU93 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU94 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU95 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU96 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU97 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU98 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU99 INV1S $PINS O=n42 I=n43
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU102 ND2 $PINS O=n9 I1=n64 I2=n45
XU103 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU104 ND2 $PINS O=n10 I1=n110 I2=n50
XU105 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU106 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU107 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU108 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU109 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU110 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU112 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU113 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU114 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU115 NR2 $PINS O=n35 I1=n40 I2=n37
XU116 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU118 INV1S $PINS O=n27 I=n29
XU119 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU120 INV1S $PINS O=n20 I=n22
XU121 INV1S $PINS O=n19 I=n21
XU122 AOI12H $PINS O=n46 A1=n48 B1=n51 B2=n110
XU124 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU125 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU126 INV1S $PINS O=n57 I=n16
XU127 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU128 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU129 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU130 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU131 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU132 INV1S $PINS O=n63 I=n40
XU133 INV1S $PINS O=n64 I=n44
XU134 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU135 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU136 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU142 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU143 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU144 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU149 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU150 OR2 $PINS O=n113 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_300 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN241_branch_metrics_2__0__1
XFE_OFC3064_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2955_n40 INV1S $PINS O=n63 I=n40
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[7] I2=B[7]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 ND2P $PINS O=n55 I1=B[0] I2=A[0]
XU92 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=FE_OFN241_branch_metrics_2__0__1 I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU99 INV1S $PINS O=n50 I=n51
XU100 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU101 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU102 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU103 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU104 ND2 $PINS O=n10 I1=n65 I2=n49
XU105 INV1S $PINS O=n65 I=n48
XU106 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU107 ND2 $PINS O=n6 I1=n61 I2=n33
XU108 INV1S $PINS O=n61 I=n32
XU109 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU110 ND2 $PINS O=n8 I1=n63 I2=n41
XU112 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU113 ND2 $PINS O=n4 I1=n59 I2=n25
XU114 INV1S $PINS O=n59 I=n24
XU115 ND2 $PINS O=n9 I1=n64 I2=n46
XU116 INV1S $PINS O=n64 I=n45
XU117 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU118 ND2 $PINS O=n7 I1=n110 I2=n38
XU119 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU120 ND2 $PINS O=n5 I1=n111 I2=n30
XU121 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU122 ND2 $PINS O=n3 I1=n112 I2=n22
XU123 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU124 ND2 $PINS O=n2 I1=n57 I2=n17
XU125 INV1S $PINS O=n57 I=n16
XU126 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU127 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU128 NR2 $PINS O=n43 I1=n45 I2=n48
XU129 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU130 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU131 INV1S $PINS O=n36 I=n38
XU132 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU133 INV1S $PINS O=n28 I=n30
XU134 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n112
XU135 INV1S $PINS O=n20 I=n22
XU136 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU137 ND2 $PINS O=n11 I1=n66 I2=n53
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=FE_OFN241_branch_metrics_2__0__1
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_301 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN161_branch_metrics_2__3__7
XFE_RC_265_0 AOI12HP $PINS O=n47 A1=n49 B1=n52 B2=n112
XFE_OFC3050_n53 INV1S $PINS O=n67 I=n53
XFE_OFC3017_n51 INV1S $PINS O=n49 I=n51
XU84 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU85 OR2 $PINS O=n111 I1=A[6] I2=B[6]
XU86 OR2 $PINS O=n112 I1=A[2] I2=B[2]
XU87 OR2 $PINS O=n113 I1=A[4] I2=B[4]
XU88 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU89 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU90 AN2 $PINS O=SUM[0] I1=n118 I2=n56
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n56 I1=B[0] I2=A[0]
XU94 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU98 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU99 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU100 OR2S $PINS O=n118 I1=A[0] I2=B[0]
XU101 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU102 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU103 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU104 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU105 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU106 ND2 $PINS O=n9 I1=n65 I2=n46
XU107 INV1S $PINS O=n65 I=n45
XU108 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU109 ND2 $PINS O=n7 I1=n63 I2=n38
XU110 INV1S $PINS O=n63 I=n37
XU111 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU112 ND2 $PINS O=n3 I1=n59 I2=n22
XU113 INV1S $PINS O=n59 I=n21
XU114 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU115 ND2 $PINS O=n5 I1=n61 I2=n30
XU116 INV1S $PINS O=n61 I=n29
XU117 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU118 ND2 $PINS O=n10 I1=n112 I2=n51
XU119 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU120 ND2 $PINS O=n8 I1=n113 I2=n43
XU121 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU122 ND2 $PINS O=n6 I1=n111 I2=n35
XU123 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU124 ND2 $PINS O=n2 I1=n115 I2=n19
XU125 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU126 ND2 $PINS O=n4 I1=n114 I2=n27
XU129 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n113
XU130 INV1S $PINS O=n41 I=n43
XU131 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n111
XU132 INV1S $PINS O=n33 I=n35
XU133 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU134 INV1S $PINS O=n25 I=n27
XU135 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU136 ND2 $PINS O=n11 I1=n67 I2=n54
XU138 INV1S $PINS O=n17 I=n19
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 NR2 $PINS O=n29 I1=A[7] I2=FE_OFN161_branch_metrics_2__3__7
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_302 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC3039_n50 INV1S $PINS O=n48 I=n50
XFE_OFC3016_n24 INV1S $PINS O=n59 I=n24
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2S $PINS O=n9 I1=n64 I2=n45
XU88 AN2S $PINS O=SUM[0] I1=n113 I2=n55
XU89 ND2S $PINS O=n8 I1=n63 I2=n41
XU90 XOR2HS $PINS O=SUM[5] I1=n7 I2=n115
XU91 OA12S $PINS O=n115 A1=n41 B1=n42 B2=n40
XU92 ND2S $PINS O=n3 I1=n111 I2=n22
XU93 OR2S $PINS O=n116 I1=B[11] I2=A[11]
XU94 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU95 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU96 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU97 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU98 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU99 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU100 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU101 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU102 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU103 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU104 INV1S $PINS O=n42 I=n43
XU105 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU106 ND2 $PINS O=n11 I1=n66 I2=n53
XU107 INV1S $PINS O=n66 I=n52
XU108 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU109 INV1S $PINS O=n64 I=n44
XU110 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU111 ND2 $PINS O=n10 I1=n112 I2=n50
XU112 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU113 INV1S $PINS O=n63 I=n40
XU114 ND2 $PINS O=n7 I1=n62 I2=n38
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU119 ND2 $PINS O=n2 I1=n57 I2=n17
XU120 INV1S $PINS O=n57 I=n16
XU121 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU122 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU123 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU124 ND2 $PINS O=n1 I1=n116 I2=n14
XU125 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU126 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU127 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU128 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU129 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU130 NR2 $PINS O=n35 I1=n40 I2=n37
XU131 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU132 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU133 INV1S $PINS O=n28 I=n30
XU134 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU135 INV1S $PINS O=n20 I=n22
XU136 AOI12HS $PINS O=n46 A1=n48 B1=n112 B2=n51
XU138 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU139 ND2 $PINS O=n6 I1=n61 I2=n33
XU140 INV1S $PINS O=n61 I=n32
XU141 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU142 ND2 $PINS O=n5 I1=n110 I2=n30
XU143 INV1S $PINS O=n62 I=n37
XU144 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU145 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU146 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU147 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU148 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU149 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU150 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU151 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU152 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_303 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN203_backward_metrics_4__2__0
XFE_RC_266_0 AOI12HP $PINS O=n18 A1=n20 B1=n23 B2=n19
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2 $PINS O=n2 I1=n57 I2=n17
XU85 ND2S $PINS O=n1 I1=n112 I2=n14
XU86 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU93 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n111 I1=FE_OFN203_backward_metrics_4__2__0 I2=A[0]
XU97 INV1S $PINS O=n42 I=n43
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU101 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU102 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU103 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU104 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU105 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU106 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU107 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU108 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU109 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU110 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU111 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU112 NR2 $PINS O=n35 I1=n40 I2=n37
XU113 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU114 INV1S $PINS O=n28 I=n30
XU115 INV1S $PINS O=n27 I=n29
XU117 INV1S $PINS O=n20 I=n22
XU118 INV1S $PINS O=n19 I=n21
XU119 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU120 INV1S $PINS O=n48 I=n50
XU121 INV1S $PINS O=n47 I=n49
XU122 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU123 INV1S $PINS O=n57 I=n16
XU124 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU125 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU126 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU127 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU128 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU129 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU130 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU131 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU132 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU133 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU134 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU135 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU136 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU137 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU138 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU139 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU140 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU141 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU142 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU145 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU146 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU147 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU148 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU149 OR2 $PINS O=n112 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_304 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU84 OAI12HS $PINS O=n36 A1=n38 B1=n39 B2=n37
XU85 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU86 OR2 $PINS O=n111 I1=A[6] I2=B[6]
XU87 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU88 OR2 $PINS O=n113 I1=A[2] I2=B[2]
XU89 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU90 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU91 AN2 $PINS O=SUM[0] I1=n118 I2=n56
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2P $PINS O=n56 I1=B[0] I2=A[0]
XU94 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU98 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU99 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU100 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU101 OR2S $PINS O=n118 I1=A[0] I2=B[0]
XU102 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU103 ND2 $PINS O=n11 I1=n67 I2=n54
XU104 INV1S $PINS O=n67 I=n53
XU105 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU106 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU107 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU108 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU109 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU110 ND2 $PINS O=n3 I1=n59 I2=n22
XU111 INV1S $PINS O=n59 I=n21
XU112 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU113 ND2 $PINS O=n7 I1=n63 I2=n38
XU114 INV1S $PINS O=n63 I=n37
XU115 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU116 ND2 $PINS O=n9 I1=n65 I2=n46
XU117 INV1S $PINS O=n65 I=n45
XU118 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU119 ND2 $PINS O=n5 I1=n61 I2=n30
XU120 INV1S $PINS O=n61 I=n29
XU121 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU122 ND2 $PINS O=n10 I1=n113 I2=n51
XU123 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU124 ND2 $PINS O=n6 I1=n111 I2=n35
XU125 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU126 ND2 $PINS O=n8 I1=n112 I2=n43
XU127 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU128 ND2 $PINS O=n4 I1=n114 I2=n27
XU129 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU130 ND2 $PINS O=n2 I1=n115 I2=n19
XU131 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n113
XU132 INV1S $PINS O=n49 I=n51
XU133 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n112
XU134 INV1S $PINS O=n41 I=n43
XU135 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n111
XU136 INV1S $PINS O=n33 I=n35
XU137 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU138 INV1S $PINS O=n25 I=n27
XU139 INV1S $PINS O=n17 I=n19
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2P $PINS O=n53 I1=A[1] I2=B[1]
XU142 ND2 $PINS O=n1 I1=n119 I2=n14
XU143 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU144 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU145 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU146 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_305 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_262_0 AOI12H $PINS O=n42 A1=n44 B1=n51 B2=n43
XFE_OFC2777_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[7] I2=B[7]
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 OA12S $PINS O=n114 A1=n49 B1=n50 B2=n48
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU92 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU99 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU101 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU102 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 INV1S $PINS O=n66 I=n52
XU104 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU105 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU107 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU108 ND2 $PINS O=n10 I1=n65 I2=n49
XU109 INV1S $PINS O=n65 I=n48
XU110 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU111 ND2 $PINS O=n2 I1=n57 I2=n17
XU112 INV1S $PINS O=n57 I=n16
XU113 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU114 ND2 $PINS O=n6 I1=n61 I2=n33
XU115 INV1S $PINS O=n61 I=n32
XU116 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU117 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 INV1S $PINS O=n59 I=n24
XU119 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU120 ND2 $PINS O=n8 I1=n63 I2=n41
XU121 INV1S $PINS O=n63 I=n40
XU122 ND2 $PINS O=n9 I1=n64 I2=n46
XU123 INV1S $PINS O=n64 I=n45
XU124 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU125 ND2 $PINS O=n5 I1=n110 I2=n30
XU126 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU127 ND2 $PINS O=n7 I1=n111 I2=n38
XU128 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU129 ND2 $PINS O=n3 I1=n112 I2=n22
XU130 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU132 NR2 $PINS O=n43 I1=n45 I2=n48
XU133 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU134 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU135 INV1S $PINS O=n36 I=n38
XU136 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU137 INV1S $PINS O=n28 I=n30
XU138 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU139 INV1S $PINS O=n20 I=n22
XU140 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU141 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU142 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU143 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU144 ND2 $PINS O=n1 I1=n117 I2=n14
XU145 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_306 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2910_n30 INV1S $PINS O=n28 I=n30
XFE_OFC2789_n43 INV1S $PINS O=n42 I=n43
XFE_OFC2747_n22 INV1S $PINS O=n20 I=n22
XU83 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU84 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU85 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU86 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU87 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU88 ND2S $PINS O=n8 I1=n63 I2=n41
XU89 ND2S $PINS O=n10 I1=n112 I2=n50
XU90 ND2S $PINS O=n6 I1=n61 I2=n33
XU91 XOR2HS $PINS O=SUM[5] I1=n7 I2=n114
XU92 OA12S $PINS O=n114 A1=n41 B1=n42 B2=n40
XU93 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU94 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU95 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU96 OR2S $PINS O=n117 I1=B[11] I2=A[11]
XU97 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU98 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU99 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU100 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU101 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU102 ND2 $PINS O=n22 I1=A[9] I2=B[9]
XU103 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU104 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU105 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU107 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU108 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU111 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU112 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU116 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU118 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n112
XU119 INV1S $PINS O=n48 I=n50
XU120 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU121 ND2 $PINS O=n9 I1=n64 I2=n45
XU122 INV1S $PINS O=n64 I=n44
XU123 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU124 INV1S $PINS O=n63 I=n40
XU125 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU126 ND2 $PINS O=n4 I1=n59 I2=n25
XU127 INV1S $PINS O=n59 I=n24
XU128 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU129 ND2 $PINS O=n2 I1=n57 I2=n17
XU130 INV1S $PINS O=n57 I=n16
XU131 ND2 $PINS O=n7 I1=n62 I2=n38
XU132 INV1S $PINS O=n62 I=n37
XU133 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU134 ND2 $PINS O=n3 I1=n111 I2=n22
XU135 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU136 ND2 $PINS O=n11 I1=n66 I2=n53
XU137 INV1S $PINS O=n66 I=n52
XU138 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU139 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU140 INV1S $PINS O=n61 I=n32
XU141 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU142 ND2 $PINS O=n5 I1=n110 I2=n30
XU143 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU144 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU145 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU146 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU147 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU148 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU149 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU150 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU151 ND2 $PINS O=n1 I1=n117 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_307 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2926_n19 INV1S $PINS O=n17 I=n19
XU84 OR2 $PINS O=n111 I1=B[10] I2=A[10]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2 $PINS O=n19 I1=A[10] I2=B[10]
XU88 XNR2HS $PINS O=SUM[11] I1=n1 I2=n114
XU89 AO12 $PINS O=n114 A1=n17 B1=n20 B2=n111
XU90 ND2S $PINS O=n5 I1=n61 I2=n30
XU91 ND2S $PINS O=n3 I1=n59 I2=n22
XU92 XOR2HS $PINS O=SUM[8] I1=n4 I2=n115
XU93 OA12S $PINS O=n115 A1=n30 B1=n31 B2=n29
XU94 ND2S $PINS O=n9 I1=n65 I2=n46
XU95 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU96 OR2 $PINS O=n117 I1=B[11] I2=A[11]
XU97 ND2S $PINS O=n42 I1=A[4] I2=B[4]
XU98 ND2S $PINS O=n27 I1=A[8] I2=B[8]
XU99 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU100 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU101 ND2S $PINS O=n39 I1=A[5] I2=B[5]
XU102 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU103 ND2S $PINS O=n34 I1=A[6] I2=B[6]
XU104 ND2S $PINS O=n51 I1=A[2] I2=B[2]
XU105 AN2 $PINS O=SUM[0] I1=n113 I2=n56
XU106 INV1S $PINS O=n43 I=n44
XU107 INV1S $PINS O=n31 I=n32
XU108 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU109 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU110 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU111 OAI12H $PINS O=n32 A1=n34 B1=n35 B2=n33
XU112 AOI12H $PINS O=n35 A1=n37 B1=n36 B2=n44
XU113 NR2 $PINS O=n36 I1=n41 I2=n38
XU114 OAI12HS $PINS O=n37 A1=n39 B1=n38 B2=n42
XU115 AOI12H $PINS O=n23 A1=n25 B1=n24 B2=n32
XU116 OAI12HS $PINS O=n25 A1=n27 B1=n26 B2=n30
XU117 NR2 $PINS O=n24 I1=n29 I2=n26
XU118 XNR2HS $PINS O=SUM[2] I1=n52 I2=n10
XU119 ND2 $PINS O=n10 I1=n112 I2=n51
XU120 XOR2HS $PINS O=SUM[3] I1=n47 I2=n9
XU121 INV1S $PINS O=n65 I=n45
XU122 XOR2HS $PINS O=SUM[4] I1=n8 I2=n43
XU123 ND2 $PINS O=n8 I1=n64 I2=n42
XU124 INV1S $PINS O=n64 I=n41
XU125 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU126 ND2 $PINS O=n2 I1=n111 I2=n19
XU127 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 INV1S $PINS O=n59 I=n21
XU129 ND2 $PINS O=n1 I1=n117 I2=n14
XU131 AOI12HS $PINS O=n47 A1=n49 B1=n112 B2=n52
XU132 INV1S $PINS O=n49 I=n51
XU133 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU134 ND2 $PINS O=n11 I1=n67 I2=n54
XU135 INV1S $PINS O=n67 I=n53
XU136 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU137 INV1S $PINS O=n61 I=n29
XU138 XOR2HS $PINS O=SUM[6] I1=n6 I2=n35
XU139 ND2 $PINS O=n6 I1=n62 I2=n34
XU140 INV1S $PINS O=n62 I=n33
XU141 XNR2HS $PINS O=SUM[5] I1=n7 I2=n40
XU142 ND2 $PINS O=n7 I1=n63 I2=n39
XU143 OAI12HS $PINS O=n40 A1=n42 B1=n43 B2=n41
XU144 INV1S $PINS O=n63 I=n38
XU145 ND2 $PINS O=n4 I1=n60 I2=n27
XU146 INV1S $PINS O=n60 I=n26
XU147 NR2 $PINS O=n41 I1=B[4] I2=A[4]
XU148 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU149 NR2 $PINS O=n38 I1=B[5] I2=A[5]
XU150 NR2P $PINS O=n26 I1=B[8] I2=A[8]
XU151 NR2 $PINS O=n45 I1=B[3] I2=A[3]
XU152 NR2 $PINS O=n33 I1=B[6] I2=A[6]
XU153 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU154 NR2 $PINS O=n53 I1=B[1] I2=A[1]
XU155 ND2 $PINS O=n56 I1=A[0] I2=B[0]
XU156 ND2 $PINS O=n30 I1=A[7] I2=B[7]
.ENDS

.SUBCKT Siso_DW01_add_308 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN164_branch_metrics_4__0__1
+ FE_OFN165_branch_metrics_4__0__0
XFE_OFC2864_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2550_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU90 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU91 ND2S $PINS O=n55 I1=FE_OFN165_branch_metrics_4__0__0 I2=A[0]
XU92 OR2S $PINS O=n116 I1=A[0] I2=FE_OFN165_branch_metrics_4__0__0
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n53 I1=FE_OFN164_branch_metrics_4__0__1 I2=A[1]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU99 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU101 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU105 ND2 $PINS O=n10 I1=n65 I2=n49
XU106 INV1S $PINS O=n65 I=n48
XU107 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU108 ND2 $PINS O=n6 I1=n61 I2=n33
XU109 INV1S $PINS O=n61 I=n32
XU110 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU111 ND2 $PINS O=n8 I1=n63 I2=n41
XU113 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU114 ND2 $PINS O=n4 I1=n59 I2=n25
XU115 INV1S $PINS O=n59 I=n24
XU116 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU117 ND2 $PINS O=n2 I1=n57 I2=n17
XU118 INV1S $PINS O=n57 I=n16
XU119 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU120 ND2 $PINS O=n7 I1=n110 I2=n38
XU121 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU122 ND2 $PINS O=n5 I1=n112 I2=n30
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n111 I2=n22
XU125 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU126 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU127 NR2 $PINS O=n43 I1=n45 I2=n48
XU128 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU129 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU130 INV1S $PINS O=n36 I=n38
XU131 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU132 INV1S $PINS O=n28 I=n30
XU133 AOI12HS $PINS O=n18 A1=n20 B1=n23 B2=n111
XU134 INV1S $PINS O=n20 I=n22
XU135 ND2 $PINS O=n9 I1=n64 I2=n46
XU136 INV1S $PINS O=n64 I=n45
XU137 XOR2H $PINS O=SUM[1] I1=n55 I2=n11
XU138 ND2 $PINS O=n11 I1=n66 I2=n53
XU139 INV1S $PINS O=n66 I=n52
XU140 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU141 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU142 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU143 NR2 $PINS O=n52 I1=A[1] I2=FE_OFN164_branch_metrics_4__0__1
XU144 ND2 $PINS O=n1 I1=n117 I2=n14
XU145 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_309 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN170_branch_metrics_4__3__9
+ FE_OFN171_branch_metrics_4__3__5
XFE_OFC2806_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[7] I2=B[7]
XU84 OR2 $PINS O=n111 I1=A[5] I2=FE_OFN171_branch_metrics_4__3__5
XU85 OR2 $PINS O=n112 I1=A[9] I2=FE_OFN170_branch_metrics_4__3__9
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU90 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU91 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU92 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU93 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU94 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU96 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU97 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU98 ND2S $PINS O=n38 I1=FE_OFN171_branch_metrics_4__3__5 I2=A[5]
XU99 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU101 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU102 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 INV1S $PINS O=n66 I=n52
XU104 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU105 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU107 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU108 ND2 $PINS O=n10 I1=n65 I2=n49
XU109 INV1S $PINS O=n65 I=n48
XU110 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU111 ND2 $PINS O=n8 I1=n63 I2=n41
XU112 INV1S $PINS O=n63 I=n40
XU113 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU114 ND2 $PINS O=n6 I1=n61 I2=n33
XU115 INV1S $PINS O=n61 I=n32
XU116 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU117 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 INV1S $PINS O=n59 I=n24
XU119 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU120 ND2 $PINS O=n2 I1=n57 I2=n17
XU121 INV1S $PINS O=n57 I=n16
XU122 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU123 ND2 $PINS O=n7 I1=n111 I2=n38
XU124 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU125 ND2 $PINS O=n3 I1=n112 I2=n22
XU126 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU127 ND2 $PINS O=n5 I1=n110 I2=n30
XU128 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU129 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU130 NR2 $PINS O=n43 I1=n45 I2=n48
XU131 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU132 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU133 INV1S $PINS O=n36 I=n38
XU134 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU135 INV1S $PINS O=n28 I=n30
XU136 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU137 INV1S $PINS O=n20 I=n22
XU138 ND2 $PINS O=n9 I1=n64 I2=n46
XU139 INV1S $PINS O=n64 I=n45
XU140 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU141 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU142 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU143 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU144 ND2 $PINS O=n1 I1=n117 I2=n14
XU145 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_310 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_258_0 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n111
XFE_RC_254_0 AOI12HP $PINS O=n26 A1=n28 B1=n31 B2=n110
XFE_OFC3011_n24 INV1S $PINS O=n59 I=n24
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[2] I2=A[2]
XU85 OR2 $PINS O=n112 I1=B[9] I2=A[9]
XU86 ND2S $PINS O=n1 I1=n114 I2=n115
XU87 OR2 $PINS O=n114 I1=B[11] I2=A[11]
XU88 ND2S $PINS O=n115 I1=A[11] I2=B[11]
XU89 ND2S $PINS O=n9 I1=n64 I2=n45
XU90 AN2S $PINS O=SUM[0] I1=n116 I2=n55
XU91 ND2S $PINS O=n8 I1=n63 I2=n41
XU92 ND2S $PINS O=n3 I1=n112 I2=n22
XU93 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU94 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU95 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU96 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU97 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU98 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU99 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU100 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU101 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU102 OR2S $PINS O=n116 I1=B[0] I2=A[0]
XU103 INV1S $PINS O=n42 I=n43
XU104 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU105 ND2 $PINS O=n11 I1=n66 I2=n53
XU106 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU107 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU108 ND2 $PINS O=n10 I1=n111 I2=n50
XU109 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU110 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU111 ND2 $PINS O=n7 I1=n62 I2=n38
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU115 ND2 $PINS O=n4 I1=n59 I2=n25
XU116 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU117 ND2 $PINS O=n2 I1=n57 I2=n17
XU118 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU119 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU120 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU121 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU122 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU123 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU124 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU125 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU126 NR2 $PINS O=n35 I1=n40 I2=n37
XU127 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU129 INV1S $PINS O=n28 I=n30
XU130 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU131 INV1S $PINS O=n20 I=n22
XU133 INV1S $PINS O=n48 I=n50
XU134 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU135 INV1S $PINS O=n63 I=n40
XU136 INV1S $PINS O=n64 I=n44
XU138 INV1S $PINS O=n57 I=n16
XU139 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU140 ND2 $PINS O=n5 I1=n110 I2=n30
XU141 INV1S $PINS O=n62 I=n37
XU142 INV1S $PINS O=n61 I=n32
XU143 INV1S $PINS O=n66 I=n52
XU144 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU145 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU146 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU147 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU148 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU149 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU150 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU151 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU152 ND2 $PINS O=n41 I1=A[4] I2=B[4]
.ENDS

.SUBCKT Siso_DW01_add_311 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_221_0 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XFE_OFC3023_n24 INV1S $PINS O=n59 I=n24
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 AN2 $PINS O=SUM[0] I1=n114 I2=n55
XU86 ND2S $PINS O=n3 I1=n111 I2=n22
XU87 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU88 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU89 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU90 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU91 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU92 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU93 ND2 $PINS O=n25 I1=A[8] I2=B[8]
XU94 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU95 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU96 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU97 OR2S $PINS O=n114 I1=B[0] I2=A[0]
XU98 INV1S $PINS O=n42 I=n43
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 ND2 $PINS O=n11 I1=n66 I2=n53
XU101 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU102 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU103 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU104 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU105 ND2 $PINS O=n5 I1=n110 I2=n30
XU106 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU107 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU108 ND2 $PINS O=n4 I1=n59 I2=n25
XU110 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XU111 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU112 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU113 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU114 NR2 $PINS O=n35 I1=n40 I2=n37
XU115 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU116 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU117 INV1S $PINS O=n28 I=n30
XU118 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU119 INV1S $PINS O=n20 I=n22
XU120 AOI12H $PINS O=n46 A1=n48 B1=n47 B2=n51
XU121 INV1S $PINS O=n48 I=n50
XU122 INV1S $PINS O=n47 I=n49
XU123 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU124 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU125 ND2 $PINS O=n7 I1=n62 I2=n38
XU126 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU127 ND2 $PINS O=n2 I1=n57 I2=n17
XU128 INV1S $PINS O=n57 I=n16
XU129 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU130 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU131 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU132 ND2 $PINS O=n6 I1=n61 I2=n33
XU133 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU134 INV1S $PINS O=n62 I=n37
XU135 INV1S $PINS O=n61 I=n32
XU137 INV1S $PINS O=n66 I=n52
XU138 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU139 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU140 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU142 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU143 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU144 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU149 ND2 $PINS O=n1 I1=n113 I2=n14
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_312 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2790_n40 INV1S $PINS O=n65 I=n40
XFE_OFC2742_n48 INV1S $PINS O=n67 I=n48
XU85 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU86 AN2 $PINS O=SUM[0] I1=n119 I2=n57
XU87 OR2 $PINS O=n113 I1=A[5] I2=B[5]
XU88 OR2 $PINS O=n114 I1=A[3] I2=B[3]
XU89 OR2 $PINS O=n115 I1=A[1] I2=B[1]
XU90 OR2 $PINS O=n116 I1=A[7] I2=B[7]
XU91 OR2 $PINS O=n117 I1=A[9] I2=B[9]
XU92 XOR2HS $PINS O=SUM[11] I1=n1 I2=n118
XU93 OA12 $PINS O=n118 A1=n17 B1=n18 B2=n16
XU94 ND2 $PINS O=n57 I1=B[0] I2=A[0]
XU95 ND2S $PINS O=n49 I1=B[2] I2=A[2]
XU96 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU97 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU98 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU99 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU100 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU101 OR2S $PINS O=n119 I1=A[0] I2=B[0]
XU102 OAI12H $PINS O=n47 A1=n49 B1=n50 B2=n48
XU103 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU104 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU105 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU106 ND2 $PINS O=n2 I1=n59 I2=n17
XU107 INV1S $PINS O=n59 I=n16
XU108 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU109 ND2 $PINS O=n10 I1=n67 I2=n49
XU111 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU112 ND2 $PINS O=n8 I1=n65 I2=n41
XU114 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU115 ND2 $PINS O=n6 I1=n63 I2=n33
XU116 INV1S $PINS O=n63 I=n32
XU117 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU118 ND2 $PINS O=n4 I1=n61 I2=n25
XU119 INV1S $PINS O=n61 I=n24
XU120 XNR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU121 ND2 $PINS O=n11 I1=n115 I2=n54
XU122 XNR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU123 ND2 $PINS O=n9 I1=n114 I2=n46
XU124 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU125 ND2 $PINS O=n7 I1=n113 I2=n38
XU126 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU127 ND2 $PINS O=n5 I1=n116 I2=n30
XU128 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU129 ND2 $PINS O=n3 I1=n117 I2=n22
XU130 AOI12H $PINS O=n50 A1=n52 B1=n115 B2=n55
XU131 INV1S $PINS O=n52 I=n54
XU132 AOI12H $PINS O=n42 A1=n44 B1=n47 B2=n114
XU133 INV1S $PINS O=n44 I=n46
XU134 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n113
XU135 INV1S $PINS O=n36 I=n38
XU136 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n116
XU137 INV1S $PINS O=n28 I=n30
XU138 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n117
XU139 INV1S $PINS O=n20 I=n22
XU140 INV1S $PINS O=n55 I=n57
XU141 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU142 ND2 $PINS O=n1 I1=n120 I2=n14
XU143 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU144 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU148 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU149 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n120 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_313 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_251_0 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n110
XFE_OFC2758_n51 INV1S $PINS O=n50 I=n51
XFE_OFC2609_branch_metrics_5__3__4 BUF1 $PINS
+ O=FE_OFN5513_branch_metrics_5__3__4 I=B[4]
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[7] I2=B[7]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 AN2 $PINS O=SUM[0] I1=n116 I2=n55
XU87 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU88 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU89 ND2S $PINS O=n55 I1=B[0] I2=A[0]
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU93 ND2S $PINS O=n41 I1=FE_OFN5513_branch_metrics_5__3__4 I2=A[4]
XU94 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 OR2S $PINS O=n116 I1=A[0] I2=B[0]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 INV1S $PINS O=n66 I=n52
XU103 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU107 ND2 $PINS O=n2 I1=n57 I2=n17
XU108 INV1S $PINS O=n57 I=n16
XU109 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU110 ND2 $PINS O=n10 I1=n65 I2=n49
XU111 INV1S $PINS O=n65 I=n48
XU112 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU113 ND2 $PINS O=n8 I1=n63 I2=n41
XU114 INV1S $PINS O=n63 I=n40
XU115 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU116 ND2 $PINS O=n6 I1=n61 I2=n33
XU117 INV1S $PINS O=n61 I=n32
XU118 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU119 ND2 $PINS O=n4 I1=n59 I2=n25
XU120 INV1S $PINS O=n59 I=n24
XU121 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU122 ND2 $PINS O=n9 I1=n64 I2=n46
XU123 INV1S $PINS O=n64 I=n45
XU124 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU125 ND2 $PINS O=n7 I1=n110 I2=n38
XU126 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU127 ND2 $PINS O=n3 I1=n112 I2=n22
XU128 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU129 ND2 $PINS O=n5 I1=n111 I2=n30
XU130 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=FE_OFN5513_branch_metrics_5__3__4
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n1 I1=n117 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU150 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_314 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN188_backward_metrics_1__0__0
XFE_OFC3053_n26 INV1S $PINS O=n24 I=n26
XU84 AN2 $PINS O=SUM[0] I1=n112 I2=n56
XU85 OR2 $PINS O=n113 I1=B[11] I2=A[11]
XU86 ND2P $PINS O=n1 I1=n113 I2=n114
XU87 ND2S $PINS O=n114 I1=A[11] I2=B[11]
XU88 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU89 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU90 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU91 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU92 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU93 ND2S $PINS O=n19 I1=A[10] I2=B[10]
XU94 ND2S $PINS O=n27 I1=A[8] I2=B[8]
XU95 ND2S $PINS O=n35 I1=A[6] I2=B[6]
XU96 ND2S $PINS O=n51 I1=A[2] I2=B[2]
XU97 ND2S $PINS O=n43 I1=A[4] I2=B[4]
XU98 OR2S $PINS O=n112 I1=FE_OFN188_backward_metrics_1__0__0 I2=A[0]
XU99 XNR2HS $PINS O=SUM[2] I1=n52 I2=n10
XU100 XOR2HS $PINS O=SUM[5] I1=n39 I2=n7
XU101 XOR2HS $PINS O=SUM[3] I1=n47 I2=n9
XU102 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU103 XOR2HS $PINS O=SUM[9] I1=n23 I2=n3
XU104 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU105 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU106 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU107 XOR2HS $PINS O=SUM[7] I1=n31 I2=n5
XU108 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU109 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU110 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU111 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU112 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU113 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n56
XU114 AOI12HS $PINS O=n47 A1=n49 B1=n52 B2=n48
XU115 INV1S $PINS O=n49 I=n51
XU116 INV1S $PINS O=n48 I=n50
XU117 AOI12HS $PINS O=n39 A1=n41 B1=n44 B2=n40
XU118 INV1S $PINS O=n41 I=n43
XU119 INV1S $PINS O=n40 I=n42
XU120 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n32
XU121 INV1S $PINS O=n33 I=n35
XU122 INV1S $PINS O=n32 I=n34
XU123 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n24
XU124 INV1S $PINS O=n25 I=n27
XU126 AOI12HS $PINS O=n15 A1=n17 B1=n20 B2=n16
XU127 INV1S $PINS O=n17 I=n19
XU128 INV1S $PINS O=n16 I=n18
XU129 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU130 OR2B1S $PINS O=n2 I1=n18 B1=n19
XU131 XOR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU132 OR2B1S $PINS O=n10 I1=n50 B1=n51
XU133 OR2B1S $PINS O=n11 I1=n53 B1=n54
XU134 OR2B1S $PINS O=n9 I1=n45 B1=n46
XU135 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU136 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU137 OR2B1S $PINS O=n8 I1=n42 B1=n43
XU138 OR2B1S $PINS O=n6 I1=n34 B1=n35
XU139 OR2B1S $PINS O=n4 I1=n26 B1=n27
XU140 NR2 $PINS O=n45 I1=B[3] I2=A[3]
XU141 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU142 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU143 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU144 NR2 $PINS O=n50 I1=B[2] I2=A[2]
XU145 NR2 $PINS O=n42 I1=B[4] I2=A[4]
XU146 NR2 $PINS O=n34 I1=B[6] I2=A[6]
XU147 NR2 $PINS O=n26 I1=B[8] I2=A[8]
XU148 NR2 $PINS O=n18 I1=B[10] I2=A[10]
XU149 NR2 $PINS O=n53 I1=B[1] I2=A[1]
XU150 ND2 $PINS O=n56 I1=A[0] I2=B[0]
.ENDS

.SUBCKT Siso_DW01_add_315 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU85 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU86 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU87 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU88 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU89 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU90 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU91 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU92 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU93 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU94 OR2 $PINS O=n112 I1=B[11] I2=A[11]
XU95 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU96 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU97 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU98 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU99 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU100 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU101 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU102 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU103 INV1S $PINS O=n42 I=n43
XU104 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU105 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU107 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU108 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU109 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU110 NR2 $PINS O=n35 I1=n40 I2=n37
XU111 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU112 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU113 INV1S $PINS O=n20 I=n22
XU114 INV1S $PINS O=n19 I=n21
XU115 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU116 INV1S $PINS O=n28 I=n30
XU117 INV1S $PINS O=n27 I=n29
XU118 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU119 INV1S $PINS O=n48 I=n50
XU120 INV1S $PINS O=n47 I=n49
XU121 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU122 ND2 $PINS O=n2 I1=n57 I2=n17
XU123 INV1S $PINS O=n57 I=n16
XU124 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU125 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU126 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU127 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU128 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU129 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU130 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU131 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU132 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU133 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU134 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU135 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU136 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU137 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU138 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU139 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU140 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU141 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU142 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU143 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU144 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 ND2 $PINS O=n1 I1=n112 I2=n14
XU148 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_316 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN152_branch_metrics_1__0__0
XFE_RC_203_0 AOI12HT $PINS O=n31 A1=n33 B1=n36 B2=n111
XFE_RC_111_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n113
XFE_OFC3005_n51 INV1S $PINS O=n49 I=n51
XFE_OFC2776_n45 INV1S $PINS O=n65 I=n45
XU84 OAI12HP $PINS O=n36 A1=n38 B1=n39 B2=n37
XU85 OR2 $PINS O=n111 I1=A[6] I2=B[6]
XU86 OR2 $PINS O=n112 I1=A[2] I2=B[2]
XU87 OR2 $PINS O=n113 I1=A[4] I2=B[4]
XU88 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU89 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU90 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU95 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU96 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU97 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU98 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU99 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU100 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU101 ND2 $PINS O=n11 I1=n67 I2=n54
XU102 INV1S $PINS O=n67 I=n53
XU103 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU104 OAI12HP $PINS O=n44 A1=n46 B1=n47 B2=n45
XU105 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XU106 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU107 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU108 ND2 $PINS O=n2 I1=n115 I2=n19
XU109 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU110 ND2 $PINS O=n9 I1=n65 I2=n46
XU112 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU113 ND2 $PINS O=n7 I1=n63 I2=n38
XU114 INV1S $PINS O=n63 I=n37
XU115 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU116 ND2 $PINS O=n5 I1=n61 I2=n30
XU117 INV1S $PINS O=n61 I=n29
XU118 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU119 ND2 $PINS O=n3 I1=n59 I2=n22
XU120 INV1S $PINS O=n59 I=n21
XU121 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU122 ND2 $PINS O=n10 I1=n112 I2=n51
XU123 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU124 ND2 $PINS O=n8 I1=n113 I2=n43
XU125 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU126 ND2 $PINS O=n6 I1=n111 I2=n35
XU127 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU128 ND2 $PINS O=n4 I1=n114 I2=n27
XU129 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n112
XU132 INV1S $PINS O=n41 I=n43
XU134 INV1S $PINS O=n33 I=n35
XU135 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU136 INV1S $PINS O=n25 I=n27
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2P $PINS O=n56 I1=FE_OFN152_branch_metrics_1__0__0 I2=A[0]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU145 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_317 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN156_branch_metrics_1__3__11
+ FE_OFN229_branch_metrics_1__3__5
XFE_RC_224_0 AOI12HP $PINS O=n23 A1=n25 B1=n28 B2=n114
XFE_OFC2886_n51 INV1S $PINS O=n49 I=n51
XU84 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU85 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU86 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU87 OR2 $PINS O=n113 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU89 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU90 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU94 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU95 ND2S $PINS O=n38 I1=FE_OFN229_branch_metrics_1__3__5 I2=A[5]
XU96 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU97 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU98 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU99 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU100 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU101 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU102 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU103 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU104 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU105 ND2 $PINS O=n9 I1=n65 I2=n46
XU106 INV1S $PINS O=n65 I=n45
XU107 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU108 ND2 $PINS O=n7 I1=n63 I2=n38
XU109 INV1S $PINS O=n63 I=n37
XU110 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU111 ND2 $PINS O=n3 I1=n59 I2=n22
XU112 INV1S $PINS O=n59 I=n21
XU113 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU114 ND2 $PINS O=n5 I1=n61 I2=n30
XU115 INV1S $PINS O=n61 I=n29
XU116 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU117 ND2 $PINS O=n10 I1=n111 I2=n51
XU118 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU119 ND2 $PINS O=n8 I1=n112 I2=n43
XU120 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU121 ND2 $PINS O=n6 I1=n113 I2=n35
XU122 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU123 ND2 $PINS O=n2 I1=n115 I2=n19
XU124 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU125 ND2 $PINS O=n4 I1=n114 I2=n27
XU126 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n111
XU128 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n112
XU129 INV1S $PINS O=n41 I=n43
XU130 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n113
XU131 INV1S $PINS O=n33 I=n35
XU133 INV1S $PINS O=n25 I=n27
XU134 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU135 ND2 $PINS O=n11 I1=n67 I2=n54
XU136 INV1S $PINS O=n67 I=n53
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2P $PINS O=n56 I1=B[0] I2=A[0]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=FE_OFN156_branch_metrics_1__3__11 I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_318 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN208_backward_metrics_5__1__0
XFE_RC_270_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n111
XFE_RC_269_0 OAI12HT $PINS O=n28 A1=n30 B1=n31 B2=n29
XFE_RC_207_0 AOI12HP $PINS O=n31 A1=n33 B1=n36 B2=n32
XFE_RC_186_0 AOI12HP $PINS O=n23 A1=n25 B1=n28 B2=n24
XFE_OFC3063_n34 INV1S $PINS O=n32 I=n34
XFE_OFC3037_n26 INV1S $PINS O=n24 I=n26
XFE_OFC2944_n43 INV1S $PINS O=n41 I=n43
XFE_OFC2884_n37 INV1S $PINS O=n63 I=n37
XU84 OR2 $PINS O=n111 I1=B[4] I2=A[4]
XU85 OR2 $PINS O=n112 I1=B[10] I2=A[10]
XU86 OR2 $PINS O=n113 I1=B[2] I2=A[2]
XU87 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU88 XNR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU89 AO12 $PINS O=n115 A1=n17 B1=n20 B2=n112
XU90 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU91 ND2S $PINS O=n19 I1=A[10] I2=B[10]
XU92 ND2S $PINS O=n43 I1=A[4] I2=B[4]
XU93 ND2S $PINS O=n51 I1=A[2] I2=B[2]
XU94 ND2S $PINS O=n27 I1=A[8] I2=B[8]
XU95 ND2S $PINS O=n35 I1=A[6] I2=B[6]
XU96 OR2S $PINS O=n117 I1=B[11] I2=A[11]
XU97 ND2 $PINS O=n38 I1=A[5] I2=B[5]
XU98 ND2S $PINS O=n46 I1=A[3] I2=B[3]
XU99 ND2S $PINS O=n54 I1=A[1] I2=B[1]
XU100 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU101 OR2S $PINS O=n116 I1=FE_OFN208_backward_metrics_5__1__0 I2=A[0]
XU102 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU103 XOR2HS $PINS O=SUM[3] I1=n47 I2=n9
XU104 ND2 $PINS O=n9 I1=n65 I2=n46
XU105 XNR2HS $PINS O=SUM[2] I1=n52 I2=n10
XU106 ND2 $PINS O=n10 I1=n113 I2=n51
XU107 XNR2HS $PINS O=SUM[4] I1=n44 I2=n8
XU108 ND2 $PINS O=n8 I1=n111 I2=n43
XU109 XOR2HS $PINS O=SUM[5] I1=n39 I2=n7
XU110 ND2 $PINS O=n7 I1=n63 I2=n38
XU111 XNR2HS $PINS O=SUM[6] I1=n36 I2=n6
XU112 XNR2HS $PINS O=SUM[8] I1=n28 I2=n4
XU113 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU114 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU115 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU116 OAI12HP $PINS O=n36 A1=n38 B1=n39 B2=n37
XU118 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU120 INV1S $PINS O=n33 I=n35
XU123 INV1S $PINS O=n25 I=n27
XU125 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n113
XU126 INV1S $PINS O=n49 I=n51
XU129 XNR2HS $PINS O=SUM[10] I1=n20 I2=n2
XU130 ND2 $PINS O=n2 I1=n112 I2=n19
XU131 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU132 ND2 $PINS O=n1 I1=n117 I2=n14
XU133 INV1S $PINS O=n17 I=n19
XU134 OR2B1S $PINS O=n6 I1=n34 B1=n35
XU135 OR2B1S $PINS O=n4 I1=n26 B1=n27
XU136 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU137 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU138 INV1S $PINS O=n65 I=n45
XU140 OR2B1S $PINS O=n11 I1=n53 B1=n54
XU141 NR2 $PINS O=n45 I1=B[3] I2=A[3]
XU142 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU145 NR2 $PINS O=n34 I1=B[6] I2=A[6]
XU146 NR2 $PINS O=n26 I1=B[8] I2=A[8]
XU147 NR2 $PINS O=n53 I1=B[1] I2=A[1]
XU148 ND2 $PINS O=n56 I1=A[0] I2=B[0]
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_319 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN215_backward_metrics_5__3__3
+ FE_OFN235_backward_metrics_5__3__0
XFE_RC_223_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC3048_n29 INV1S $PINS O=n27 I=n29
XFE_OFC2942_n30 INV1S $PINS O=n28 I=n30
XU83 OR2 $PINS O=n110 I1=B[2] I2=A[2]
XU84 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU85 ND2S $PINS O=n10 I1=n110 I2=n50
XU86 ND2S $PINS O=n2 I1=n57 I2=n17
XU87 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU88 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU93 ND2 $PINS O=n30 I1=A[7] I2=B[7]
XU94 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU95 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU96 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU97 OR2S $PINS O=n112 I1=FE_OFN235_backward_metrics_5__3__0 I2=A[0]
XU98 INV1S $PINS O=n42 I=n43
XU99 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 ND2 $PINS O=n9 I1=n64 I2=n45
XU102 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU103 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU104 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU105 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU106 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU107 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12HS $PINS O=n43 A1=n45 B1=n46 B2=n44
XU111 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU112 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU117 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU118 INV1S $PINS O=n20 I=n22
XU119 INV1S $PINS O=n19 I=n21
XU120 AOI12H $PINS O=n46 A1=n48 B1=n51 B2=n110
XU121 INV1S $PINS O=n48 I=n50
XU122 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU123 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU124 INV1S $PINS O=n57 I=n16
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU127 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU128 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU129 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU130 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU131 INV1S $PINS O=n64 I=n44
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU134 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU135 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU136 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU137 NR2 $PINS O=n44 I1=FE_OFN215_backward_metrics_5__3__3 I2=A[3]
XU138 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU139 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU140 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU141 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU142 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU143 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU144 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 OR2 $PINS O=n113 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_320 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN158_branch_metrics_2__0__11
+ FE_OFN159_branch_metrics_2__0__2 FE_OFN238_branch_metrics_2__0__2
XFE_RC_250_0 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XFE_RC_249_0 AOI12HP $PINS O=n39 A1=n41 B1=n44 B2=n113
XFE_RC_190_0 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n111
XFE_RC_103_0 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XFE_RC_102_0 OAI12HP $PINS O=n44 A1=n46 B1=n47 B2=n45
XFE_RC_93_0 AOI12HP $PINS O=n31 A1=n33 B1=n36 B2=n112
XFE_RC_56_0 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XFE_OFC2880_n51 INV1S $PINS O=n49 I=n51
XFE_OFC2751_n37 INV1S $PINS O=n63 I=n37
XFE_OFC2736_n43 INV1S $PINS O=n41 I=n43
XU84 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU85 OR2 $PINS O=n112 I1=A[6] I2=B[6]
XU86 OR2 $PINS O=n113 I1=A[4] I2=B[4]
XU87 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU88 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU89 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU90 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU91 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU94 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU95 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU96 ND2 $PINS O=n43 I1=B[4] I2=A[4]
XU97 ND2 $PINS O=n51 I1=B[2] I2=A[2]
XU98 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU99 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU102 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XU104 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU105 ND2 $PINS O=n9 I1=n65 I2=n46
XU106 INV1S $PINS O=n65 I=n45
XU107 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU108 ND2 $PINS O=n7 I1=n63 I2=n38
XU110 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU111 ND2 $PINS O=n5 I1=n61 I2=n30
XU112 INV1S $PINS O=n61 I=n29
XU113 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU114 ND2 $PINS O=n3 I1=n59 I2=n22
XU115 INV1S $PINS O=n59 I=n21
XU116 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU117 ND2 $PINS O=n10 I1=n111 I2=n51
XU118 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU119 ND2 $PINS O=n6 I1=n112 I2=n35
XU120 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU121 ND2 $PINS O=n8 I1=n113 I2=n43
XU122 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU123 ND2 $PINS O=n4 I1=n114 I2=n27
XU124 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU125 ND2 $PINS O=n2 I1=n115 I2=n19
XU131 INV1S $PINS O=n33 I=n35
XU133 INV1S $PINS O=n25 I=n27
XU134 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU135 ND2 $PINS O=n11 I1=n67 I2=n54
XU136 INV1S $PINS O=n67 I=n53
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU145 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=FE_OFN158_branch_metrics_2__0__11
.ENDS

.SUBCKT Siso_DW01_add_321 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_271_0 AOI12HP $PINS O=n47 A1=n49 B1=n52 B2=n111
XU84 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU85 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU86 OR2 $PINS O=n112 I1=A[4] I2=B[4]
XU87 OR2 $PINS O=n113 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU89 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU90 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU91 XNR2HS $PINS O=SUM[11] I1=n1 I2=n117
XU92 AO12 $PINS O=n117 A1=n17 B1=n20 B2=n115
XU93 ND2S $PINS O=n54 I1=B[1] I2=A[1]
XU94 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU97 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU98 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU99 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU100 OAI12H $PINS O=n52 A1=n54 B1=n53 B2=n56
XU101 OAI12H $PINS O=n44 A1=n46 B1=n47 B2=n45
XU102 OAI12H $PINS O=n28 A1=n30 B1=n31 B2=n29
XU103 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU104 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU105 ND2 $PINS O=n9 I1=n65 I2=n46
XU106 INV1S $PINS O=n65 I=n45
XU107 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU108 ND2 $PINS O=n7 I1=n63 I2=n38
XU109 INV1S $PINS O=n63 I=n37
XU110 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU111 ND2 $PINS O=n3 I1=n59 I2=n22
XU112 INV1S $PINS O=n59 I=n21
XU113 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU114 ND2 $PINS O=n5 I1=n61 I2=n30
XU115 INV1S $PINS O=n61 I=n29
XU116 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU117 ND2 $PINS O=n10 I1=n111 I2=n51
XU118 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU119 ND2 $PINS O=n8 I1=n112 I2=n43
XU120 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU121 ND2 $PINS O=n6 I1=n113 I2=n35
XU122 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU123 ND2 $PINS O=n2 I1=n115 I2=n19
XU124 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU125 ND2 $PINS O=n4 I1=n114 I2=n27
XU127 INV1S $PINS O=n49 I=n51
XU128 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n112
XU129 INV1S $PINS O=n41 I=n43
XU130 AOI12H $PINS O=n31 A1=n33 B1=n36 B2=n113
XU131 INV1S $PINS O=n33 I=n35
XU132 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU133 INV1S $PINS O=n25 I=n27
XU134 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU135 ND2 $PINS O=n11 I1=n67 I2=n54
XU136 INV1S $PINS O=n67 I=n53
XU137 INV1S $PINS O=n17 I=n19
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU140 ND2P $PINS O=n56 I1=B[0] I2=A[0]
XU141 ND2 $PINS O=n1 I1=n119 I2=n14
XU142 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU143 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU144 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU145 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU146 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU147 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU148 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU150 OR2 $PINS O=n119 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_322 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN201_backward_metrics_4__1__9
+ FE_OFN202_backward_metrics_4__1__3
XFE_OFC2927_n29 INV1S $PINS O=n27 I=n29
XFE_OFC2733_n43 INV1S $PINS O=n42 I=n43
XU83 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU84 XOR2HS $PINS O=SUM[11] I1=n1 I2=n111
XU85 OA12P $PINS O=n111 A1=n17 B1=n18 B2=n16
XU86 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU87 ND2S $PINS O=n22 I1=A[9] I2=FE_OFN201_backward_metrics_4__1__9
XU88 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU93 ND2S $PINS O=n45 I1=A[3] I2=FE_OFN202_backward_metrics_4__1__3
XU94 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU100 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU101 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU102 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU105 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU106 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU107 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU108 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU111 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU112 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU113 NR2 $PINS O=n35 I1=n40 I2=n37
XU114 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU115 INV1S $PINS O=n28 I=n30
XU117 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU118 INV1S $PINS O=n20 I=n22
XU119 INV1S $PINS O=n19 I=n21
XU120 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU121 INV1S $PINS O=n48 I=n50
XU122 INV1S $PINS O=n47 I=n49
XU123 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU124 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU125 ND2 $PINS O=n2 I1=n57 I2=n17
XU126 INV1S $PINS O=n57 I=n16
XU127 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU128 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU129 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU130 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU131 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU132 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU133 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU134 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU135 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU136 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU137 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU138 NR2 $PINS O=n44 I1=FE_OFN202_backward_metrics_4__1__3 I2=A[3]
XU139 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU140 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU141 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU142 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_323 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_225_0 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC3061_n29 INV1S $PINS O=n27 I=n29
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 ND2S $PINS O=n2 I1=n57 I2=n17
XU85 ND2S $PINS O=n14 I1=A[11] I2=B[11]
XU86 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU87 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU88 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU89 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU90 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU91 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU92 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU93 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU94 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU95 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU96 INV1S $PINS O=n42 I=n43
XU97 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU98 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU99 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU100 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU101 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU102 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU103 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU107 OAI12HS $PINS O=n43 A1=n45 B1=n46 B2=n44
XU108 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU109 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU110 NR2 $PINS O=n35 I1=n40 I2=n37
XU111 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU112 INV1S $PINS O=n28 I=n30
XU114 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU115 INV1S $PINS O=n20 I=n22
XU116 INV1S $PINS O=n19 I=n21
XU117 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU118 INV1S $PINS O=n48 I=n50
XU119 INV1S $PINS O=n47 I=n49
XU120 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU121 INV1S $PINS O=n57 I=n16
XU122 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU123 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU124 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU125 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU126 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU127 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU128 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU129 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU130 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU131 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU132 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU133 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU134 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU135 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU136 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU137 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU138 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU139 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU140 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU141 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU142 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU143 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU144 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU148 ND2 $PINS O=n1 I1=n112 I2=n14
XU149 OR2 $PINS O=n112 I1=B[11] I2=A[11]
.ENDS

.SUBCKT Siso_DW01_add_324 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN162_branch_metrics_3__0__11
XFE_OFC2939_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2906_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2741_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[7] I2=B[7]
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU88 ND2S $PINS O=n10 I1=n65 I2=n49
XU89 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU90 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU91 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU92 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU93 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU94 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU95 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU96 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU103 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU108 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU109 ND2 $PINS O=n2 I1=n57 I2=n17
XU110 INV1S $PINS O=n57 I=n16
XU111 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU112 ND2 $PINS O=n6 I1=n61 I2=n33
XU113 INV1S $PINS O=n61 I=n32
XU114 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU115 ND2 $PINS O=n8 I1=n63 I2=n41
XU116 INV1S $PINS O=n63 I=n40
XU117 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU118 ND2 $PINS O=n4 I1=n59 I2=n25
XU119 INV1S $PINS O=n59 I=n24
XU120 ND2 $PINS O=n9 I1=n64 I2=n46
XU121 INV1S $PINS O=n64 I=n45
XU122 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU123 ND2 $PINS O=n7 I1=n111 I2=n38
XU124 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU125 ND2 $PINS O=n5 I1=n110 I2=n30
XU126 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU127 ND2 $PINS O=n3 I1=n112 I2=n22
XU128 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU129 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU130 NR2 $PINS O=n43 I1=n45 I2=n48
XU131 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU132 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU133 INV1S $PINS O=n36 I=n38
XU134 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU135 INV1S $PINS O=n28 I=n30
XU136 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU137 INV1S $PINS O=n20 I=n22
XU138 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU141 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU142 ND2 $PINS O=n55 I1=B[0] I2=A[0]
XU143 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 ND2 $PINS O=n1 I1=n117 I2=n14
XU145 ND2 $PINS O=n14 I1=FE_OFN162_branch_metrics_3__0__11 I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_325 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_239_0 OR2T $PINS O=FE_RN_63_0 I1=n52 I2=n55
XFE_RC_238_0 ND2T $PINS O=n51 I1=FE_RN_63_0 I2=n53
XFE_RC_201_0 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XFE_RC_187_0 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XFE_OFC2876_n51 INV2 $PINS O=n50 I=n51
XFE_OFC2807_n40 INV1S $PINS O=n63 I=n40
XFE_OFC2761_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2734_n52 INV1S $PINS O=n66 I=n52
XU83 OR2 $PINS O=n110 I1=A[7] I2=B[7]
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 ND2P $PINS O=n53 I1=B[1] I2=A[1]
XU93 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU94 ND2 $PINS O=n41 I1=B[4] I2=A[4]
XU95 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU96 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU109 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU110 ND2 $PINS O=n2 I1=n57 I2=n17
XU111 INV1S $PINS O=n57 I=n16
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU117 INV1S $PINS O=n59 I=n24
XU118 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU119 ND2 $PINS O=n8 I1=n63 I2=n41
XU121 ND2 $PINS O=n9 I1=n64 I2=n46
XU122 INV1S $PINS O=n64 I=n45
XU123 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU124 ND2 $PINS O=n5 I1=n110 I2=n30
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n111 I2=n38
XU127 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU128 ND2 $PINS O=n3 I1=n112 I2=n22
XU130 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU131 NR2 $PINS O=n43 I1=n45 I2=n48
XU132 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU134 INV1S $PINS O=n36 I=n38
XU135 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU136 INV1S $PINS O=n28 I=n30
XU137 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU138 INV1S $PINS O=n20 I=n22
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2P $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2 $PINS O=n55 I1=B[0] I2=A[0]
XU144 ND2 $PINS O=n1 I1=n117 I2=n14
XU145 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_326 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XU83 OR2 $PINS O=n110 I1=B[9] I2=A[9]
XU84 OR2 $PINS O=n111 I1=B[7] I2=A[7]
XU85 OR2 $PINS O=n112 I1=B[2] I2=A[2]
XU86 OR2 $PINS O=n113 I1=B[0] I2=A[0]
XU87 ND2S $PINS O=n8 I1=n63 I2=n41
XU88 XOR2HS $PINS O=SUM[5] I1=n7 I2=n114
XU89 OA12S $PINS O=n114 A1=n41 B1=n42 B2=n40
XU90 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU91 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU92 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU93 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU94 OR2S $PINS O=n116 I1=B[11] I2=A[11]
XU95 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU96 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU97 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU98 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU99 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU100 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU101 INV1S $PINS O=n42 I=n43
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU105 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU106 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU107 NR2 $PINS O=n35 I1=n40 I2=n37
XU108 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU109 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU110 INV1S $PINS O=n28 I=n30
XU111 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n110
XU112 INV1S $PINS O=n20 I=n22
XU113 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU114 ND2 $PINS O=n9 I1=n64 I2=n45
XU115 INV1S $PINS O=n64 I=n44
XU116 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU117 INV1S $PINS O=n63 I=n40
XU118 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU119 ND2 $PINS O=n2 I1=n57 I2=n17
XU120 INV1S $PINS O=n57 I=n16
XU121 ND2 $PINS O=n7 I1=n62 I2=n38
XU122 INV1S $PINS O=n62 I=n37
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n110 I2=n22
XU125 AOI12H $PINS O=n46 A1=n48 B1=n112 B2=n51
XU126 INV1S $PINS O=n48 I=n50
XU127 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU128 ND2 $PINS O=n11 I1=n66 I2=n53
XU129 INV1S $PINS O=n66 I=n52
XU130 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU131 ND2 $PINS O=n10 I1=n112 I2=n50
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 ND2 $PINS O=n6 I1=n61 I2=n33
XU134 INV1S $PINS O=n61 I=n32
XU135 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU136 ND2 $PINS O=n4 I1=n59 I2=n25
XU137 INV1S $PINS O=n59 I=n24
XU138 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU139 ND2 $PINS O=n5 I1=n111 I2=n30
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU142 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU143 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU144 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU145 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 ND2 $PINS O=n1 I1=n116 I2=n14
XU151 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_327 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN231_backward_metrics_3__3__0
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[2] I2=A[2]
XU85 OR2 $PINS O=n112 I1=B[9] I2=A[9]
XU86 OR2 $PINS O=n113 I1=FE_OFN231_backward_metrics_3__3__0 I2=A[0]
XU87 OR2 $PINS O=n115 I1=B[11] I2=A[11]
XU88 ND2S $PINS O=n8 I1=n63 I2=n41
XU89 ND2S $PINS O=n3 I1=n112 I2=n22
XU90 ND2S $PINS O=n9 I1=n64 I2=n45
XU91 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU92 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU93 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU94 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU95 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU96 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU97 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU98 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU99 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU100 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU101 INV1S $PINS O=n42 I=n43
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU105 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU106 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU107 NR2 $PINS O=n35 I1=n40 I2=n37
XU108 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU109 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU110 INV1S $PINS O=n28 I=n30
XU111 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU112 INV1S $PINS O=n20 I=n22
XU113 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU114 ND2 $PINS O=n10 I1=n111 I2=n50
XU115 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU116 INV1S $PINS O=n64 I=n44
XU117 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU118 ND2 $PINS O=n2 I1=n57 I2=n17
XU119 INV1S $PINS O=n57 I=n16
XU120 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU121 AOI12HS $PINS O=n46 A1=n48 B1=n111 B2=n51
XU122 INV1S $PINS O=n48 I=n50
XU123 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU124 ND2 $PINS O=n11 I1=n66 I2=n53
XU125 INV1S $PINS O=n66 I=n52
XU126 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU127 INV1S $PINS O=n63 I=n40
XU128 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU129 ND2 $PINS O=n6 I1=n61 I2=n33
XU130 INV1S $PINS O=n61 I=n32
XU131 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU132 ND2 $PINS O=n4 I1=n59 I2=n25
XU133 INV1S $PINS O=n59 I=n24
XU134 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU135 ND2 $PINS O=n7 I1=n62 I2=n38
XU136 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU137 INV1S $PINS O=n62 I=n37
XU138 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU139 ND2 $PINS O=n5 I1=n110 I2=n30
XU140 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU141 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU142 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU143 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU144 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU145 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n1 I1=n115 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_328 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN166_branch_metrics_4__0__0
XFE_RC_252_0 AOI12HP $PINS O=n42 A1=n44 B1=n51 B2=n43
XFE_RC_191_0 OAI12HP $PINS O=n51 A1=n53 B1=n55 B2=n52
XFE_RC_163_0 AOI12HP $PINS O=n34 A1=n36 B1=n39 B2=n110
XFE_OFC3002_n48 INV1S $PINS O=n65 I=n48
XFE_OFC2905_n52 INV1S $PINS O=n66 I=n52
XFE_OFC2875_n45 INV1S $PINS O=n64 I=n45
XFE_OFC2513_n51 INV2 $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[9] I2=B[9]
XU85 OR2 $PINS O=n112 I1=A[7] I2=B[7]
XU86 OR2 $PINS O=n113 I1=A[0] I2=FE_OFN166_branch_metrics_4__0__0
XU87 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU88 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU89 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU90 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU91 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU92 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU93 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU94 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU95 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU96 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 ND2 $PINS O=n11 I1=n66 I2=n53
XU101 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XU102 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU103 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU104 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU105 ND2 $PINS O=n2 I1=n57 I2=n17
XU106 INV1S $PINS O=n57 I=n16
XU107 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU108 ND2 $PINS O=n10 I1=n65 I2=n49
XU110 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU111 ND2 $PINS O=n6 I1=n61 I2=n33
XU112 INV1S $PINS O=n61 I=n32
XU113 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU114 ND2 $PINS O=n8 I1=n63 I2=n41
XU115 INV1S $PINS O=n63 I=n40
XU116 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU117 ND2 $PINS O=n4 I1=n59 I2=n25
XU118 INV1S $PINS O=n59 I=n24
XU119 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU120 ND2 $PINS O=n7 I1=n110 I2=n38
XU121 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU122 ND2 $PINS O=n5 I1=n112 I2=n30
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n111 I2=n22
XU127 NR2 $PINS O=n43 I1=n45 I2=n48
XU128 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU130 INV1S $PINS O=n36 I=n38
XU131 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n112
XU132 INV1S $PINS O=n28 I=n30
XU133 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU134 INV1S $PINS O=n20 I=n22
XU135 ND2 $PINS O=n9 I1=n64 I2=n46
XU137 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU138 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU139 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU140 NR2P $PINS O=n52 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n55 I1=FE_OFN166_branch_metrics_4__0__0 I2=A[0]
XU142 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU143 ND2 $PINS O=n1 I1=n116 I2=n14
XU144 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU145 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n116 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_329 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_OFC2711_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[7] I2=B[7]
XU84 OR2 $PINS O=n111 I1=A[5] I2=B[5]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12P $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU93 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU94 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU95 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU96 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU97 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU98 ND2S $PINS O=n30 I1=B[7] I2=A[7]
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 INV1S $PINS O=n66 I=n52
XU103 OAI12H $PINS O=n39 A1=n41 B1=n42 B2=n40
XU104 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU105 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU106 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU107 ND2 $PINS O=n10 I1=n65 I2=n49
XU108 INV1S $PINS O=n65 I=n48
XU109 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU110 ND2 $PINS O=n8 I1=n63 I2=n41
XU111 INV1S $PINS O=n63 I=n40
XU112 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU113 ND2 $PINS O=n6 I1=n61 I2=n33
XU114 INV1S $PINS O=n61 I=n32
XU115 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU116 ND2 $PINS O=n4 I1=n59 I2=n25
XU117 INV1S $PINS O=n59 I=n24
XU118 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU119 ND2 $PINS O=n2 I1=n57 I2=n17
XU120 INV1S $PINS O=n57 I=n16
XU121 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU122 ND2 $PINS O=n7 I1=n111 I2=n38
XU123 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU124 ND2 $PINS O=n3 I1=n112 I2=n22
XU125 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU126 ND2 $PINS O=n5 I1=n110 I2=n30
XU127 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU128 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU129 NR2 $PINS O=n43 I1=n45 I2=n48
XU130 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU131 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n111
XU132 INV1S $PINS O=n36 I=n38
XU133 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU134 INV1S $PINS O=n28 I=n30
XU135 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU136 INV1S $PINS O=n20 I=n22
XU137 ND2 $PINS O=n9 I1=n64 I2=n46
XU138 INV1S $PINS O=n64 I=n45
XU139 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU140 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU141 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU142 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU143 ND2P $PINS O=n55 I1=B[0] I2=A[0]
XU144 ND2 $PINS O=n1 I1=n117 I2=n14
XU145 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU146 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU147 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU148 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU149 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU150 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU151 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_330 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN228_backward_metrics_2__1__1
XFE_RC_261_0 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XFE_OFC3060_n32 INV1S $PINS O=n61 I=n32
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 AN2 $PINS O=SUM[0] I1=n114 I2=n55
XU86 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU87 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU88 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU89 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU90 ND2S $PINS O=n53 I1=A[1] I2=FE_OFN228_backward_metrics_2__1__1
XU91 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU92 ND2 $PINS O=n33 I1=A[6] I2=B[6]
XU93 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU94 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU95 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU96 OR2S $PINS O=n114 I1=B[0] I2=A[0]
XU97 INV1S $PINS O=n42 I=n43
XU98 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU99 ND2 $PINS O=n11 I1=n66 I2=n53
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU102 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU103 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU104 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU105 ND2 $PINS O=n6 I1=n61 I2=n33
XU106 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU107 ND2 $PINS O=n4 I1=n59 I2=n25
XU108 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU109 ND2 $PINS O=n5 I1=n110 I2=n30
XU110 OAI12HP $PINS O=n31 A1=n33 B1=n34 B2=n32
XU111 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU112 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU113 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU114 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU115 NR2 $PINS O=n35 I1=n40 I2=n37
XU116 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU117 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU118 INV1S $PINS O=n28 I=n30
XU119 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU120 INV1S $PINS O=n20 I=n22
XU121 AOI12H $PINS O=n46 A1=n48 B1=n47 B2=n51
XU122 INV1S $PINS O=n48 I=n50
XU123 INV1S $PINS O=n47 I=n49
XU124 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU125 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU126 ND2 $PINS O=n3 I1=n111 I2=n22
XU127 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU128 ND2 $PINS O=n2 I1=n57 I2=n17
XU129 INV1S $PINS O=n57 I=n16
XU130 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU131 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU132 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU133 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU135 INV1S $PINS O=n59 I=n24
XU136 INV1S $PINS O=n66 I=n52
XU137 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU138 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU139 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU140 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU141 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU142 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU143 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU144 NR2 $PINS O=n52 I1=FE_OFN228_backward_metrics_2__1__1 I2=A[1]
XU145 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU146 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU147 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU150 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_331 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_206_0 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XFE_RC_205_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC3066_n22 INV1S $PINS O=n20 I=n22
XU83 OR2 $PINS O=n110 I1=B[7] I2=A[7]
XU84 OR2 $PINS O=n111 I1=B[9] I2=A[9]
XU85 OR2 $PINS O=n113 I1=B[11] I2=A[11]
XU86 AN2S $PINS O=SUM[0] I1=n114 I2=n55
XU87 ND2S $PINS O=n3 I1=n111 I2=n22
XU88 ND2S $PINS O=n8 I1=n63 I2=n41
XU89 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU90 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU91 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU92 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU93 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU94 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU95 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU96 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU97 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU98 OR2S $PINS O=n114 I1=B[0] I2=A[0]
XU99 INV1S $PINS O=n42 I=n43
XU100 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU101 ND2 $PINS O=n11 I1=n66 I2=n53
XU102 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU103 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU104 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU105 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU106 ND2 $PINS O=n5 I1=n110 I2=n30
XU107 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU108 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU109 ND2 $PINS O=n4 I1=n59 I2=n25
XU110 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU112 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU113 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU115 NR2 $PINS O=n35 I1=n40 I2=n37
XU116 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU117 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n110
XU118 INV1S $PINS O=n28 I=n30
XU119 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n111
XU121 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU122 INV1S $PINS O=n48 I=n50
XU123 INV1S $PINS O=n47 I=n49
XU124 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU125 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU126 ND2 $PINS O=n7 I1=n62 I2=n38
XU127 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU128 ND2 $PINS O=n2 I1=n57 I2=n17
XU129 INV1S $PINS O=n57 I=n16
XU130 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU131 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU132 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU133 ND2 $PINS O=n6 I1=n61 I2=n33
XU134 INV1S $PINS O=n63 I=n40
XU135 INV1S $PINS O=n62 I=n37
XU136 INV1S $PINS O=n61 I=n32
XU137 INV1S $PINS O=n59 I=n24
XU138 INV1S $PINS O=n66 I=n52
XU139 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU140 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU141 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU142 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU143 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU144 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU145 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU146 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU147 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU148 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU149 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU150 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU151 ND2 $PINS O=n1 I1=n113 I2=n14
XU152 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_332 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN172_branch_metrics_5__0__9
XFE_RC_244_0 OAI12HP $PINS O=n44 A1=n46 B1=n47 B2=n45
XFE_RC_215_0 AOI12H $PINS O=n47 A1=n49 B1=n52 B2=n111
XFE_RC_192_0 AOI12HP $PINS O=n31 A1=n33 B1=n36 B2=n112
XFE_RC_104_0 OAI12HP $PINS O=n28 A1=n30 B1=n31 B2=n29
XFE_OFC3040_n45 INV1S $PINS O=n65 I=n45
XFE_OFC2885_n37 INV1S $PINS O=n63 I=n37
XU84 OR2 $PINS O=n52 I1=n117 I2=n118
XU86 OR2 $PINS O=n111 I1=A[2] I2=B[2]
XU87 OR2 $PINS O=n112 I1=A[6] I2=B[6]
XU88 OR2 $PINS O=n113 I1=A[4] I2=B[4]
XU89 OR2 $PINS O=n114 I1=A[8] I2=B[8]
XU90 OR2 $PINS O=n115 I1=A[10] I2=B[10]
XU91 OR2 $PINS O=n116 I1=A[0] I2=B[0]
XU92 NR2 $PINS O=n53 I1=A[1] I2=B[1]
XU93 ND2 $PINS O=n54 I1=B[1] I2=A[1]
XU94 ND2 $PINS O=n56 I1=B[0] I2=A[0]
XU95 INV1S $PINS O=n118 I=n54
XU96 NR2 $PINS O=n117 I1=n53 I2=n56
XU97 XNR2HS $PINS O=SUM[11] I1=n1 I2=n119
XU98 OAI12H $PINS O=n36 A1=n38 B1=n39 B2=n37
XU99 AO12 $PINS O=n119 A1=n17 B1=n20 B2=n115
XU100 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU101 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU102 ND2S $PINS O=n43 I1=B[4] I2=A[4]
XU103 ND2S $PINS O=n51 I1=B[2] I2=A[2]
XU104 ND2S $PINS O=n35 I1=B[6] I2=A[6]
XU105 AN2 $PINS O=SUM[0] I1=n116 I2=n56
XU108 OAI12H $PINS O=n20 A1=n22 B1=n23 B2=n21
XU109 XNR2HS $PINS O=SUM[10] I1=n2 I2=n20
XU110 ND2 $PINS O=n2 I1=n115 I2=n19
XU111 XOR2HS $PINS O=SUM[3] I1=n9 I2=n47
XU112 ND2 $PINS O=n9 I1=n65 I2=n46
XU114 XOR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU115 ND2 $PINS O=n7 I1=n63 I2=n38
XU117 XOR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU118 ND2 $PINS O=n5 I1=n61 I2=n30
XU119 INV1S $PINS O=n61 I=n29
XU120 XOR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU121 ND2 $PINS O=n3 I1=n59 I2=n22
XU122 INV1S $PINS O=n59 I=n21
XU123 XNR2HS $PINS O=SUM[2] I1=n10 I2=n52
XU124 ND2 $PINS O=n10 I1=n111 I2=n51
XU125 XNR2HS $PINS O=SUM[6] I1=n6 I2=n36
XU126 ND2 $PINS O=n6 I1=n112 I2=n35
XU127 XNR2HS $PINS O=SUM[4] I1=n8 I2=n44
XU128 ND2 $PINS O=n8 I1=n113 I2=n43
XU129 XNR2HS $PINS O=SUM[8] I1=n4 I2=n28
XU130 ND2 $PINS O=n4 I1=n114 I2=n27
XU131 INV1S $PINS O=n49 I=n51
XU132 AOI12H $PINS O=n39 A1=n41 B1=n44 B2=n113
XU133 INV1S $PINS O=n41 I=n43
XU135 INV1S $PINS O=n33 I=n35
XU136 AOI12H $PINS O=n23 A1=n25 B1=n28 B2=n114
XU137 INV1S $PINS O=n25 I=n27
XU138 XOR2HS $PINS O=SUM[1] I1=n56 I2=n11
XU139 ND2 $PINS O=n11 I1=n67 I2=n54
XU140 INV1S $PINS O=n67 I=n53
XU141 INV1S $PINS O=n17 I=n19
XU142 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU143 ND2 $PINS O=n1 I1=n121 I2=n14
XU144 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU145 NR2 $PINS O=n37 I1=A[5] I2=B[5]
XU146 NR2 $PINS O=n29 I1=A[7] I2=B[7]
XU147 NR2 $PINS O=n21 I1=A[9] I2=B[9]
XU148 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU149 ND2 $PINS O=n22 I1=FE_OFN172_branch_metrics_5__0__9 I2=A[9]
XU150 ND2 $PINS O=n27 I1=B[8] I2=A[8]
XU151 ND2 $PINS O=n19 I1=B[10] I2=A[10]
XU152 OR2 $PINS O=n121 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_333 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO
XFE_RC_240_0 OAI12HP $PINS O=n39 A1=n41 B1=n42 B2=n40
XFE_OFC2802_n51 INV1S $PINS O=n50 I=n51
XU83 OR2 $PINS O=n110 I1=A[5] I2=B[5]
XU84 OR2 $PINS O=n111 I1=A[7] I2=B[7]
XU85 OR2 $PINS O=n112 I1=A[9] I2=B[9]
XU86 OR2 $PINS O=n113 I1=A[0] I2=B[0]
XU87 ND2 $PINS O=n49 I1=B[2] I2=A[2]
XU88 XOR2HS $PINS O=SUM[3] I1=n9 I2=n114
XU89 OA12 $PINS O=n114 A1=n49 B1=n50 B2=n48
XU90 XOR2HS $PINS O=SUM[11] I1=n1 I2=n115
XU91 OA12 $PINS O=n115 A1=n17 B1=n18 B2=n16
XU92 ND2S $PINS O=n41 I1=B[4] I2=A[4]
XU93 ND2S $PINS O=n33 I1=B[6] I2=A[6]
XU94 ND2S $PINS O=n53 I1=B[1] I2=A[1]
XU95 ND2S $PINS O=n46 I1=B[3] I2=A[3]
XU96 ND2S $PINS O=n38 I1=B[5] I2=A[5]
XU97 AN2 $PINS O=SUM[0] I1=n113 I2=n55
XU100 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU101 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU102 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU103 ND2 $PINS O=n2 I1=n57 I2=n17
XU104 INV1S $PINS O=n57 I=n16
XU105 XOR2HS $PINS O=SUM[2] I1=n10 I2=n50
XU106 ND2 $PINS O=n10 I1=n65 I2=n49
XU107 INV1S $PINS O=n65 I=n48
XU108 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU109 ND2 $PINS O=n8 I1=n63 I2=n41
XU110 INV1S $PINS O=n63 I=n40
XU111 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU112 ND2 $PINS O=n6 I1=n61 I2=n33
XU113 INV1S $PINS O=n61 I=n32
XU114 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU115 ND2 $PINS O=n4 I1=n59 I2=n25
XU116 INV1S $PINS O=n59 I=n24
XU117 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU118 ND2 $PINS O=n9 I1=n64 I2=n46
XU119 INV1S $PINS O=n64 I=n45
XU120 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU121 ND2 $PINS O=n7 I1=n110 I2=n38
XU122 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU123 ND2 $PINS O=n3 I1=n112 I2=n22
XU124 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU125 ND2 $PINS O=n5 I1=n111 I2=n30
XU126 AOI12H $PINS O=n42 A1=n44 B1=n43 B2=n51
XU127 NR2 $PINS O=n43 I1=n45 I2=n48
XU128 OAI12HS $PINS O=n44 A1=n46 B1=n45 B2=n49
XU129 AOI12H $PINS O=n34 A1=n36 B1=n39 B2=n110
XU130 INV1S $PINS O=n36 I=n38
XU131 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n111
XU132 INV1S $PINS O=n28 I=n30
XU133 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n112
XU134 INV1S $PINS O=n20 I=n22
XU135 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU136 ND2 $PINS O=n11 I1=n66 I2=n53
XU137 INV1S $PINS O=n66 I=n52
XU138 NR2 $PINS O=n48 I1=A[2] I2=B[2]
XU139 NR2 $PINS O=n45 I1=A[3] I2=B[3]
XU140 NR2 $PINS O=n52 I1=A[1] I2=B[1]
XU141 ND2 $PINS O=n55 I1=B[0] I2=A[0]
XU142 ND2 $PINS O=n1 I1=n117 I2=n14
XU143 ND2 $PINS O=n14 I1=B[11] I2=A[11]
XU144 NR2 $PINS O=n40 I1=A[4] I2=B[4]
XU145 NR2 $PINS O=n32 I1=A[6] I2=B[6]
XU146 NR2 $PINS O=n24 I1=A[8] I2=B[8]
XU147 NR2 $PINS O=n16 I1=A[10] I2=B[10]
XU148 ND2 $PINS O=n25 I1=B[8] I2=A[8]
XU149 ND2 $PINS O=n30 I1=B[7] I2=A[7]
XU150 ND2 $PINS O=n22 I1=B[9] I2=A[9]
XU151 ND2 $PINS O=n17 I1=B[10] I2=A[10]
XU152 OR2 $PINS O=n117 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_334 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN242_backward_metrics_1__1__0
XFE_RC_222_0 OAI12HP $PINS O=n23 A1=n25 B1=n26 B2=n24
XFE_OFC2941_n29 INV1S $PINS O=n27 I=n29
XFE_OFC2928_n22 INV1S $PINS O=n20 I=n22
XU83 AN2 $PINS O=SUM[0] I1=n112 I2=n55
XU84 OA12P $PINS O=n111 A1=n17 B1=n18 B2=n16
XU85 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU86 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU87 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU88 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU89 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU90 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU91 XOR2HS $PINS O=SUM[11] I1=n1 I2=n111
XU92 OR2S $PINS O=n113 I1=B[11] I2=A[11]
XU93 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU94 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU95 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU96 OR2S $PINS O=n112 I1=B[0] I2=A[0]
XU97 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU98 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU99 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU100 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU101 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU102 XOR2HS $PINS O=SUM[4] I1=n42 I2=n8
XU103 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU104 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU105 INV1S $PINS O=n42 I=n43
XU106 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU107 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU109 OAI12HS $PINS O=n51 A1=n53 B1=n52 B2=n55
XU110 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU111 AOI12H $PINS O=n34 A1=n36 B1=n35 B2=n43
XU112 NR2 $PINS O=n35 I1=n40 I2=n37
XU113 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU114 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU115 INV1S $PINS O=n28 I=n30
XU117 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU119 INV1S $PINS O=n19 I=n21
XU120 AOI12HS $PINS O=n46 A1=n48 B1=n51 B2=n47
XU121 INV1S $PINS O=n48 I=n50
XU122 INV1S $PINS O=n47 I=n49
XU123 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU124 ND2 $PINS O=n2 I1=n57 I2=n17
XU125 INV1S $PINS O=n57 I=n16
XU126 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU127 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU128 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU129 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU130 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU131 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU132 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU133 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU134 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU135 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU136 NR2 $PINS O=n40 I1=B[4] I2=A[4]
XU137 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU138 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU139 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU140 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU141 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU142 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU143 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU144 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU145 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU146 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU147 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU148 ND2 $PINS O=n1 I1=n113 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso_DW01_add_335 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2]
+ SUM[1] SUM[0] CO FE_OFN191_backward_metrics_1__3__4
XU83 AN2 $PINS O=SUM[0] I1=n111 I2=n55
XU84 OR2 $PINS O=n112 I1=B[11] I2=A[11]
XU85 ND2S $PINS O=n45 I1=A[3] I2=B[3]
XU86 ND2S $PINS O=n50 I1=A[2] I2=B[2]
XU87 ND2S $PINS O=n17 I1=A[10] I2=B[10]
XU88 ND2S $PINS O=n38 I1=A[5] I2=B[5]
XU89 ND2S $PINS O=n53 I1=A[1] I2=B[1]
XU90 ND2S $PINS O=n25 I1=A[8] I2=B[8]
XU91 ND2S $PINS O=n33 I1=A[6] I2=B[6]
XU92 ND2S $PINS O=n22 I1=A[9] I2=B[9]
XU93 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU94 OR2S $PINS O=n111 I1=B[0] I2=A[0]
XU95 XNR2HS $PINS O=SUM[2] I1=n51 I2=n10
XU96 XOR2HS $PINS O=SUM[3] I1=n46 I2=n9
XU97 XOR2HS $PINS O=SUM[4] I1=n8 I2=n42
XU98 XOR2HS $PINS O=SUM[8] I1=n4 I2=n26
XU99 XNR2HS $PINS O=SUM[5] I1=n7 I2=n39
XU100 XNR2HS $PINS O=SUM[7] I1=n5 I2=n31
XU101 XNR2HS $PINS O=SUM[9] I1=n3 I2=n23
XU102 XOR2HS $PINS O=SUM[6] I1=n6 I2=n34
XU103 INV1S $PINS O=n42 I=n43
XU104 XOR2HS $PINS O=SUM[1] I1=n55 I2=n11
XU105 OAI12H $PINS O=n31 A1=n33 B1=n34 B2=n32
XU106 OAI12H $PINS O=n23 A1=n25 B1=n26 B2=n24
XU107 OAI12H $PINS O=n51 A1=n53 B1=n52 B2=n55
XU108 OAI12H $PINS O=n43 A1=n45 B1=n46 B2=n44
XU109 AOI12HS $PINS O=n34 A1=n36 B1=n35 B2=n43
XU110 NR2 $PINS O=n35 I1=n40 I2=n37
XU111 OAI12HS $PINS O=n36 A1=n38 B1=n37 B2=n41
XU112 AOI12H $PINS O=n18 A1=n20 B1=n23 B2=n19
XU113 INV1S $PINS O=n20 I=n22
XU114 INV1S $PINS O=n19 I=n21
XU115 AOI12H $PINS O=n26 A1=n28 B1=n31 B2=n27
XU116 INV1S $PINS O=n28 I=n30
XU117 INV1S $PINS O=n27 I=n29
XU118 AOI12HS $PINS O=n46 A1=n48 B1=n47 B2=n51
XU119 INV1S $PINS O=n48 I=n50
XU120 INV1S $PINS O=n47 I=n49
XU121 XOR2HS $PINS O=SUM[10] I1=n2 I2=n18
XU122 ND2 $PINS O=n2 I1=n57 I2=n17
XU123 INV1S $PINS O=n57 I=n16
XU124 OR2B1S $PINS O=n9 I1=n44 B1=n45
XU125 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU126 OR2B1S $PINS O=n10 I1=n49 B1=n50
XU127 OR2B1S $PINS O=n11 I1=n52 B1=n53
XU128 OR2B1S $PINS O=n8 I1=n40 B1=n41
XU129 OR2B1S $PINS O=n7 I1=n37 B1=n38
XU130 OR2B1S $PINS O=n6 I1=n32 B1=n33
XU131 OR2B1S $PINS O=n4 I1=n24 B1=n25
XU132 OR2B1S $PINS O=n5 I1=n29 B1=n30
XU133 OR2B1S $PINS O=n3 I1=n21 B1=n22
XU134 NR2 $PINS O=n40 I1=FE_OFN191_backward_metrics_1__3__4 I2=A[4]
XU135 NR2 $PINS O=n37 I1=B[5] I2=A[5]
XU136 NR2 $PINS O=n44 I1=B[3] I2=A[3]
XU137 NR2 $PINS O=n32 I1=B[6] I2=A[6]
XU138 NR2 $PINS O=n16 I1=B[10] I2=A[10]
XU139 NR2 $PINS O=n24 I1=B[8] I2=A[8]
XU140 NR2 $PINS O=n49 I1=B[2] I2=A[2]
XU141 NR2 $PINS O=n21 I1=B[9] I2=A[9]
XU142 NR2 $PINS O=n29 I1=B[7] I2=A[7]
XU143 NR2 $PINS O=n52 I1=B[1] I2=A[1]
XU144 ND2 $PINS O=n55 I1=A[0] I2=B[0]
XU145 ND2 $PINS O=n41 I1=A[4] I2=B[4]
XU146 XNR2HS $PINS O=SUM[11] I1=n1 I2=n15
XU147 OAI12HS $PINS O=n15 A1=n17 B1=n18 B2=n16
XU148 ND2 $PINS O=n1 I1=n112 I2=n14
XU149 ND2 $PINS O=n14 I1=A[11] I2=B[11]
.ENDS

.SUBCKT Siso reset_n_i read_en_i sys_i[27] sys_i[26] sys_i[25] sys_i[24]
+ sys_i[23] sys_i[22] sys_i[21] sys_i[20] sys_i[19] sys_i[18] sys_i[17]
+ sys_i[16] sys_i[15] sys_i[14] sys_i[13] sys_i[12] sys_i[11] sys_i[10]
+ sys_i[9] sys_i[8] sys_i[7] sys_i[6] sys_i[5] sys_i[4] sys_i[3] sys_i[2]
+ sys_i[1] sys_i[0] enc_i[27] enc_i[26] enc_i[25] enc_i[24] enc_i[23] enc_i[22]
+ enc_i[21] enc_i[20] enc_i[19] enc_i[18] enc_i[17] enc_i[16] enc_i[15]
+ enc_i[14] enc_i[13] enc_i[12] enc_i[11] enc_i[10] enc_i[9] enc_i[8] enc_i[7]
+ enc_i[6] enc_i[5] enc_i[4] enc_i[3] enc_i[2] enc_i[1] enc_i[0] ext_i[83]
+ ext_i[82] ext_i[81] ext_i[80] ext_i[79] ext_i[78] ext_i[77] ext_i[76]
+ ext_i[75] ext_i[74] ext_i[73] ext_i[72] ext_i[71] ext_i[70] ext_i[69]
+ ext_i[68] ext_i[67] ext_i[66] ext_i[65] ext_i[64] ext_i[63] ext_i[62]
+ ext_i[61] ext_i[60] ext_i[59] ext_i[58] ext_i[57] ext_i[56] ext_i[55]
+ ext_i[54] ext_i[53] ext_i[52] ext_i[51] ext_i[50] ext_i[49] ext_i[48]
+ ext_i[47] ext_i[46] ext_i[45] ext_i[44] ext_i[43] ext_i[42] ext_i[41]
+ ext_i[40] ext_i[39] ext_i[38] ext_i[37] ext_i[36] ext_i[35] ext_i[34]
+ ext_i[33] ext_i[32] ext_i[31] ext_i[30] ext_i[29] ext_i[28] ext_i[27]
+ ext_i[26] ext_i[25] ext_i[24] ext_i[23] ext_i[22] ext_i[21] ext_i[20]
+ ext_i[19] ext_i[18] ext_i[17] ext_i[16] ext_i[15] ext_i[14] ext_i[13]
+ ext_i[12] ext_i[11] ext_i[10] ext_i[9] ext_i[8] ext_i[7] ext_i[6] ext_i[5]
+ ext_i[4] ext_i[3] ext_i[2] ext_i[1] ext_i[0] data_o[83] data_o[82] data_o[81]
+ data_o[80] data_o[79] data_o[78] data_o[77] data_o[76] data_o[75] data_o[74]
+ data_o[73] data_o[72] data_o[71] data_o[70] data_o[69] data_o[68] data_o[67]
+ data_o[66] data_o[65] data_o[64] data_o[63] data_o[62] data_o[61] data_o[60]
+ data_o[59] data_o[58] data_o[57] data_o[56] data_o[55] data_o[54] data_o[53]
+ data_o[52] data_o[51] data_o[50] data_o[49] data_o[48] data_o[47] data_o[46]
+ data_o[45] data_o[44] data_o[43] data_o[42] data_o[41] data_o[40] data_o[39]
+ data_o[38] data_o[37] data_o[36] data_o[35] data_o[34] data_o[33] data_o[32]
+ data_o[31] data_o[30] data_o[29] data_o[28] data_o[27] data_o[26] data_o[25]
+ data_o[24] data_o[23] data_o[22] data_o[21] data_o[20] data_o[19] data_o[18]
+ data_o[17] data_o[16] data_o[15] data_o[14] data_o[13] data_o[12] data_o[11]
+ data_o[10] data_o[9] data_o[8] data_o[7] data_o[6] data_o[5] data_o[4]
+ data_o[3] data_o[2] data_o[1] data_o[0] finish FE_OFN137_i_reset_n_i
+ FE_OFN136_i_reset_n_i FE_OFN135_i_reset_n_i FE_OFN134_i_reset_n_i
+ FE_OFN133_i_reset_n_i FE_OFN132_i_reset_n_i FE_OFN131_i_reset_n_i
+ FE_OFN130_i_reset_n_i FE_OFN129_i_reset_n_i FE_OFN128_i_reset_n_i
+ FE_OFN127_i_reset_n_i FE_OFN126_i_reset_n_i FE_OFN125_i_reset_n_i
+ FE_OFN124_i_reset_n_i FE_OFN123_i_reset_n_i FE_OFN122_i_reset_n_i
+ FE_OFN121_i_reset_n_i FE_OFN120_i_reset_n_i FE_OFN119_i_reset_n_i
+ FE_OFN118_i_reset_n_i FE_OFN117_i_reset_n_i FE_OFN116_i_reset_n_i
+ FE_OFN115_i_reset_n_i FE_OFN114_i_reset_n_i FE_OFN113_i_reset_n_i
+ FE_OFN112_i_reset_n_i FE_OFN111_i_reset_n_i FE_OFN110_i_reset_n_i
+ FE_OFN109_i_reset_n_i FE_OFN108_i_reset_n_i FE_OFN107_i_reset_n_i
+ FE_OFN106_i_reset_n_i FE_OFN105_i_reset_n_i FE_OFN104_i_reset_n_i
+ FE_OFN103_i_reset_n_i FE_OFN102_i_reset_n_i FE_OFN101_i_reset_n_i
+ FE_OFN100_i_reset_n_i FE_OFN99_i_reset_n_i FE_OFN98_i_reset_n_i
+ FE_OFN97_i_reset_n_i FE_OFN96_i_reset_n_i FE_OFN95_i_reset_n_i
+ FE_OFN94_i_reset_n_i FE_OFN93_i_reset_n_i FE_OFN92_i_reset_n_i
+ FE_OFN91_i_reset_n_i FE_OFN90_i_reset_n_i FE_OFN89_i_reset_n_i
+ FE_OFN88_i_reset_n_i FE_OFN87_i_reset_n_i FE_OFN86_i_reset_n_i
+ FE_OFN85_i_reset_n_i FE_OFN84_i_reset_n_i FE_OFN83_i_reset_n_i
+ FE_OFN82_i_reset_n_i FE_OFN81_i_reset_n_i FE_OFN80_i_reset_n_i
+ FE_OFN79_i_reset_n_i FE_OFN78_i_reset_n_i FE_OFN77_i_reset_n_i
+ FE_OFN76_i_reset_n_i FE_OFN75_i_reset_n_i FE_OFN74_i_reset_n_i
+ FE_OFN73_i_reset_n_i FE_OFN72_i_reset_n_i FE_OFN71_i_reset_n_i
+ FE_OFN70_i_reset_n_i FE_OFN69_i_reset_n_i FE_OFN68_i_reset_n_i
+ FE_OFN67_i_reset_n_i FE_OFN66_i_reset_n_i FE_OFN65_i_reset_n_i
+ FE_OFN64_i_reset_n_i FE_OFN63_i_reset_n_i FE_OFN62_i_reset_n_i
+ FE_OFN61_i_reset_n_i FE_OFN60_i_reset_n_i FE_OFN59_i_reset_n_i
+ FE_OFN58_i_reset_n_i FE_OFN57_i_reset_n_i FE_OFN56_i_reset_n_i
+ FE_OFN55_i_reset_n_i FE_OFN54_i_reset_n_i FE_OFN53_i_reset_n_i
+ FE_OFN52_i_reset_n_i FE_OFN51_i_reset_n_i FE_OFN50_i_reset_n_i
+ FE_OFN49_i_reset_n_i FE_OFN48_i_reset_n_i FE_OFN47_i_reset_n_i
+ FE_OFN46_i_reset_n_i FE_OFN45_i_reset_n_i FE_OFN44_i_reset_n_i
+ FE_OFN43_i_reset_n_i FE_OFN42_i_reset_n_i FE_OFN41_i_reset_n_i
+ FE_OFN40_i_reset_n_i FE_OFN39_i_reset_n_i FE_OFN38_i_reset_n_i
+ FE_OFN37_i_reset_n_i FE_OFN36_i_reset_n_i FE_OFN35_i_reset_n_i
+ FE_OFN34_i_reset_n_i FE_OFN33_i_reset_n_i FE_OFN32_i_reset_n_i
+ FE_OFN31_i_reset_n_i FE_OFN30_i_reset_n_i FE_OFN29_i_reset_n_i
+ FE_OFN28_i_reset_n_i FE_OFN27_i_reset_n_i FE_OFN26_i_reset_n_i
+ FE_OFN25_i_reset_n_i FE_OFN24_i_reset_n_i FE_OFN23_i_reset_n_i
+ FE_OFN22_i_reset_n_i FE_OFN21_i_reset_n_i FE_OFN20_i_reset_n_i
+ FE_OFN19_i_reset_n_i FE_OFN18_i_reset_n_i FE_OFN17_i_reset_n_i
+ FE_OFN16_i_reset_n_i FE_OFN15_i_reset_n_i FE_OFN14_i_reset_n_i
+ FE_OFN13_i_reset_n_i FE_OFN12_i_reset_n_i FE_OFN11_i_reset_n_i
+ FE_OFN10_i_reset_n_i FE_OFN9_i_reset_n_i FE_OFN8_i_reset_n_i
+ FE_OFN7_i_reset_n_i FE_OFN6_i_reset_n_i FE_OFN5_i_reset_n_i
+ FE_OFN4_i_reset_n_i FE_OFN3_i_reset_n_i FE_OFN2_i_reset_n_i
+ FE_OFN1_i_reset_n_i FE_OFN0_i_reset_n_i clk_i_clone24 clk_i_clone23
+ clk_i_clone22 clk_i_clone21 clk_i_clone20 clk_i_clone19 clk_i_clone17
+ clk_i_clone16 clk_i_clone18 clk_i_clone13 clk_i_clone14 clk_i_clone12
+ clk_i_clone10 clk_i_clone11 clk_i_clone15 clk_i_clone9 clk_i_clone8
+ clk_i_clone7 clk_i_clone5 clk_i_clone6 clk_i_clone3 clk_i_clone4 clk_i_clone1
+ clk_i clk_i_clone2
XFE_RC_302_0 MUX2 $PINS O=n3051 S=FE_OFN1328_n995 A=ext[5][0] B=FE_OFN1358_n1
XFE_RC_301_0 MUX2 $PINS O=n3081 S=FE_OFN1313_n995 A=enc[3][0] B=enc_i[12]
XFE_RC_300_0 MUX2 $PINS O=n3052 S=FE_OFN1284_n995 A=ext[6][11] B=FE_OFN1357_n1
XFE_RC_299_0 MUX2 $PINS O=n3041 S=FE_OFN1284_n995 A=ext[5][10] B=FE_OFN1357_n1
XFE_RC_298_0 MUX2 $PINS O=n2975 S=FE_OFN1336_n995 A=sys[5][0] B=sys_i[4]
XFE_RC_297_0 MUX2 $PINS O=n2971 S=FE_OFN1336_n995 A=sys[4][0] B=sys_i[8]
XFE_RC_296_0 MUX2 $PINS O=n3062 S=FE_OFN1337_n995 A=ext[6][1] B=FE_OFN1358_n1
XFE_RC_295_0 MUX2 $PINS O=n3061 S=FE_OFN1328_n995 A=ext[6][2] B=FE_OFN1358_n1
XFE_RC_294_0 MUX2 $PINS O=n3088 S=FE_OFN1313_n995 A=enc[5][1] B=enc_i[5]
XFE_RC_293_0 MUX2 $PINS O=n3048 S=FE_OFN1318_n995 A=ext[5][3] B=FE_OFN1356_n1
XFE_RC_292_0 MUX2 $PINS O=n3060 S=FE_OFN1314_n995 A=ext[6][3] B=FE_OFN1356_n1
XFE_RC_291_0 MUX2 $PINS O=n3036 S=FE_OFN1311_n995 A=ext[4][3] B=ext_i[27]
XFE_RC_290_0 MUX2 $PINS O=n3058 S=FE_OFN1310_n995 A=ext[6][5] B=FE_OFN1356_n1
XFE_RC_289_0 MUX2 $PINS O=n3023 S=FE_OFN1306_n995 A=ext[3][4] B=ext_i[40]
XFE_RC_288_0 MUX2 $PINS O=n3078 S=FE_OFN1295_n995 A=enc[3][3] B=enc_i[15]
XFE_RC_287_0 MUX2 $PINS O=n3034 S=FE_OFN1300_n995 A=ext[4][5] B=ext_i[29]
XFE_RC_286_0 MUX2 $PINS O=n3040 S=FE_OFN1290_n995 A=ext[5][11] B=FE_OFN1357_n1
XFE_RC_285_0 MUX2 $PINS O=n3032 S=FE_OFN1293_n995 A=ext[4][7] B=ext_i[31]
XFE_RC_284_0 MUX2 $PINS O=n3053 S=FE_OFN1284_n995 A=ext[6][10] B=FE_OFN1357_n1
XFE_RC_283_0 MUX2 $PINS O=n3019 S=FE_OFN1286_n995 A=ext[3][8] B=ext_i[44]
XFE_RC_282_0 MUX2 $PINS O=n3055 S=FE_OFN1285_n995 A=ext[6][8] B=FE_OFN1355_n1
XFE_RC_281_0 MUX2 $PINS O=n3042 S=n995 A=ext[5][9] B=FE_OFN1357_n1
XFE_RC_280_0 MUX2 $PINS O=n3018 S=n995 A=ext[3][9] B=ext_i[45]
XFE_RC_277_0 OAI22H $PINS O=n4883 A1=n4934 A2=n4882 B1=n4881 B2=n4880
XFE_OCPC3209_n5 BUF1CK $PINS O=FE_OCPN5687_n5 I=FE_OFN512_FE_DBTN82_n5
XFE_OCPC3208_n5 INV4 $PINS O=FE_OFN512_FE_DBTN82_n5 I=n5
XFE_OCPC3207_n5 INV2 $PINS O=FE_OFN3099_FE_DBTN82_n5 I=n5
XFE_RC_274_0 ND2 $PINS O=FE_RN_67_0 I1=n5635 I2=n5634
XFE_RC_273_0 OAI12HS $PINS O=n5650 A1=FE_RN_67_0 B1=N481 B2=n5442
XFE_RC_272_0 MOAI1 $PINS O=n5673 A1=N505 A2=n5678 B1=n5658 B2=n5657
XFE_OCPC3206_n1456 BUF1 $PINS O=FE_OCPN5686_n1456 I=FE_OCPN5685_n1456
XFE_OCPC3205_n1456 BUF2 $PINS O=FE_OCPN5685_n1456 I=n1456
XFE_OCPC3204_n1456 BUF4 $PINS O=FE_OFN2059_n1456 I=n1456
XFE_OCPC3203_n1456 BUF2 $PINS O=FE_OFN2058_n1456 I=n1456
XCTS_ccl_a_INV_clk_p_i_G0_L7_28 INV12CK $PINS O=CTS_62 I=clk_i_clone2
XCTS_ccl_a_INV_clk_p_i_G0_L7_27 INV12CK $PINS O=CTS_61 I=clk_i_clone4
XCTS_ccl_a_INV_clk_p_i_G0_L7_25 INV12CK $PINS O=CTS_60 I=clk_i_clone4
XCTS_ccl_a_INV_clk_p_i_G0_L7_24 INV12CK $PINS O=CTS_59 I=clk_i_clone6
XCTS_ccl_a_INV_clk_p_i_G0_L7_22 INV12CK $PINS O=CTS_58 I=clk_i_clone6
XCTS_ccl_a_INV_clk_p_i_G0_L7_17 INV12CK $PINS O=CTS_57 I=clk_i_clone11
XCTS_ccl_a_INV_clk_p_i_G0_L7_14 INV8CK $PINS O=CTS_56 I=clk_i_clone14
XCTS_ccl_a_INV_clk_p_i_G0_L7_13 INV12CK $PINS O=CTS_55 I=clk_i_clone14
XCTS_ccl_a_INV_clk_p_i_G0_L7_12 INV12CK $PINS O=CTS_53 I=CTS_54
XCTS_ccl_a_INV_clk_p_i_G0_L7_11 INV12CK $PINS O=CTS_52 I=CTS_54
XCTS_ccl_a_INV_clk_p_i_G0_L6_5 INV8CK $PINS O=CTS_54 I=clk_i_clone15
XCTS_ccl_a_INV_clk_p_i_G0_L7_8 INV12CK $PINS O=CTS_50 I=CTS_51
XCTS_ccl_a_INV_clk_p_i_G0_L7_7 INV12CK $PINS O=CTS_49 I=CTS_51
XCTS_ccl_a_INV_clk_p_i_G0_L6_3 INV8CK $PINS O=CTS_51 I=clk_i_clone18
XFE_OFC3202_FE_OFN520_FE_DBTN73_n1452 BUF1 $PINS
+ O=FE_OFN5684_FE_OFN520_FE_DBTN73_n1452 I=FE_OFN520_FE_DBTN73_n1452
XFE_RC_264_0 AN2 $PINS O=FE_RN_66_0 I1=n1588 I2=n1587
XFE_RC_263_0 ND2 $PINS O=N357 I1=FE_RN_66_0 I2=n1589
XFE_RC_256_0 OAI22S $PINS O=n4659 A1=n4656 A2=n4657 B1=n4857 B2=n4658
XFE_RC_246_0 INV2 $PINS O=FE_RN_64_0 I=n1185
XFE_RC_245_0 ND3P $PINS O=N505 I1=FE_RN_64_0 I2=n1186 I3=n1187
XFE_RC_242_0 OR3B2 $PINS O=n983 I1=FE_OFN5517_count_0 B1=n5510 B2=n3667
XFE_RC_241_0 MUX2 $PINS O=n5362 S=FE_OFN5554_n1457 A=n5295 B=FE_OFN2224_n5294
XFE_RC_232_0 AOI22S $PINS O=n4665 A1=n4661 A2=n4852 B1=n4659 B2=n4660
XFE_RC_229_0 MXL2HS $PINS OB=n4931 S=FE_DBTN77_n4833 A=n4807 B=n4777
XFE_RC_216_0 OA222 $PINS O=n5110 A1=n4989 A2=n4990 B1=n4992 B2=n4988 C1=n5113
+ C2=n4991
XFE_RC_214_0 OAI22H $PINS O=n4829 A1=n4715 A2=n4714 B1=n4713 B2=n4843
XFE_RC_212_0 OAI22H $PINS O=n5270 A1=n5155 A2=n5154 B1=n5153 B2=n5283
XFE_RC_210_0 ND2 $PINS O=FE_RN_59_0 I1=n5726 I2=n5725
XFE_RC_209_0 OAI12HS $PINS O=n5741 A1=FE_RN_59_0 B1=N553 B2=n5746
XFE_RC_197_0 OAI22S $PINS O=n4668 A1=n4664 A2=n4665 B1=n4837 B2=n4663
XFE_RC_195_0 INV1S $PINS O=FE_RN_58_0 I=n4708
XFE_RC_194_0 ND3P $PINS O=n4842 I1=n4707 I2=FE_RN_58_0 I3=n4706
XFE_RC_193_0 AOI22S $PINS O=n4657 A1=n4654 A2=n4860 B1=n4652 B2=n4653
XFE_RC_189_0 AOI22S $PINS O=n4940 A1=LLR_sum[1][2][11]
+ A2=FE_OFN1596_FE_DBTN86_n985 B1=LLR_sum[2][2][11] B2=FE_OFN1684_FE_DBTN85_n987
XFE_RC_188_0 OAI12HS $PINS O=n5328 A1=n5322 B1=n5323 B2=n5372
XFE_RC_184_0 AOI12HS $PINS O=FE_RN_57_0 A1=n4951 B1=LLR_sum[5][0][11]
+ B2=FE_OFN1494_n1442
XFE_RC_183_0 OR2B1T $PINS O=n5154 I1=n4950 B1=FE_RN_57_0
XFE_RC_182_0 INV1S $PINS O=n5271 I=FE_RN_56_0
XFE_RC_181_0 OAI222S $PINS O=FE_RN_56_0 A1=n5150 A2=n5151 B1=n5149 B2=n5282
+ C1=n5274 C2=n5152
XFE_RC_180_0 OAI22S $PINS O=FE_RN_54_0 A1=n4549 A2=n4550 B1=n4673 B2=n4551
XFE_RC_179_0 NR2 $PINS O=FE_RN_55_0 I1=n4840 I2=FE_OFN5541_n4841
XFE_RC_178_0 NR2 $PINS O=n4670 I1=FE_RN_54_0 I2=FE_RN_55_0
XFE_RC_174_0 INV1S $PINS O=FE_RN_53_0 I=n4547
XFE_RC_173_0 ND3P $PINS O=n4840 I1=FE_RN_53_0 I2=n4545 I3=n4546
XFE_RC_172_0 OAI22H $PINS O=n5322 A1=n5321 A2=n5373 B1=n5320 B2=n5319
XFE_RC_164_0 AOI22S $PINS O=n4890 A1=n4872 A2=n4929 B1=n4886 B2=n4931
XFE_RC_161_0 INV1S $PINS O=FE_RN_49_0 I=n4509
XFE_RC_160_0 ND3HT $PINS O=n4714 I1=n4508 I2=FE_RN_49_0 I3=n4507
XFE_RC_158_0 OR2P $PINS O=FE_RN_48_0 I1=n5370 I2=n5325
XFE_RC_157_0 ND2P $PINS O=n5327 I1=n5324 I2=FE_RN_48_0
XFE_RC_155_0 INV1S $PINS O=FE_RN_47_0 I=n5142
XFE_RC_154_0 ND3P $PINS O=n5283 I1=n5141 I2=n5140 I3=FE_RN_47_0
XFE_RC_152_0 AOI22S $PINS O=n4500 A1=LLR_sum[2][6][11]
+ A2=FE_OFN1682_FE_DBTN85_n987 B1=LLR_sum[1][6][11] B2=FE_OFN1591_FE_DBTN86_n985
XFE_RC_151_0 AOI22S $PINS O=FE_RN_45_0 A1=LLR_sum[3][6][11]
+ A2=FE_OFN1718_FE_DBTN71_n4217 B1=LLR_sum[4][6][11] B2=FE_OFN1846_n5509
XFE_RC_150_0 ND2P $PINS O=FE_RN_46_0 I1=LLR_sum[5][6][11] I2=FE_OFN1482_n1442
XFE_RC_149_0 ND2P $PINS O=n4501 I1=FE_RN_46_0 I2=FE_RN_45_0
XFE_RC_148_0 ND2 $PINS O=FE_RN_42_0 I1=LLR_sum[5][7][11] I2=FE_OFN1507_n1442
XFE_RC_147_0 ND2 $PINS O=FE_RN_43_0 I1=LLR_sum[3][7][11]
+ I2=FE_OFN5614_FE_OFN1728_FE_DBTN71_n4217
XFE_RC_146_0 ND2S $PINS O=FE_RN_44_0 I1=LLR_sum[4][7][11] I2=FE_OFN5566_n
XFE_RC_145_0 ND3 $PINS O=n4505 I1=FE_RN_44_0 I2=FE_RN_43_0 I3=FE_RN_42_0
XFE_RC_143_0 INV1S $PINS O=FE_RN_39_0 I=n4704
XFE_RC_142_0 ND2 $PINS O=FE_RN_40_0 I1=LLR_sum[5][5][10] I2=FE_OFN1508_n1442
XFE_RC_141_0 ND2S $PINS O=FE_RN_41_0 I1=FE_RN_40_0 I2=FE_RN_39_0
XFE_RC_140_0 OR2P $PINS O=n4843 I1=FE_RN_41_0 I2=n4703
XFE_RC_136_0 INV1S $PINS O=FE_RN_38_0 I=n4866
XFE_RC_135_0 MXL2HS $PINS OB=n4929 S=FE_DBTN77_n4833 A=FE_RN_38_0 B=n4764
XFE_RC_131_0 INV2 $PINS O=FE_RN_35_0 I=n5310
XFE_RC_130_0 INV1S $PINS O=FE_RN_36_0 I=n5311
XFE_RC_129_0 MXL2HS $PINS OB=n5370 S=FE_OFN2060_n1457 A=FE_RN_36_0 B=FE_RN_35_0
XFE_RC_128_0 AO12 $PINS O=FE_RN_34_0 A1=n4521 B1=LLR_sum[5][7][9]
+ B2=FE_OFN1516_n1442
XFE_RC_127_0 OR2 $PINS O=n4674 I1=FE_RN_34_0 I2=n4520
XFE_RC_120_0 INV1S $PINS O=FE_RN_28_0 I=n4515
XFE_RC_119_0 ND2 $PINS O=FE_RN_29_0 I1=LLR_sum[5][5][11] I2=FE_OFN1508_n1442
XFE_RC_118_0 ND2S $PINS O=FE_RN_30_0 I1=FE_RN_29_0 I2=FE_RN_28_0
XFE_RC_117_0 OR2T $PINS O=n4831 I1=FE_RN_30_0 I2=n4514
XFE_RC_113_0 MXL2HS $PINS OB=n5368 S=FE_OFN2060_n1457 A=n5439 B=n5204
XFE_RC_112_0 AOI112H $PINS O=n1456 A1=FE_RN_24_0 B1=FE_RN_25_0 C1=FE_RN_23_0
+ C2=FE_RN_22_0
XFE_RC_110_0 INV1S $PINS O=FE_RN_22_0 I=n5112
XFE_RC_109_0 INV1S $PINS O=FE_RN_23_0 I=FE_OFN2210_n5111
XFE_RC_108_0 NR2P $PINS O=FE_RN_24_0 I1=n5108 I2=n5107
XFE_RC_107_0 NR2P $PINS O=FE_RN_25_0 I1=n5109 I2=n5110
XFE_RC_101_0 INV1S $PINS O=FE_RN_20_0 I=n1585
XFE_RC_100_0 AN2B1S $PINS O=FE_RN_21_0 I1=n1584 B1=FE_RN_20_0
XFE_RC_99_0 ND2P $PINS O=N358 I1=n1586 I2=FE_RN_21_0
XFE_RC_98_0 ND3P $PINS O=n4833 I1=n1436 I2=n1437 I3=n1435
XFE_RC_97_0 OAI22HP $PINS O=n4669 A1=n4548 A2=n4552 B1=n4554 B2=n4553
XFE_RC_91_0 ND2 $PINS O=FE_RN_19_0 I1=FE_OFN520_FE_DBTN73_n1452 I2=n4931
XFE_RC_90_0 OAI12HS $PINS O=N2923 A1=FE_RN_19_0 B1=FE_OFN520_FE_DBTN73_n1452
+ B2=n4886
XFE_RC_89_0 INV1S $PINS O=FE_RN_17_0 I=n4505
XFE_RC_88_0 ND3P $PINS O=n4671 I1=FE_RN_17_0 I2=n4504 I3=n4503
XFE_RC_87_0 INV1S $PINS O=FE_RN_15_0 I=n4500
XFE_RC_86_0 NR2P $PINS O=FE_RN_16_0 I1=FE_RN_15_0 I2=n4501
XFE_RC_85_0 ND2T $PINS O=n4553 I1=FE_RN_16_0 I2=n4499
XFE_RC_83_0 INV1S $PINS O=FE_RN_14_0 I=n4941
XFE_RC_82_0 ND3HT $PINS O=n4993 I1=FE_RN_14_0 I2=n4940 I3=n4939
XFE_RC_81_0 MOAI1H $PINS O=n4909 A1=n4905 A2=n4904 B1=FE_RN_1_0 B2=FE_RN_0_0
XFE_RC_79_0 OAI22HP $PINS O=n5109 A1=n4994 A2=n4993 B1=FE_OFN5542_n5280
+ B2=FE_OFN5570_n5281
XFE_RC_78_0 INV1S $PINS O=FE_RN_12_0 I=n5359
XFE_RC_77_0 INV1S $PINS O=FE_RN_13_0 I=n5342
XFE_RC_76_0 MOAI1 $PINS O=n5348 A1=n5344 A2=n5343 B1=FE_RN_13_0 B2=FE_RN_12_0
XFE_RC_75_0 INV1S $PINS O=FE_RN_9_0 I=n5269
XFE_RC_74_0 INV1S $PINS O=FE_RN_10_0 I=n5268
XFE_RC_73_0 OAI22S $PINS O=FE_RN_11_0 A1=n5270 A2=n5271 B1=n5273
+ B2=FE_OFN5537_n5272
XFE_RC_72_0 AOI12H $PINS O=n1457 A1=FE_RN_11_0 B1=FE_RN_10_0 B2=FE_RN_9_0
XFE_RC_71_0 OAI12H $PINS O=n4889 A1=n4883 B1=n4884 B2=n4933
XFE_RC_65_0 AOI22H $PINS O=n4905 A1=n4921 A2=n4901 B1=n4899 B2=n4900
XFE_RC_63_0 AOI22H $PINS O=n4897 A1=n4894 A2=n4925 B1=n4892 B2=n4893
XFE_RC_57_0 AOI22S $PINS O=n5344 A1=n5360 A2=n5340 B1=n5338 B2=n5339
XFE_RC_55_0 INV1S $PINS O=FE_RN_5_0 I=n4924
XFE_RC_54_0 INV1S $PINS O=FE_RN_6_0 I=n4898
XFE_RC_53_0 MOAI1H $PINS O=n4899 A1=n4897 A2=n4896 B1=FE_RN_6_0 B2=FE_RN_5_0
XFE_RC_48_0 INV1S $PINS O=FE_RN_2_0 I=n5363
XFE_RC_47_0 INV1S $PINS O=FE_RN_3_0 I=n5337
XFE_RC_46_0 MOAI1 $PINS O=n5338 A1=n5336 A2=n5335 B1=FE_RN_3_0 B2=FE_RN_2_0
XFE_RC_44_0 INV1S $PINS O=FE_RN_0_0 I=n4920
XFE_RC_43_0 INV1S $PINS O=FE_RN_1_0 I=n4903
XFE_RC_41_0 OAI222H $PINS O=n4892 A1=n4888 A2=n4889 B1=n4891 B2=n4890 C1=n4887
+ C2=n4928
XFE_RC_40_0 OAI222H $PINS O=n1452 A1=n4908 A2=n4909 B1=n4911 B2=n4910 C1=n4914
+ C2=FE_OFN2218_n4912
XFE_OFC3103_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN3103_FE_DBTN86_n985
+ I=FE_OFN1643_FE_DBTN86_n985
XFE_OFC3200_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5682_n
+ I=FE_OFN1630_FE_DBTN86_n985
XFE_OFC3199_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5681_n
+ I=FE_OFN1637_FE_DBTN86_n985
XFE_OFC3102_n5509 BUF2 $PINS O=FE_OFN3102_n5509 I=FE_OFN1913_n5509
XFE_OFC3198_n5509 BUF4 $PINS O=FE_OFN5680_n I=FE_OFN1895_n5509
XFE_OFC3196_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5678_n
+ I=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985
XFE_OFC3195_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5677_n I=FE_OFN5676_n
XFE_OFC3194_FE_DBTN86_n985 BUF2 $PINS O=FE_OFN5676_n
+ I=FE_OFN1635_FE_DBTN86_n985
XFE_OFC3191_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5673_n
+ I=FE_OFN1607_FE_DBTN86_n985
XFE_OFC3190_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5672_n
+ I=FE_OFN1607_FE_DBTN86_n985
XFE_OFC3188_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5670_n
+ I=FE_OFN1625_FE_DBTN86_n985
XFE_OFC3186_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5668_n
+ I=FE_OFN1625_FE_DBTN86_n985
XFE_OFC3185_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN5667_n I=FE_OFN5666_n
XFE_OFC3184_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN5666_n
+ I=FE_OFN1673_FE_DBTN85_n987
XFE_OFC3183_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN5665_n I=FE_OFN5664_n
XFE_OFC3182_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN5664_n
+ I=FE_OFN1686_FE_DBTN85_n987
XFE_OFC3101_n5419 BUF1CK $PINS O=FE_OFN3101_n5419 I=FE_OFN1832_n5419
XFE_OFC3181_backward_metrics_6__2__0 BUF1 $PINS
+ O=FE_OFN5663_backward_metrics_6__2__0 I=backward_metrics[6][2][0]
XFE_OFC3180_backward_metrics_4__3__1 BUF1 $PINS
+ O=FE_OFN5662_backward_metrics_4__3__1 I=backward_metrics[4][3][1]
XFE_OFC3178_backward_metrics_3__0__3 BUF1 $PINS
+ O=FE_OFN5660_backward_metrics_3__0__3 I=backward_metrics[3][0][3]
XFE_OFC3177_forward_sum_0__2__3 BUF1 $PINS O=FE_OFN5659_forward_sum_0__2__3
+ I=forward_sum[0][2][3]
XFE_OFC3176_branch_metrics_5__0__4 BUF1 $PINS
+ O=FE_OFN5658_branch_metrics_5__0__4 I=branch_metrics[5][0][4]
XFE_OFC3175_branch_metrics_4__0__1 BUF1 $PINS
+ O=FE_OFN5657_branch_metrics_4__0__1 I=branch_metrics[4][0][1]
XFE_OFC3174_branch_metrics_1__0__4 BUF1 $PINS
+ O=FE_OFN5656_branch_metrics_1__0__4 I=branch_metrics[1][0][4]
XFE_OFC3173_FE_OFN1628_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5655_FE_OFN1628_FE_DBTN86_n985 I=FE_OFN1628_FE_DBTN86_n985
XFE_OFC3170_FE_OFN5518_count_0 BUF1 $PINS O=FE_OFN5652_FE_OFN5518_count_0
+ I=FE_OFN5518_count_0
XFE_OFC3100_branch_metrics_4_2_0 BUF2 $PINS O=FE_OFN3100_branch_metrics_4_2_0
+ I=branch_metrics[4][2][0]
XFE_OFC3169_forward_sum_0__2__0 BUF1 $PINS O=FE_OFN5651_forward_sum_0__2__0
+ I=forward_sum[0][2][0]
XFE_OFC3167_forward_sum_0__1__2 BUF1 $PINS O=FE_OFN5649_forward_sum_0__1__2
+ I=forward_sum[0][1][2]
XFE_OFC3166_forward_sum_0__1__3 BUF1 $PINS O=FE_OFN5648_forward_sum_0__1__3
+ I=forward_sum[0][1][3]
XFE_OFC3165_FE_OFN1530_n1442 INV2 $PINS O=FE_OFN5647_FE_OFN1530_n1442
+ I=FE_OFN5646_FE_OFN1530_n1442
XFE_OFC3164_FE_OFN1530_n1442 INV1S $PINS O=FE_OFN5646_FE_OFN1530_n1442
+ I=FE_OFN1530_n1442
XFE_OFC3163_FE_OFN1690_FE_DBTN85_n987 BUF1 $PINS
+ O=FE_OFN5645_FE_OFN1690_FE_DBTN85_n987 I=FE_OFN1690_FE_DBTN85_n987
XFE_OFC3162_FE_OFN1878_n5509 BUF1 $PINS O=FE_OFN5644_FE_OFN1878_n5509
+ I=FE_OFN1878_n5509
XFE_OFC3161_FE_OFN5534_n BUF1 $PINS O=FE_OFN5643_FE_OFN5534_n I=FE_OFN5534_n
XFE_OFC3160_backward_metrics_1__1__0 BUF1 $PINS
+ O=FE_OFN5642_backward_metrics_1__1__0 I=backward_metrics[1][1][0]
XFE_OFC3159_branch_metrics_4__0__0 BUF1 $PINS
+ O=FE_OFN5641_branch_metrics_4__0__0 I=branch_metrics[4][0][0]
XFE_OFC3158_branch_metrics_1__2__0 BUF1 $PINS
+ O=FE_OFN5640_branch_metrics_1__2__0 I=branch_metrics[1][2][0]
XFE_OFC3157_FE_OFN1526_n1442 BUF1 $PINS O=FE_OFN5639_FE_OFN1526_n1442
+ I=FE_OFN5637_FE_OFN1526_n1442
XFE_OFC3155_FE_OFN1526_n1442 BUF1 $PINS O=FE_OFN5637_FE_OFN1526_n1442
+ I=FE_OFN1526_n1442
XFE_OFC3154_FE_OFN1664_FE_DBTN85_n987 BUF1 $PINS
+ O=FE_OFN5636_FE_OFN1664_FE_DBTN85_n987 I=FE_OFN1664_FE_DBTN85_n987
XFE_OFC3153_FE_OFN1664_FE_DBTN85_n987 BUF1 $PINS
+ O=FE_OFN5635_FE_OFN1664_FE_DBTN85_n987 I=FE_OFN1664_FE_DBTN85_n987
XFE_OFC3152_FE_OFN1892_n5509 BUF1 $PINS O=FE_OFN5634_FE_OFN1892_n5509
+ I=FE_OFN1892_n5509
XFE_OFC3151_FE_OFN1905_n5509 INV1S $PINS O=FE_OFN5633_FE_OFN1905_n5509
+ I=FE_OFN5632_FE_OFN1905_n5509
XFE_OFC3150_FE_OFN1905_n5509 INV1S $PINS O=FE_OFN5632_FE_OFN1905_n5509
+ I=FE_OFN1905_n5509
XFE_OFC3149_FE_OFN1905_n5509 BUF1 $PINS O=FE_OFN5631_FE_OFN1905_n5509
+ I=FE_OFN1905_n5509
XFE_OFC3148_FE_OFN5539_n BUF1 $PINS O=FE_OFN5630_FE_OFN5539_n I=FE_OFN5539_n
XFE_OFC3146_FE_OFN1416_n1441 BUF1 $PINS O=FE_OFN5628_FE_OFN1416_n1441
+ I=FE_OFN1416_n1441
XFE_OFC3144_FE_OFN1416_n1441 BUF1 $PINS O=FE_OFN5626_FE_OFN1416_n1441
+ I=FE_OFN1416_n1441
XFE_OFC3143_FE_OFN1634_FE_DBTN86_n985 BUF2 $PINS
+ O=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985 I=FE_OFN1634_FE_DBTN86_n985
XFE_OFC3141_FE_OFN1634_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985 I=FE_OFN1634_FE_DBTN86_n985
XFE_OFC3140_FE_OFN1636_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5622_FE_OFN1636_FE_DBTN86_n985 I=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985
XFE_OFC3139_FE_OFN1636_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985 I=FE_OFN1636_FE_DBTN86_n985
XFE_OFC3138_FE_OFN1672_FE_DBTN85_n987 BUF1 $PINS
+ O=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987 I=FE_OFN1672_FE_DBTN85_n987
XFE_OFC3137_FE_OFN1672_FE_DBTN85_n987 BUF1 $PINS
+ O=FE_OFN5619_FE_OFN1672_FE_DBTN85_n987 I=FE_OFN1672_FE_DBTN85_n987
XFE_OFC3136_FE_OFN1724_FE_DBTN71_n4217 BUF1 $PINS
+ O=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217 I=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217
XFE_OFC3135_FE_OFN1724_FE_DBTN71_n4217 BUF1 $PINS
+ O=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217 I=FE_OFN1724_FE_DBTN71_n4217
XFE_OFC3134_FE_OFN1882_n5509 BUF1 $PINS O=FE_OFN5616_FE_OFN1882_n5509
+ I=FE_OFN1882_n5509
XFE_OFC3133_FE_OFN1882_n5509 BUF1 $PINS O=FE_OFN5615_FE_OFN1882_n5509
+ I=FE_OFN1882_n5509
XFE_OFC3132_FE_OFN1728_FE_DBTN71_n4217 BUF1 $PINS
+ O=FE_OFN5614_FE_OFN1728_FE_DBTN71_n4217 I=FE_OFN5613_FE_OFN1728_FE_DBTN71_n4217
XFE_OFC3131_FE_OFN1728_FE_DBTN71_n4217 BUF1 $PINS
+ O=FE_OFN5613_FE_OFN1728_FE_DBTN71_n4217 I=FE_OFN1728_FE_DBTN71_n4217
XFE_OFC3130_FE_OFN1828_n5419 BUF1 $PINS O=FE_OFN5612_FE_OFN1828_n5419
+ I=FE_OFN5611_FE_OFN1828_n5419
XFE_OFC3129_FE_OFN1828_n5419 BUF1 $PINS O=FE_OFN5611_FE_OFN1828_n5419
+ I=FE_OFN1828_n5419
XFE_OFC3128_FE_OFN1897_n5509 BUF3CK $PINS O=FE_OFN5610_FE_OFN1897_n5509
+ I=FE_OFN1897_n5509
XFE_OFC3126_FE_OFN1897_n5509 BUF1 $PINS O=FE_OFN5608_FE_OFN1897_n5509
+ I=FE_OFN1897_n5509
XFE_OFC3125_FE_OFN1897_n5509 BUF1 $PINS O=FE_OFN5607_FE_OFN1897_n5509
+ I=FE_OFN1897_n5509
XFE_OFC3124_FE_OFN1533_n1442 BUF1 $PINS O=FE_OFN5606_FE_OFN1533_n1442
+ I=FE_OFN5603_FE_OFN1533_n1442
XFE_OFC3122_FE_OFN1533_n1442 BUF1 $PINS O=FE_OFN5604_FE_OFN1533_n1442
+ I=FE_OFN1533_n1442
XFE_OFC3121_FE_OFN1533_n1442 BUF1 $PINS O=FE_OFN5603_FE_OFN1533_n1442
+ I=FE_OFN1533_n1442
XFE_OFC3118_FE_OFN1622_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985 I=FE_OFN5598_FE_OFN1622_FE_DBTN86_n985
XFE_OFC3117_FE_OFN1622_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5599_FE_OFN1622_FE_DBTN86_n985 I=FE_OFN5598_FE_OFN1622_FE_DBTN86_n985
XFE_OFC3116_FE_OFN1622_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5598_FE_OFN1622_FE_DBTN86_n985 I=FE_OFN1622_FE_DBTN86_n985
XFE_OFC3115_FE_OFN1915_n5509 BUF1 $PINS O=FE_OFN5597_FE_OFN1915_n5509
+ I=FE_OFN5594_FE_OFN1915_n5509
XFE_OFC3112_FE_OFN1915_n5509 BUF6CK $PINS O=FE_OFN5594_FE_OFN1915_n5509
+ I=FE_OFN1915_n5509
XFE_OFC3110_FE_OFN1915_n5509 BUF1 $PINS O=FE_OFN5592_FE_OFN1915_n5509
+ I=FE_OFN1915_n5509
XFE_OFC3109_FE_OFN5578_n BUF1 $PINS O=FE_OFN5591_FE_OFN5578_n
+ I=FE_OFN5589_FE_OFN5578_n
XFE_OFC3108_FE_OFN5578_n BUF1 $PINS O=FE_OFN5590_FE_OFN5578_n I=FE_OFN5578_n
XFE_OFC3107_FE_OFN5578_n BUF1 $PINS O=FE_OFN5589_FE_OFN5578_n I=FE_OFN5578_n
XFE_OFC3105_FE_OFN1620_FE_DBTN86_n985 BUF1 $PINS
+ O=FE_OFN5587_FE_OFN1620_FE_DBTN86_n985 I=FE_OFN5585_FE_OFN1620_FE_DBTN86_n985
XFE_OFC3104_FE_OFN1620_FE_DBTN86_n985 INV1S $PINS
+ O=FE_OFN5586_FE_OFN1620_FE_DBTN86_n985 I=FE_OFN5584_FE_OFN1620_FE_DBTN86_n985
XFE_OFC3103_FE_OFN1620_FE_DBTN86_n985 INV1S $PINS
+ O=FE_OFN5585_FE_OFN1620_FE_DBTN86_n985 I=FE_OFN5584_FE_OFN1620_FE_DBTN86_n985
XFE_OFC3102_FE_OFN1620_FE_DBTN86_n985 INV1S $PINS
+ O=FE_OFN5584_FE_OFN1620_FE_DBTN86_n985 I=FE_OFN1620_FE_DBTN86_n985
XFE_OFC3101_FE_OFN1388_n1441 BUF1CK $PINS O=FE_OFN5583_FE_OFN1388_n1441
+ I=FE_OFN1388_n1441
XFE_OFC3100_FE_OFN1388_n1441 BUF1 $PINS O=FE_OFN5582_FE_OFN1388_n1441
+ I=FE_OFN1388_n1441
XFE_OFC3099_FE_OFN1388_n1441 BUF1 $PINS O=FE_OFN5581_FE_OFN1388_n1441
+ I=FE_OFN1388_n1441
XFE_RC_39_0 MUX2 $PINS O=n2973 S=FE_OFN1343_n995 A=sys[5][2] B=sys_i[6]
XFE_RC_38_0 MUX2 $PINS O=n2974 S=FE_OFN1343_n995 A=sys[5][1] B=sys_i[5]
XFE_RC_37_0 MUX2 $PINS O=n2978 S=FE_OFN1336_n995 A=sys[6][1] B=sys_i[1]
XFE_RC_36_0 MUX2 $PINS O=n3038 S=FE_OFN1335_n995 A=ext[4][1] B=ext_i[25]
XFE_RC_35_0 MUX2 $PINS O=n3089 S=FE_OFN1322_n995 A=enc[5][0] B=enc_i[4]
XFE_RC_34_0 MUX2 $PINS O=n3092 S=FE_OFN1322_n995 A=enc[6][1] B=enc_i[1]
XFE_RC_33_0 MUX2 $PINS O=n3080 S=FE_OFN1309_n995 A=enc[3][1] B=enc_i[13]
XFE_RC_32_0 MUX2 $PINS O=n3086 S=FE_OFN1304_n995 A=enc[5][3] B=enc_i[7]
XFE_RC_31_0 MUX2 $PINS O=n3020 S=FE_OFN1286_n995 A=ext[3][7] B=ext_i[43]
XFE_RC_30_0 AO12 $PINS O=n1497 A1=n5650 B1=n5651 B2=n5649
XFE_RC_29_0 AOI12H $PINS O=N2299 A1=n5673 B1=n5674 B2=n5672
XFE_RC_28_0 AO12P $PINS O=n1455 A1=n5741 B1=n5742 B2=n5740
XFE_RC_27_0 AO12P $PINS O=n1454 A1=n5707 B1=n5708 B2=n5706
XFE_RC_26_0 AO12 $PINS O=n5645 A1=n1493 B1=n1492 B2=n5648
XFE_RC_25_0 AO12 $PINS O=n5736 A1=n1491 B1=n1490 B2=n5739
XFE_RC_24_0 AO12 $PINS O=n5702 A1=n1489 B1=n1488 B2=n5705
XFE_RC_23_0 AO12 $PINS O=n5668 A1=n1487 B1=n1486 B2=n5671
XFE_RC_22_0 AO12 $PINS O=n1513 A1=n5551 B1=n5552 B2=n5550
XFE_RC_21_0 AO12 $PINS O=n1502 A1=n5576 B1=n5577 B2=n5575
XFE_RC_20_0 AO12 $PINS O=n1503 A1=n5626 B1=n5627 B2=n5625
XFE_RC_19_0 AO12 $PINS O=n1501 A1=n5601 B1=n5602 B2=n5600
XFE_RC_18_0 MUX2 $PINS O=n2977 S=FE_OFN1343_n995 A=sys[6][2] B=sys_i[2]
XFE_RC_17_0 MUX2 $PINS O=n2976 S=FE_OFN1343_n995 A=sys[6][3] B=sys_i[3]
XFE_RC_16_0 MUX2 $PINS O=n2979 S=FE_OFN1336_n995 A=sys[6][0] B=sys_i[0]
XFE_RC_15_0 MUX2 $PINS O=n3026 S=FE_OFN1336_n995 A=ext[3][1] B=ext_i[37]
XFE_RC_14_0 MUX2 $PINS O=n3039 S=FE_OFN1335_n995 A=ext[4][0] B=ext_i[24]
XFE_RC_13_0 MUX2 $PINS O=n3091 S=FE_OFN1322_n995 A=enc[6][2] B=enc_i[2]
XFE_RC_12_0 MUX2 $PINS O=n3093 S=FE_OFN1322_n995 A=enc[6][0] B=enc_i[0]
XFE_RC_11_0 MUX2 $PINS O=n3087 S=FE_OFN1309_n995 A=enc[5][2] B=enc_i[6]
XFE_RC_10_0 MUX2 $PINS O=n3024 S=FE_OFN1311_n995 A=ext[3][3] B=ext_i[39]
XFE_RC_9_0 MUX2 $PINS O=n3084 S=FE_OFN1304_n995 A=enc[4][1] B=enc_i[9]
XFE_RC_8_0 MUX2 $PINS O=n3090 S=FE_OFN1304_n995 A=enc[6][3] B=enc_i[3]
XFE_RC_7_0 MUX2 $PINS O=n3035 S=FE_OFN1306_n995 A=ext[4][4] B=ext_i[28]
XFE_RC_6_0 AN2B1S $PINS O=n3046 I1=ext[5][5] B1=FE_OFN1300_n995
XFE_RC_5_0 AN2B1S $PINS O=n3057 I1=ext[6][6] B1=FE_OFN1296_n995
XFE_RC_4_0 MUX2 $PINS O=n3017 S=FE_OFN1290_n995 A=ext[3][10] B=ext_i[46]
XFE_RC_3_0 MUX2 $PINS O=n3044 S=FE_OFN1292_n995 A=ext[5][7] B=FE_OFN1355_n1
XFE_RC_2_0 MUX2 $PINS O=n3031 S=FE_OFN1286_n995 A=ext[4][8] B=ext_i[32]
XFE_RC_1_0 MUX2 $PINS O=n3029 S=FE_OFN1284_n995 A=ext[4][10] B=ext_i[34]
XFE_RC_0_0 MUX2 $PINS O=n3030 S=FE_OFN1286_n995 A=ext[4][9] B=ext_i[33]
XFE_OFC3098_n5296 INV1S $PINS O=FE_OFN5580_n5296 I=n5098
XFE_OFC3097_n5296 INV3 $PINS O=n5098 I=n5296
XFE_OFC3096_n4674 INV1S $PINS O=FE_OFN5579_n4674 I=n4551
XFE_OFC3095_n4674 INV3 $PINS O=n4551 I=n4674
XFE_OFC3094_n4992 INV2 $PINS O=FE_OFN5542_n5280 I=n4992
XFE_OFC3093_n987 BUF2 $PINS O=FE_OFN5578_n I=FE_OFN1662_FE_DBTN85_n987
XFE_OFC3092_n987 BUF1 $PINS O=FE_OFN1658_FE_DBTN85_n987
+ I=FE_OFN1660_FE_DBTN85_n987
XFE_OFC3091_n987 INV1S $PINS O=FE_OFN1662_FE_DBTN85_n987 I=FE_DBTN85_n987
XFE_OFC3090_n987 INV2 $PINS O=FE_OFN1660_FE_DBTN85_n987 I=FE_DBTN85_n987
XFE_OFC3089_n987 INV3 $PINS O=FE_DBTN85_n987 I=FE_OFN1455_n987
XFE_OFC3087_n BUF2 $PINS O=FE_OFN5577_n I=FE_OFN1824_n5419
XFE_OFC3086_n BUF1 $PINS O=FE_OFN1831_n5419 I=FE_OFN1824_n5419
XFE_OFC3085_n BUF1 $PINS O=FE_OFN1829_n5419 I=FE_OFN5526_n
XFE_OFC3084_n BUF2 $PINS O=FE_OFN1824_n5419 I=FE_OFN5526_n
XFE_OFC3083_n1442 INV2 $PINS O=FE_OFN5576_n I=FE_OFN1496_n1442
XFE_OFC3080_n1442 INV2 $PINS O=FE_OFN1496_n1442 I=FE_OFN1491_n1442
XFE_OFC3079_n1442 BUF1 $PINS O=FE_OFN1532_n1442 I=FE_OFN1491_n1442
XFE_OFC3078_n5509 BUF1 $PINS O=FE_OFN5575_n I=FE_OFN5574_n
XFE_OFC3077_n5509 BUF3CK $PINS O=FE_OFN5574_n I=FE_OFN1866_n5509
XFE_OFC3076_n5509 BUF1 $PINS O=FE_OFN1910_n5509 I=FE_OFN1866_n5509
XFE_OFC3075_n5509 INV2 $PINS O=FE_OFN1904_n5509 I=FE_OFN1850_n5509
XFE_OFC3074_n5509 INV3 $PINS O=FE_OFN1866_n5509 I=FE_OFN1850_n5509
XFE_OFC3073_n5509 BUF1 $PINS O=FE_OFN1855_n5509 I=FE_OFN1850_n5509
XFE_OFC3071_branch_metrics_2__2__2 BUF1 $PINS
+ O=FE_OFN810_branch_metrics_2__2__2 I=branch_metrics[2][2][2]
XFE_OFC3068_n INV1S $PINS O=FE_OFN1826_n5419 I=FE_OFN5526_n
XFE_OFC3065_n4856 INV1S $PINS O=n4658 I=n4856
XFE_OFC3057_branch_metrics_3__1__1 BUF2 $PINS
+ O=FE_OFN847_branch_metrics_3__1__1 I=branch_metrics[3][1][1]
XFE_OFC3056_n4927 INV1S $PINS O=n4887 I=n4927
XFE_OFC3047_n4864 INV1S $PINS O=n4647 I=n4864
XFE_OFC3044_n4862 INV1S $PINS O=FE_OFN5573_n4862 I=n4808
XFE_OFC3043_n4862 INV3 $PINS O=n4808 I=n4862
XFE_OFC3042_n4838 INV1S $PINS O=n4822 I=n4838
XFE_OFC3041_n5302 INV3 $PINS O=n5248 I=n5302
XFE_OFC3036_n5267 INV1S $PINS O=n5151 I=n5267
XFE_OFC3035_branch_metrics_1__1__1 BUF3 $PINS
+ O=FE_OFN751_branch_metrics_1__1__1 I=branch_metrics[1][1][1]
XFE_OFC3034_n1441 INV2 $PINS O=FE_OFN5572_n1441 I=FE_OFN1365_n1441
XFE_OFC3032_n1441 INV1S $PINS O=FE_OFN1366_n1441 I=FE_OFN1365_n1441
XFE_OFC3031_n1441 INV1S $PINS O=FE_OFN1363_n1441 I=FE_OFN1369_n1441
XFE_OFC3029_n1441 INV1S $PINS O=FE_OFN1365_n1441 I=n1441
XFE_OFC3028_n1441 BUF1 $PINS O=FE_OFN1369_n1441 I=n1441
XFE_OFC3026_n5375 INV3 $PINS O=n5084 I=n5375
XFE_OFC3024_branch_metrics_5__3__2 BUF1 $PINS
+ O=FE_OFN965_branch_metrics_5__3__2 I=branch_metrics[5][3][2]
XFE_OFC3022_n5366 INV1S $PINS O=n5326 I=n5366
XFE_OFC3020_branch_metrics_2__0__2 BUF1 $PINS
+ O=FE_OFN786_branch_metrics_2__0__2 I=branch_metrics[2][0][2]
XFE_OFC3015_n5314 INV1S $PINS O=n5231 I=n5314
XFE_OFC3014_n5281 INV1S $PINS O=FE_OFN5571_n5281 I=n4988
XFE_OFC3013_n5281 INV2 $PINS O=FE_OFN5570_n5281 I=n4988
XFE_OFC3012_n5281 INV2CK $PINS O=n4988 I=n5281
XFE_OFC3006_n5365 INV1S $PINS O=n5333 I=n5365
XFE_OFC3000_n4840 INV2CK $PINS O=n4552 I=n4840
XFE_OFC2996_n BUF2 $PINS O=FE_OFN5569_n I=FE_OFN1813_n5419
XFE_OFC2995_n BUF1 $PINS O=FE_OFN5568_n I=FE_OFN1822_n5419
XFE_OFC2994_n BUF2 $PINS O=FE_OFN1813_n5419 I=FE_OFN5528_n
XFE_OFC2993_n INV2 $PINS O=FE_OFN1822_n5419 I=FE_OFN1819_n5419
XFE_OFC2992_n INV1S $PINS O=FE_OFN5528_n I=FE_OFN1819_n5419
XFE_OFC2991_n INV1S $PINS O=FE_OFN1819_n5419 I=FE_OFN5525_n
XFE_OFC2990_backward_metrics_1__3__0 BUF1 $PINS
+ O=FE_OFN1057_backward_metrics_1__3__0 I=backward_metrics[1][3][0]
XFE_OFC2989_FE_DBTN85_n987 BUF2 $PINS O=FE_OFN5564_n
+ I=FE_OFN1693_FE_DBTN85_n987
XFE_OFC2988_FE_DBTN85_n987 BUF2 $PINS O=FE_OFN1693_FE_DBTN85_n987
+ I=FE_OFN1688_FE_DBTN85_n987
XFE_OFC2987_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1680_FE_DBTN85_n987
+ I=FE_OFN1669_FE_DBTN85_n987
XFE_OFC2986_FE_DBTN85_n987 BUF2CK $PINS O=FE_OFN1681_FE_DBTN85_n987
+ I=FE_OFN1669_FE_DBTN85_n987
XFE_OFC2985_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1688_FE_DBTN85_n987
+ I=FE_OFN1669_FE_DBTN85_n987
XFE_OFC2984_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1620_FE_DBTN86_n985
+ I=FE_OFN1596_FE_DBTN86_n985
XFE_OFC2983_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5550_n
+ I=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985
XFE_OFC2982_FE_DBTN86_n985 BUF6 $PINS O=FE_OFN1608_FE_DBTN86_n985
+ I=FE_OFN1627_FE_DBTN86_n985
XFE_OFC2981_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5519_n
+ I=FE_OFN1627_FE_DBTN86_n985
XFE_OFC2980_FE_DBTN86_n985 INV2 $PINS O=FE_OFN1604_FE_DBTN86_n985
+ I=FE_OFN1627_FE_DBTN86_n985
XFE_OFC2979_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1596_FE_DBTN86_n985
+ I=FE_OFN1627_FE_DBTN86_n985
XFE_OFC2977_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1624_FE_DBTN86_n985
+ I=FE_OFN1626_FE_DBTN86_n985
XFE_OFC2975_FE_DBTN86_n985 INV2 $PINS O=FE_OFN1627_FE_DBTN86_n985
+ I=FE_OFN1588_FE_DBTN86_n985
XFE_OFC2973_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1625_FE_DBTN86_n985
+ I=FE_OFN1588_FE_DBTN86_n985
XFE_OFC2972_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1626_FE_DBTN86_n985
+ I=FE_OFN1588_FE_DBTN86_n985
XFE_OFC2971_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1634_FE_DBTN86_n985
+ I=FE_OFN1588_FE_DBTN86_n985
XFE_OFC2970_n5313 INV2 $PINS O=FE_OFN2208_n5313 I=n5244
XFE_OFC2969_n5313 INV3 $PINS O=n5244 I=n5313
XFE_OFC2968_n3782 BUF1 $PINS O=FE_OFN5567_n I=FE_OFN1859_n5509
XFE_OFC2967_n3782 BUF1 $PINS O=FE_OFN5566_n I=FE_OFN1856_n5509
XFE_OFC2966_n3782 INV1S $PINS O=FE_OFN1868_n5509 I=FE_OFN1855_n5509
XFE_OFC2965_n3782 INV1S $PINS O=FE_OFN5511_n I=FE_OFN1855_n5509
XFE_OFC2964_n3782 INV2 $PINS O=FE_OFN1859_n5509 I=FE_OFN1850_n5509
XFE_OFC2963_n3782 INV1S $PINS O=FE_OFN1856_n5509 I=FE_OFN1850_n5509
XFE_OFC2960_n3782 INV1S $PINS O=FE_OFN1852_n5509 I=FE_OFN1850_n5509
XFE_OFC2958_n3782 BUF2 $PINS O=FE_OFN1848_n5509 I=FE_OFN1896_n5509
XFE_OFC2957_n3782 INV3 $PINS O=FE_OFN1850_n5509 I=FE_OFN1563_n3782
XFE_OFC2956_n3782 INV1S $PINS O=FE_OFN1896_n5509 I=FE_OFN1563_n3782
XFE_OFC2954_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN5565_n I=FE_OFN5564_n
XFE_OFC2946_branch_metrics_4__2__5 BUF1 $PINS
+ O=FE_OFN903_branch_metrics_4__2__5 I=branch_metrics[4][2][5]
XFE_OFC2945_branch_metrics_4__2__2 BUF1 $PINS
+ O=FE_OFN906_branch_metrics_4__2__2 I=branch_metrics[4][2][2]
XFE_OFC2935_n BUF1 $PINS O=FE_OFN1837_n5419 I=FE_OFN5568_n
XFE_OFC2933_n BUF1 $PINS O=FE_OFN1812_n5419 I=FE_OFN5568_n
XFE_OFC2931_branch_metrics_5__1__1 BUF2 $PINS
+ O=FE_OFN943_branch_metrics_5__1__1 I=branch_metrics[5][1][1]
XFE_OFC2924_n INV1S $PINS O=FE_OFN5563_n I=FE_OFN1652_FE_DBTN86_n985
XFE_OFC2923_n BUF2 $PINS O=FE_OFN1653_FE_DBTN86_n985
+ I=FE_OFN1650_FE_DBTN86_n985
XFE_OFC2922_n BUF1 $PINS O=FE_OFN1652_FE_DBTN86_n985
+ I=FE_OFN1650_FE_DBTN86_n985
XFE_OFC2921_n INV2 $PINS O=FE_OFN1650_FE_DBTN86_n985 I=FE_OFN5535_n
XFE_OFC2920_n1442 BUF2 $PINS O=FE_OFN5562_n I=FE_OFN5561_n
XFE_OFC2919_n1442 INV2 $PINS O=FE_OFN5561_n I=FE_OFN1550_n1442
XFE_OFC2917_n1442 INV1S $PINS O=FE_OFN1558_n1442 I=FE_OFN1550_n1442
XFE_OFC2916_n1442 INV1S $PINS O=FE_OFN1557_n1442 I=FE_OFN1550_n1442
XFE_OFC2915_n1442 INV1S $PINS O=FE_OFN1553_n1442 I=FE_OFN1550_n1442
XFE_OFC2914_n1442 INV4 $PINS O=FE_OFN1550_n1442 I=FE_OFN1543_n1442
XFE_OFC2913_branch_metrics_5__1__2 BUF1 $PINS
+ O=FE_OFN942_branch_metrics_5__1__2 I=branch_metrics[5][1][2]
XFE_OFC2911_n5275 INV2 $PINS O=n5152 I=n5275
XFE_OFC2904_FE_DBTN88_n1454 BUF6CK $PINS O=FE_OFN1429_FE_DBTN88_n1454
+ I=FE_DBTN88_n1454
XFE_OFC2903_FE_DBTN88_n1454 BUF1CK $PINS O=FE_OFN1425_n1454 I=FE_DBTN88_n1454
XFE_OFC2898_n1442 INV1S $PINS O=FE_OFN5559_n I=FE_OFN1542_n1442
XFE_OFC2895_n1442 INV3 $PINS O=FE_OFN1542_n1442 I=FE_OFN1537_n1442
XFE_OFC2894_n1442 BUF2 $PINS O=FE_OFN1537_n1442 I=FE_OFN5544_n
XFE_OFC2893_n1442 INV1S $PINS O=FE_OFN5545_n I=FE_OFN1505_n1442
XFE_OFC2892_n1442 INV2 $PINS O=FE_OFN5544_n I=FE_OFN1505_n1442
XFE_OFC2891_n4699 INV1S $PINS O=n4700 I=n4699
XFE_OFC2890_n4854 INV1S $PINS O=FE_OFN5556_n4854 I=n4818
XFE_OFC2889_n4854 INV2 $PINS O=n4818 I=n4854
XFE_OFC2883_n4825 INV2CK $PINS O=n4711 I=n4825
XFE_OFC2878_n5357 INV1S $PINS O=n5287 I=n5357
XFE_OFC2873_n INV2 $PINS O=FE_OFN1821_n5419 I=FE_OFN1826_n5419
XFE_OFC2871_n BUF1 $PINS O=FE_OFN1818_n5419 I=FE_OFN5526_n
XFE_OFC2869_n5358 INV2 $PINS O=n5342 I=n5358
XFE_OFC2867_forward_sum_0__2__2 BUF1 $PINS O=FE_OFN987_forward_sum_0__2__2
+ I=forward_sum[0][2][2]
XFE_OFC2866_branch_metrics_2__3__3 BUF1CK $PINS
+ O=FE_OFN5555_branch_metrics_2__3__3 I=branch_metrics[2][3][3]
XFE_OFC2862_branch_metrics_5__3__3 BUF1 $PINS
+ O=FE_OFN964_branch_metrics_5__3__3 I=branch_metrics[5][3][3]
XFE_OFC2860_branch_metrics_2__0__1 BUF1 $PINS
+ O=FE_OFN787_branch_metrics_2__0__1 I=branch_metrics[2][0][1]
XFE_OFC2859_backward_metrics_3__1__1 BUF1 $PINS
+ O=FE_OFN1128_backward_metrics_3__1__1 I=backward_metrics[3][1][1]
XFE_OFC2858_n5509 BUF4CK $PINS O=FE_OFN5523_n I=FE_OFN1919_n5509
XFE_OFC2857_n5509 BUF1 $PINS O=FE_OFN5522_n I=FE_OFN1919_n5509
XFE_OFC2856_n5509 INV3 $PINS O=FE_OFN1919_n5509 I=FE_OFN1920_n5509
XFE_OFC2854_n1442 INV1S $PINS O=FE_OFN1533_n1442 I=FE_OFN1496_n1442
XFE_OFC2853_n1442 INV1S $PINS O=FE_OFN1530_n1442 I=FE_OFN1496_n1442
XFE_OFC2852_n1442 BUF1 $PINS O=FE_OFN1526_n1442 I=FE_OFN1509_n1442
XFE_OFC2851_n1442 INV2 $PINS O=FE_OFN1525_n1442 I=FE_OFN1509_n1442
XFE_OFC2850_n1442 BUF1 $PINS O=FE_OFN1519_n1442 I=FE_OFN5576_n
XFE_OFC2849_n1442 BUF1 $PINS O=FE_OFN1517_n1442 I=FE_OFN5576_n
XFE_OFC2847_n1442 INV1S $PINS O=FE_OFN1509_n1442 I=FE_OFN1496_n1442
XFE_OFC2845_branch_metrics_5__0__2 BUF1 $PINS
+ O=FE_OFN930_branch_metrics_5__0__2 I=branch_metrics[5][0][2]
XFE_OFC2844_n1457 BUF1 $PINS O=FE_OFN5554_n1457 I=n1457
XFE_OFC2843_n1457 BUF6 $PINS O=FE_OFN2060_n1457 I=n1457
XFE_OFC2842_branch_metrics_2__3__2 BUF1 $PINS
+ O=FE_OFN5553_branch_metrics_2__3__2 I=branch_metrics[2][3][2]
XFE_OFC2841_n1441 BUF1 $PINS O=FE_OFN5552_n I=FE_OFN1416_n1441
XFE_OFC2840_n1441 BUF1 $PINS O=FE_OFN5551_n I=FE_OFN5581_FE_OFN1388_n1441
XFE_OFC2838_n1441 INV2 $PINS O=FE_OFN1388_n1441 I=FE_OFN1375_n1441
XFE_OFC2836_n1441 BUF1 $PINS O=FE_OFN1386_n1441 I=FE_OFN1393_n1441
XFE_OFC2834_n1441 INV1S $PINS O=FE_OFN1416_n1441 I=FE_OFN1375_n1441
XFE_OFC2832_n1441 INV2 $PINS O=FE_OFN1393_n1441 I=FE_OFN1375_n1441
XFE_OFC2831_n4833 BUF6 $PINS O=FE_DBTN77_n4833 I=FE_OFN516_FE_DBTN77_n4833
XFE_OFC2830_n4833 INV3 $PINS O=FE_OFN516_FE_DBTN77_n4833 I=n4833
XFE_OFC2826_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1622_FE_DBTN86_n985
+ I=FE_OFN1626_FE_DBTN86_n985
XFE_OFC2823_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1610_FE_DBTN86_n985
+ I=FE_OFN1608_FE_DBTN86_n985
XFE_OFC2819_n5509 BUF1 $PINS O=FE_OFN5510_n I=FE_OFN1872_n5509
XFE_OFC2818_n5509 BUF1 $PINS O=FE_OFN1883_n5509 I=FE_OFN1904_n5509
XFE_OFC2817_n5509 BUF1 $PINS O=FE_OFN1882_n5509 I=FE_OFN1861_n5509
XFE_OFC2816_n5509 BUF1 $PINS O=FE_OFN1873_n5509 I=FE_OFN1861_n5509
XFE_OFC2814_n5509 INV2 $PINS O=FE_OFN1872_n5509 I=FE_OFN1896_n5509
XFE_OFC2811_n5509 INV1S $PINS O=FE_OFN1861_n5509 I=FE_OFN1896_n5509
XFE_OFC2810_n5509 BUF1 $PINS O=FE_OFN1880_n5509 I=FE_OFN1896_n5509
XFE_OFC2808_n4918 INV1S $PINS O=n4847 I=n4918
XFE_OFC2805_n5278 INV2 $PINS O=n5264 I=n5278
XFE_OFC2804_backward_metrics_1__1__1 BUF1 $PINS
+ O=FE_OFN1032_backward_metrics_1__1__1 I=backward_metrics[1][1][1]
XFE_OFC2800_n987 BUF1 $PINS O=FE_OFN1659_FE_DBTN85_n987
+ I=FE_OFN1660_FE_DBTN85_n987
XFE_OFC2793_n4926 INV1S $PINS O=n4894 I=n4926
XFE_OFC2792_n5304 INV1S $PINS O=FE_OFN5549_n5304 I=n5087
XFE_OFC2791_n5304 INV3 $PINS O=n5087 I=n5304
XFE_OFC2788_backward_metrics_3__2__0 BUF1 $PINS
+ O=FE_OFN1141_backward_metrics_3__2__0 I=backward_metrics[3][2][0]
XFE_OFC2786_backward_metrics_4__0__0 BUF1 $PINS
+ O=FE_OFN5548_backward_metrics_4__0__0 I=backward_metrics[4][0][0]
XFE_OFC2784_branch_metrics_4__0__2 BUF1 $PINS
+ O=FE_OFN882_branch_metrics_4__0__2 I=branch_metrics[4][0][2]
XFE_OFC2783_backward_metrics_6__3__0 BUF1CK $PINS
+ O=FE_OFN5547_backward_metrics_6__3__0 I=backward_metrics[6][3][0]
XFE_OFC2780_backward_metrics_4__3__0 BUF1 $PINS
+ O=FE_OFN1201_backward_metrics_4__3__0 I=backward_metrics[4][3][0]
XFE_OFC2775_backward_metrics_3__2__1 BUF1 $PINS
+ O=FE_OFN1140_backward_metrics_3__2__1 I=backward_metrics[3][2][1]
XFE_OFC2774_backward_metrics_3__0__0 BUF1 $PINS
+ O=FE_OFN1117_backward_metrics_3__0__0 I=backward_metrics[3][0][0]
XFE_OFC2773_backward_metrics_5__2__0 BUF1 $PINS
+ O=FE_OFN1237_backward_metrics_5__2__0 I=backward_metrics[5][2][0]
XFE_OFC2772_branch_metrics_1__0__2 BUF1 $PINS
+ O=FE_OFN738_branch_metrics_1__0__2 I=branch_metrics[1][0][2]
XFE_OFC2765_n1442 INV3 $PINS O=FE_OFN1505_n1442 I=FE_OFN1499_n1442
XFE_OFC2763_n5362 INV1S $PINS O=n5337 I=n5362
XFE_OFC2757_forward_sum_0__1__1 BUF1 $PINS O=FE_OFN978_forward_sum_0__1__1
+ I=forward_sum[0][1][1]
XFE_OFC2755_branch_metrics_5__3__0 BUF2 $PINS
+ O=FE_OFN967_branch_metrics_5__3__0 I=branch_metrics[5][3][0]
XFE_OFC2752_n5280 BUF4 $PINS O=n4992 I=n5280
XFE_OFC2749_n5364 INV1S $PINS O=n5334 I=n5364
XFE_OFC2746_branch_metrics_2__3__0 BUF2 $PINS
+ O=FE_OFN824_branch_metrics_2__3__0 I=branch_metrics[2][3][0]
XFE_OFC2745_n1441 BUF1CK $PINS O=FE_OFN1400_n1441 I=FE_OFN5583_FE_OFN1388_n1441
XFE_OFC2739_n4841 INV1S $PINS O=FE_OFN5541_n4841 I=n4548
XFE_OFC2738_n4841 BUF3 $PINS O=n4548 I=n4841
XFE_OFC2732_branch_metrics_2__2__1 BUF1 $PINS
+ O=FE_OFN811_branch_metrics_2__2__1 I=branch_metrics[2][2][1]
XFE_OFC2731_backward_metrics_2__1__1 BUF1 $PINS
+ O=FE_OFN1080_backward_metrics_2__1__1 I=backward_metrics[2][1][1]
XFE_OFC2729_n1441 INV1S $PINS O=FE_OFN5540_n I=FE_OFN1378_n1441
XFE_OFC2726_n1441 INV1S $PINS O=FE_OFN1385_n1441 I=FE_OFN1378_n1441
XFE_OFC2722_backward_metrics_5__2__1 BUF1 $PINS
+ O=FE_OFN1236_backward_metrics_5__2__1 I=backward_metrics[5][2][1]
XFE_OFC2720_branch_metrics_5__2__1 BUF1 $PINS
+ O=FE_OFN954_branch_metrics_5__2__1 I=branch_metrics[5][2][1]
XFE_OFC2719_backward_metrics_2__2__0 BUF1 $PINS
+ O=FE_OFN1093_backward_metrics_2__2__0 I=backward_metrics[2][2][0]
XFE_OFC2718_branch_metrics_1__1__5 BUF1 $PINS
+ O=FE_OFN747_branch_metrics_1__1__5 I=branch_metrics[1][1][5]
XFE_OFC2717_backward_metrics_4__1__1 BUF1 $PINS
+ O=FE_OFN1176_backward_metrics_4__1__1 I=backward_metrics[4][1][1]
XFE_OFC2716_backward_metrics_4__0__1 BUF1 $PINS
+ O=FE_OFN1164_backward_metrics_4__0__1 I=backward_metrics[4][0][1]
XFE_OFC2715_branch_metrics_5__0__1 BUF1 $PINS
+ O=FE_OFN931_branch_metrics_5__0__1 I=branch_metrics[5][0][1]
XFE_OFC2714_backward_metrics_6__1__1 BUF1 $PINS
+ O=FE_OFN1261_backward_metrics_6__1__1 I=backward_metrics[6][1][1]
XFE_OFC2713_n4835 INV2CK $PINS O=n4712 I=n4835
XFE_OFC2710_backward_metrics_1__0__2 BUF1 $PINS
+ O=FE_OFN1019_backward_metrics_1__0__2 I=backward_metrics[1][0][2]
XFE_OFC2709_branch_metrics_4__1__4 BUF1 $PINS
+ O=FE_OFN892_branch_metrics_4__1__4 I=branch_metrics[4][1][4]
XFE_OFC2708_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN5539_n
+ I=FE_OFN1723_FE_DBTN71_n4217
XFE_OFC2707_FE_DBTN71_n4217 BUF2 $PINS O=FE_OFN1725_FE_DBTN71_n4217
+ I=FE_OFN1711_FE_DBTN71_n4217
XFE_OFC2706_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1723_FE_DBTN71_n4217
+ I=FE_OFN1711_FE_DBTN71_n4217
XFE_OFC2705_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1719_FE_DBTN71_n4217
+ I=FE_OFN1711_FE_DBTN71_n4217
XFE_OFC2704_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1717_FE_DBTN71_n4217
+ I=FE_OFN1711_FE_DBTN71_n4217
XFE_OFC2703_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN1715_FE_DBTN71_n4217
+ I=FE_OFN1706_FE_DBTN71_n4217
XFE_OFC2702_FE_DBTN71_n4217 INV2 $PINS O=FE_OFN1711_FE_DBTN71_n4217
+ I=FE_OFN1731_FE_DBTN71_n4217
XFE_OFC2700_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN1706_FE_DBTN71_n4217
+ I=FE_OFN1731_FE_DBTN71_n4217
XFE_OFC2699_FE_DBTN71_n4217 BUF1 $PINS O=FE_DBTN71_n4217
+ I=FE_OFN1731_FE_DBTN71_n4217
XFE_OFC2698_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN1722_FE_DBTN71_n4217
+ I=FE_OFN1731_FE_DBTN71_n4217
XFE_OFC2694_backward_metrics_1__2__0 BUF1 $PINS
+ O=FE_OFN1045_backward_metrics_1__2__0 I=backward_metrics[1][2][0]
XFE_OFC2693_backward_metrics_5__0__0 BUF1CK $PINS
+ O=FE_OFN1213_backward_metrics_5__0__0 I=backward_metrics[5][0][0]
XFE_OFC2692_n5290 INV1S $PINS O=n5263 I=n5290
XFE_OFC2691_backward_metrics_4__2__1 BUF1 $PINS
+ O=FE_OFN1188_backward_metrics_4__2__1 I=backward_metrics[4][2][1]
XFE_OFC2688_n1442 BUF1 $PINS O=FE_OFN1539_n1442 I=FE_OFN5603_FE_OFN1533_n1442
XFE_OFC2686_backward_metrics_2__1__0 BUF1 $PINS
+ O=FE_OFN1081_backward_metrics_2__1__0 I=backward_metrics[2][1][0]
XFE_OFC2685_n5272 INV1S $PINS O=FE_OFN5537_n5272 I=n5155
XFE_OFC2683_n5272 INV2CK $PINS O=n5155 I=n5272
XFE_OFC2682_FE_DBTN86_n985 INV4 $PINS O=FE_OFN5535_n I=FE_OFN5534_n
XFE_OFC2681_FE_DBTN86_n985 INV2 $PINS O=FE_OFN5534_n
+ I=FE_OFN1608_FE_DBTN86_n985
XFE_OFC2680_FE_DBTN86_n985 INV1S $PINS O=FE_OFN5533_n
+ I=FE_OFN1608_FE_DBTN86_n985
XFE_OFC2679_FE_DBTN86_n985 INV1S $PINS O=FE_OFN5532_n
+ I=FE_OFN1608_FE_DBTN86_n985
XFE_OFC2678_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1644_FE_DBTN86_n985
+ I=FE_OFN1608_FE_DBTN86_n985
XFE_OFC2677_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1641_FE_DBTN86_n985
+ I=FE_OFN1608_FE_DBTN86_n985
XFE_OFC2676_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1640_FE_DBTN86_n985
+ I=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985
XFE_OFC2671_backward_metrics_2__0__1 BUF1 $PINS
+ O=FE_OFN1068_backward_metrics_2__0__1 I=backward_metrics[2][0][1]
XFE_OFC2667_n5282 INV1CK $PINS O=n5153 I=n5282
XFE_OFC2664_backward_metrics_1__0__1 BUF1 $PINS
+ O=FE_OFN1020_backward_metrics_1__0__1 I=backward_metrics[1][0][1]
XFE_OFC2663_n5375 INV1S $PINS O=FE_OFN5529_n5375 I=n5084
XFE_OFC2660_n5419 BUF1 $PINS O=FE_OFN5527_n I=FE_OFN1803_n5419
XFE_OFC2659_n5419 INV2 $PINS O=FE_OFN5526_n I=FE_OFN1802_n5419
XFE_OFC2658_n5419 INV1S $PINS O=FE_OFN5525_n I=FE_OFN1802_n5419
XFE_OFC2657_n5419 BUF1 $PINS O=FE_OFN1808_n5419 I=FE_OFN1794_n5419
XFE_OFC2656_n5419 INV1S $PINS O=FE_OFN1806_n5419 I=FE_OFN1447_n983
XFE_OFC2655_n5419 INV1S $PINS O=FE_OFN1803_n5419 I=FE_OFN1447_n983
XFE_OFC2654_n5419 INV3 $PINS O=FE_OFN1802_n5419 I=FE_OFN1805_n5419
XFE_OFC2653_n5419 BUF1 $PINS O=FE_OFN1794_n5419 I=FE_OFN1805_n5419
XFE_OFC2652_n5419 BUF1 $PINS O=FE_OFN1793_n5419 I=FE_OFN1805_n5419
XFE_OFC2650_n5419 INV1S $PINS O=FE_OFN1447_n983 I=FE_OFN1805_n5419
XFE_OFC2649_n5419 INV2 $PINS O=FE_OFN1805_n5419 I=n983
XFE_OFC2648_backward_metrics_5__0__1 BUF1 $PINS
+ O=FE_OFN1212_backward_metrics_5__0__1 I=backward_metrics[5][0][1]
XFE_OFC2646_n5509 BUF1 $PINS O=FE_OFN5524_n I=FE_OFN5522_n
XFE_OFC2643_n5509 INV1S $PINS O=FE_OFN2193_n3782 I=FE_OFN1920_n5509
XFE_OFC2641_n5509 INV4CK $PINS O=FE_OFN1920_n5509 I=FE_OFN1918_n5509
XFE_OFC2640_backward_metrics_2__3__1 BUF1 $PINS
+ O=FE_OFN1104_backward_metrics_2__3__1 I=backward_metrics[2][3][1]
XFE_OFC2639_backward_metrics_1__3__1 BUF1 $PINS
+ O=FE_OFN1056_backward_metrics_1__3__1 I=backward_metrics[1][3][1]
XFE_OFC2638_branch_metrics_3__3__3 BUF1 $PINS
+ O=FE_OFN869_branch_metrics_3__3__3 I=branch_metrics[3][3][3]
XFE_OFC2637_backward_metrics_3__0__1 BUF1 $PINS
+ O=FE_OFN1116_backward_metrics_3__0__1 I=backward_metrics[3][0][1]
XFE_OFC2636_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5521_n I=FE_OFN1454_n985
XFE_OFC2635_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN5520_n
+ I=FE_OFN1590_FE_DBTN86_n985
XFE_OFC2632_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1602_FE_DBTN86_n985
+ I=FE_OFN1627_FE_DBTN86_n985
XFE_OFC2631_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1454_n985
+ I=FE_OFN1627_FE_DBTN86_n985
XFE_OFC2628_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1590_FE_DBTN86_n985
+ I=FE_OFN1588_FE_DBTN86_n985
XFE_OFC2624_branch_metrics_5__0__0 BUF1 $PINS
+ O=FE_OFN932_branch_metrics_5__0__0 I=branch_metrics[5][0][0]
XFE_OFC2623_backward_metrics_2__3__0 BUF1 $PINS
+ O=FE_OFN1105_backward_metrics_2__3__0 I=backward_metrics[2][3][0]
XFE_OFC2622_forward_sum_0__5__1 BUF1 $PINS O=FE_OFN998_forward_sum_0__5__1
+ I=forward_sum[0][5][1]
XFE_OFC2621_backward_metrics_2__3__2 BUF1 $PINS
+ O=FE_OFN1103_backward_metrics_2__3__2 I=backward_metrics[2][3][2]
XFE_OFC2620_count_0 INV1S $PINS O=FE_OFN5518_count_0 I=FE_OFN1427_count_0
XFE_OFC2619_count_0 INV2 $PINS O=FE_OFN5517_count_0 I=FE_OFN1427_count_0
XFE_OFC2614_count_0 INV3 $PINS O=FE_OFN1427_count_0 I=count[0]
XFE_OFC2613_backward_metrics_2__2__1 BUF1 $PINS
+ O=FE_OFN1092_backward_metrics_2__2__1 I=backward_metrics[2][2][1]
XFE_OFC2612_branch_metrics_5__2__4 BUF1 $PINS
+ O=FE_OFN951_branch_metrics_5__2__4 I=branch_metrics[5][2][4]
XFE_OFC2611_backward_metrics_5__3__0 BUF1 $PINS
+ O=FE_OFN1249_backward_metrics_5__3__0 I=backward_metrics[5][3][0]
XFE_OFC2610_backward_metrics_5__1__1 BUF1 $PINS
+ O=FE_OFN1224_backward_metrics_5__1__1 I=backward_metrics[5][1][1]
XFE_OFC2607_n1455 BUF3 $PINS O=FE_OFN5512_n1455 I=FE_OFN1426_n1455
XFE_OFC2606_n1455 BUF2 $PINS O=FE_DBTN87_n1455 I=n1455
XFE_OFC2605_n1455 INV4 $PINS O=FE_OFN1426_n1455 I=n1455
XFE_OFC2603_n1454 BUF3 $PINS O=FE_OFN2199_n1454 I=n1454
XFE_OFC2602_n1454 INV6CK $PINS O=FE_DBTN88_n1454 I=n1454
XFE_OFC2601_backward_metrics_2__0__0 BUF1 $PINS
+ O=FE_OFN1069_backward_metrics_2__0__0 I=backward_metrics[2][0][0]
XFE_OFC2600_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1695_FE_DBTN85_n987
+ I=FE_OFN1684_FE_DBTN85_n987
XFE_OFC2599_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1690_FE_DBTN85_n987
+ I=FE_OFN1691_FE_DBTN85_n987
XFE_OFC2598_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1684_FE_DBTN85_n987
+ I=FE_OFN1691_FE_DBTN85_n987
XFE_OFC2597_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1697_FE_DBTN85_n987
+ I=FE_OFN1694_FE_DBTN85_n987
XFE_OFC2596_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1698_FE_DBTN85_n987
+ I=FE_OFN1685_FE_DBTN85_n987
XFE_OFC2595_FE_DBTN85_n987 INV1S $PINS O=FE_OFN1691_FE_DBTN85_n987
+ I=FE_OFN1677_FE_DBTN85_n987
XFE_OFC2594_FE_DBTN85_n987 INV2 $PINS O=FE_OFN1694_FE_DBTN85_n987
+ I=FE_OFN1677_FE_DBTN85_n987
XFE_OFC2593_FE_DBTN85_n987 INV1S $PINS O=FE_OFN1685_FE_DBTN85_n987
+ I=FE_OFN1677_FE_DBTN85_n987
XFE_OFC2592_N2299 BUF6 $PINS O=FE_OFN2198_N2299 I=FE_OFN1280_N2299
XFE_OFC2591_N2299 BUF6 $PINS O=FE_DBTN89_N2299 I=FE_OFN1281_N2299
XFE_OFC2590_N2299 INV3 $PINS O=FE_OFN1280_N2299 I=N2299
XFE_OFC2589_N2299 BUF6 $PINS O=FE_OFN1281_N2299 I=N2299
XFE_OFC2586_n5509 INV1S $PINS O=FE_OFN1892_n5509 I=FE_OFN1880_n5509
XFE_OFC2568_n5302 INV1S $PINS O=FE_OFN2225_n5302 I=n5248
XFE_OFC2566_n5294 INV1S $PINS O=FE_OFN2224_n5294 I=n5259
XFE_OFC2565_n5294 INV4 $PINS O=n5259 I=n5294
XFE_OFC2564_branch_metrics_3__0__1 BUF1 $PINS
+ O=FE_OFN835_branch_metrics_3__0__1 I=branch_metrics[3][0][1]
XFE_OFC2561_n5013 INV1S $PINS O=FE_OFN2223_n5013 I=n5014
XFE_OFC2560_n5013 INV1S $PINS O=n5014 I=n5013
XFE_OFC2559_n5276 INV1S $PINS O=FE_OFN2222_n5276 I=n5103
XFE_OFC2558_n5276 INV2 $PINS O=n5103 I=n5276
XFE_OFC2555_n4853 INV1S $PINS O=n4661 I=n4853
XFE_OFC2549_n5361 INV1S $PINS O=n5340 I=n5361
XFE_OFC2546_backward_metrics_1__2__3 BUF1 $PINS
+ O=FE_OFN1042_backward_metrics_1__2__3 I=backward_metrics[1][2][3]
XFE_OFC2545_N508 INV1S $PINS O=FE_OFN2220_N508 I=n5683
XFE_OFC2544_N508 INV1S $PINS O=n5683 I=N508
XFE_OFC2543_n4867 INV1S $PINS O=n5440 I=n4867
XFE_OFC2542_n4567 INV1S $PINS O=FE_OFN2219_n4567 I=n4568
XFE_OFC2541_n4567 INV1S $PINS O=n4568 I=n4567
XFE_OFC2539_n4912 INV1S $PINS O=FE_OFN2218_n4912 I=n4913
XFE_OFC2538_n4912 INV1S $PINS O=n4913 I=n4912
XFE_OFC2537_n4435 INV1S $PINS O=FE_OFN2217_n4435 I=n5460
XFE_OFC2536_n4435 INV2 $PINS O=n5460 I=n4435
XFE_OFC2533_n4873 INV2 $PINS O=n4804 I=n4873
XFE_OFC2532_n4861 INV1S $PINS O=n4654 I=n4861
XFE_OFC2531_n5019 INV1S $PINS O=FE_OFN2216_n5019 I=n5020
XFE_OFC2530_n5019 INV1S $PINS O=n5020 I=n5019
XFE_OFC2529_N509 INV1S $PINS O=FE_OFN2215_N509 I=n5682
XFE_OFC2528_N509 INV1S $PINS O=n5682 I=N509
XFE_OFC2527_n5351 INV1S $PINS O=FE_OFN2214_n5351 I=n5352
XFE_OFC2526_n5351 INV1S $PINS O=n5352 I=n5351
XFE_OFC2525_n3 BUF1 $PINS O=FE_DBTN83_n3 I=FE_OFN2062_FE_DBTN83_n3
XFE_OFC2524_n3 INV2 $PINS O=FE_OFN2062_FE_DBTN83_n3 I=n3
XFE_OFC2522_n4869 INV1S $PINS O=n4646 I=n4869
XFE_OFC2521_N554 INV1S $PINS O=FE_OFN2213_N554 I=n5753
XFE_OFC2520_N554 INV1S $PINS O=n5753 I=N554
XFE_OFC2516_branch_metrics_3__3__6 BUF1 $PINS
+ O=FE_OFN866_branch_metrics_3__3__6 I=branch_metrics[3][3][6]
XFE_OFC2515_n5315 INV2 $PINS O=FE_OFN2212_n5315 I=n5083
XFE_OFC2514_n5315 INV3 $PINS O=n5083 I=n5315
XFE_OFC2511_branch_metrics_1__1__3 BUF1CK $PINS
+ O=FE_OFN749_branch_metrics_1__1__3 I=branch_metrics[1][1][3]
XFE_OFC2510_backward_metrics_4__0__4 BUF1 $PINS
+ O=FE_OFN1161_backward_metrics_4__0__4 I=backward_metrics[4][0][4]
XFE_OFC2509_n5317 INV1S $PINS O=FE_OFN2211_n5317 I=n5245
XFE_OFC2508_n5317 INV4 $PINS O=n5245 I=n5317
XFE_OFC2507_backward_metrics_3__0__5 BUF1 $PINS
+ O=FE_OFN1112_backward_metrics_3__0__5 I=backward_metrics[3][0][5]
XFE_OFC2506_branch_metrics_4__0__5 BUF1 $PINS
+ O=FE_OFN879_branch_metrics_4__0__5 I=branch_metrics[4][0][5]
XFE_OFC2505_backward_metrics_2__0__5 BUF1 $PINS
+ O=FE_OFN1064_backward_metrics_2__0__5 I=backward_metrics[2][0][5]
XFE_OFC2503_n5111 INV1S $PINS O=FE_OFN2210_n5111 I=n4994
XFE_OFC2502_n5111 INV2CK $PINS O=n4994 I=n5111
XFE_OFC2501_n2 BUF1 $PINS O=FE_OFN2158_FE_DBTN84_n2 I=FE_DBTN84_n2
XFE_OFC2500_n2 INV2 $PINS O=FE_DBTN84_n2 I=n2
XFE_OFC2499_backward_metrics_2__1__4 BUF1 $PINS
+ O=FE_OFN1077_backward_metrics_2__1__4 I=backward_metrics[2][1][4]
XFE_OFC2498_backward_metrics_3__1__4 BUF1 $PINS
+ O=FE_OFN1125_backward_metrics_3__1__4 I=backward_metrics[3][1][4]
XFE_OFC2497_branch_metrics_1__3__2 BUF1 $PINS
+ O=FE_OFN774_branch_metrics_1__3__2 I=branch_metrics[1][3][2]
XFE_OFC2496_backward_metrics_5__1__5 BUF1 $PINS
+ O=FE_OFN1220_backward_metrics_5__1__5 I=backward_metrics[5][1][5]
XFE_OFC2495_backward_metrics_3__2__3 BUF1 $PINS
+ O=FE_OFN1138_backward_metrics_3__2__3 I=backward_metrics[3][2][3]
XFE_OFC2494_forward_sum_6__4__10 INV2 $PINS O=n4705 I=forward_sum[6][4][10]
XFE_OFC2493_backward_metrics_1__1__5 BUF1 $PINS
+ O=FE_OFN1028_backward_metrics_1__1__5 I=backward_metrics[1][1][5]
XFE_OFC2492_backward_metrics_3__0__4 BUF1 $PINS
+ O=FE_OFN1113_backward_metrics_3__0__4 I=backward_metrics[3][0][4]
XFE_OFC2491_backward_metrics_3__2__2 BUF1 $PINS
+ O=FE_OFN1139_backward_metrics_3__2__2 I=backward_metrics[3][2][2]
XFE_OFC2490_branch_metrics_4__3__4 BUF1 $PINS
+ O=FE_OFN916_branch_metrics_4__3__4 I=branch_metrics[4][3][4]
XFE_OFC2489_N506 INV1S $PINS O=FE_OFN2209_N506 I=n5685
XFE_OFC2488_N506 INV2 $PINS O=n5685 I=N506
XFE_OFC2487_branch_metrics_1__2__2 BUF1 $PINS
+ O=FE_OFN762_branch_metrics_1__2__2 I=branch_metrics[1][2][2]
XFE_OFC2486_backward_metrics_4__2__3 BUF1 $PINS
+ O=FE_OFN1186_backward_metrics_4__2__3 I=backward_metrics[4][2][3]
XFE_OFC2485_backward_metrics_4__1__3 BUF1 $PINS
+ O=FE_OFN1174_backward_metrics_4__1__3 I=backward_metrics[4][1][3]
XFE_OFC2484_backward_metrics_3__3__1 BUF1 $PINS
+ O=FE_OFN1152_backward_metrics_3__3__1 I=backward_metrics[3][3][1]
XFE_OFC2483_backward_metrics_4__1__4 BUF1 $PINS
+ O=FE_OFN1173_backward_metrics_4__1__4 I=backward_metrics[4][1][4]
XFE_OFC2482_branch_metrics_4__2__6 BUF1 $PINS
+ O=FE_OFN902_branch_metrics_4__2__6 I=branch_metrics[4][2][6]
XFE_OFC2481_backward_metrics_2__2__2 BUF1 $PINS
+ O=FE_OFN1091_backward_metrics_2__2__2 I=backward_metrics[2][2][2]
XFE_OFC2480_backward_metrics_2__1__5 BUF1 $PINS
+ O=FE_OFN1076_backward_metrics_2__1__5 I=backward_metrics[2][1][5]
XFE_OFC2479_backward_metrics_5__3__2 BUF1 $PINS
+ O=FE_OFN1247_backward_metrics_5__3__2 I=backward_metrics[5][3][2]
XFE_OFC2477_branch_metrics_4__3__5 BUF1 $PINS
+ O=FE_OFN915_branch_metrics_4__3__5 I=branch_metrics[4][3][5]
XFE_OFC2476_backward_metrics_2__1__3 BUF1 $PINS
+ O=FE_OFN1078_backward_metrics_2__1__3 I=backward_metrics[2][1][3]
XFE_OFC2475_forward_sum_6__5__10 INV2 $PINS O=n5139 I=forward_sum[6][5][10]
XFE_OFC2474_backward_metrics_4__1__5 BUF1 $PINS
+ O=FE_OFN1172_backward_metrics_4__1__5 I=backward_metrics[4][1][5]
XFE_OFC2473_branch_metrics_2__2__4 BUF1 $PINS
+ O=FE_OFN808_branch_metrics_2__2__4 I=branch_metrics[2][2][4]
XFE_OFC2472_branch_metrics_4__1__5 BUF1 $PINS
+ O=FE_OFN891_branch_metrics_4__1__5 I=branch_metrics[4][1][5]
XFE_OFC2471_backward_metrics_4__3__2 BUF1 $PINS
+ O=FE_OFN1199_backward_metrics_4__3__2 I=backward_metrics[4][3][2]
XFE_OFC2469_backward_metrics_6__1__5 BUF1 $PINS
+ O=FE_OFN1257_backward_metrics_6__1__5 I=backward_metrics[6][1][5]
XFE_OFC2468_backward_metrics_4__1__2 BUF1 $PINS
+ O=FE_OFN1175_backward_metrics_4__1__2 I=backward_metrics[4][1][2]
XFE_OFC2466_branch_metrics_2__1__0 BUF1 $PINS
+ O=FE_OFN800_branch_metrics_2__1__0 I=branch_metrics[2][1][0]
XFE_OFC2465_branch_metrics_1__1__4 BUF1 $PINS
+ O=FE_OFN748_branch_metrics_1__1__4 I=branch_metrics[1][1][4]
XFE_OFC2462_backward_metrics_3__3__2 BUF1 $PINS
+ O=FE_OFN1151_backward_metrics_3__3__2 I=backward_metrics[3][3][2]
XFE_OFC2461_branch_metrics_5__3__6 BUF1 $PINS
+ O=FE_OFN961_branch_metrics_5__3__6 I=branch_metrics[5][3][6]
XFE_OFC2460_branch_metrics_2__2__3 BUF1 $PINS
+ O=FE_OFN809_branch_metrics_2__2__3 I=branch_metrics[2][2][3]
XFE_OFC2459_backward_metrics_3__1__3 BUF1 $PINS
+ O=FE_OFN1126_backward_metrics_3__1__3 I=backward_metrics[3][1][3]
XFE_OFC2458_branch_metrics_1__1__0 BUF1 $PINS
+ O=FE_OFN752_branch_metrics_1__1__0 I=branch_metrics[1][1][0]
XFE_OFC2457_backward_metrics_5__1__2 BUF1 $PINS
+ O=FE_OFN1223_backward_metrics_5__1__2 I=backward_metrics[5][1][2]
XFE_OFC2456_backward_metrics_5__0__5 BUF1 $PINS
+ O=FE_OFN1208_backward_metrics_5__0__5 I=backward_metrics[5][0][5]
XFE_OFC2455_backward_metrics_1__2__4 BUF1 $PINS
+ O=FE_OFN1041_backward_metrics_1__2__4 I=backward_metrics[1][2][4]
XFE_OFC2454_backward_metrics_3__0__2 BUF1 $PINS
+ O=FE_OFN1115_backward_metrics_3__0__2 I=backward_metrics[3][0][2]
XFE_OFC2453_backward_metrics_4__0__5 BUF1 $PINS
+ O=FE_OFN1160_backward_metrics_4__0__5 I=backward_metrics[4][0][5]
XFE_OFC2452_backward_metrics_3__1__0 BUF1 $PINS
+ O=FE_OFN1129_backward_metrics_3__1__0 I=backward_metrics[3][1][0]
XFE_OFC2451_branch_metrics_5__0__3 BUF1 $PINS
+ O=FE_OFN929_branch_metrics_5__0__3 I=branch_metrics[5][0][3]
XFE_OFC2450_branch_metrics_1__2__3 BUF1 $PINS
+ O=FE_OFN761_branch_metrics_1__2__3 I=branch_metrics[1][2][3]
XFE_OFC2449_branch_metrics_2__1__5 BUF1 $PINS
+ O=FE_OFN795_branch_metrics_2__1__5 I=branch_metrics[2][1][5]
XFE_OFC2444_branch_metrics_4__1__6 BUF1 $PINS
+ O=FE_OFN890_branch_metrics_4__1__6 I=branch_metrics[4][1][6]
XFE_OFC2443_forward_sum_0__1__4 BUF1 $PINS O=FE_OFN975_forward_sum_0__1__4
+ I=forward_sum[0][1][4]
XFE_OFC2442_branch_metrics_4__0__4 BUF1 $PINS
+ O=FE_OFN880_branch_metrics_4__0__4 I=branch_metrics[4][0][4]
XFE_OFC2441_backward_metrics_3__3__0 BUF1 $PINS
+ O=FE_OFN1153_backward_metrics_3__3__0 I=backward_metrics[3][3][0]
XFE_OFC2440_branch_metrics_4__2__4 BUF1 $PINS
+ O=FE_OFN904_branch_metrics_4__2__4 I=branch_metrics[4][2][4]
XFE_OFC2439_backward_metrics_2__3__5 BUF1 $PINS
+ O=FE_OFN1100_backward_metrics_2__3__5 I=backward_metrics[2][3][5]
XFE_OFC2438_branch_metrics_3__0__3 BUF1 $PINS
+ O=FE_OFN833_branch_metrics_3__0__3 I=branch_metrics[3][0][3]
XFE_OFC2437_forward_sum_6__2__10 INV2 $PINS O=n4984 I=forward_sum[6][2][10]
XFE_OFC2436_branch_metrics_3__2__5 BUF1 $PINS
+ O=FE_OFN855_branch_metrics_3__2__5 I=branch_metrics[3][2][5]
XFE_OFC2434_branch_metrics_1__0__3 BUF1 $PINS
+ O=FE_OFN737_branch_metrics_1__0__3 I=branch_metrics[1][0][3]
XFE_OFC2433_branch_metrics_3__2__6 BUF1 $PINS
+ O=FE_OFN854_branch_metrics_3__2__6 I=branch_metrics[3][2][6]
XFE_OFC2432_backward_metrics_5__2__4 BUF1 $PINS
+ O=FE_OFN1233_backward_metrics_5__2__4 I=backward_metrics[5][2][4]
XFE_OFC2431_N493 INV1S $PINS O=FE_OFN2207_N493 I=n5678
XFE_OFC2430_N493 INV2 $PINS O=n5678 I=N493
XFE_OFC2428_N1056 BUF1 $PINS O=FE_OFN2179_N1056 I=N1056
XFE_OFC2427_branch_metrics_4__3__2 BUF1 $PINS
+ O=FE_OFN918_branch_metrics_4__3__2 I=branch_metrics[4][3][2]
XFE_OFC2426_branch_metrics_3__2__3 BUF1 $PINS
+ O=FE_OFN857_branch_metrics_3__2__3 I=branch_metrics[3][2][3]
XFE_OFC2425_branch_metrics_5__2__5 BUF1 $PINS
+ O=FE_OFN950_branch_metrics_5__2__5 I=branch_metrics[5][2][5]
XFE_OFC2424_forward_sum_6__7__10 INV2 $PINS O=n4980 I=forward_sum[6][7][10]
XFE_OFC2423_branch_metrics_4__0__7 BUF1 $PINS
+ O=FE_OFN877_branch_metrics_4__0__7 I=branch_metrics[4][0][7]
XFE_OFC2422_backward_metrics_4__2__5 BUF1 $PINS
+ O=FE_OFN1184_backward_metrics_4__2__5 I=backward_metrics[4][2][5]
XFE_OFC2421_branch_metrics_3__1__5 BUF1 $PINS
+ O=FE_OFN843_branch_metrics_3__1__5 I=branch_metrics[3][1][5]
XFE_OFC2420_branch_metrics_4__1__2 BUF1 $PINS
+ O=FE_OFN894_branch_metrics_4__1__2 I=branch_metrics[4][1][2]
XFE_OFC2419_branch_metrics_3__2__4 BUF1 $PINS
+ O=FE_OFN856_branch_metrics_3__2__4 I=branch_metrics[3][2][4]
XFE_OFC2418_branch_metrics_3__0__4 BUF1 $PINS
+ O=FE_OFN832_branch_metrics_3__0__4 I=branch_metrics[3][0][4]
XFE_OFC2417_backward_metrics_3__1__2 BUF1 $PINS
+ O=FE_OFN1127_backward_metrics_3__1__2 I=backward_metrics[3][1][2]
XFE_OFC2416_branch_metrics_4__3__3 BUF1 $PINS
+ O=FE_OFN917_branch_metrics_4__3__3 I=branch_metrics[4][3][3]
XFE_OFC2415_branch_metrics_2__1__4 BUF1 $PINS
+ O=FE_OFN796_branch_metrics_2__1__4 I=branch_metrics[2][1][4]
XFE_OFC2414_branch_metrics_4__2__3 BUF1 $PINS
+ O=FE_OFN905_branch_metrics_4__2__3 I=branch_metrics[4][2][3]
XFE_OFC2413_branch_metrics_5__1__4 BUF1 $PINS
+ O=FE_OFN940_branch_metrics_5__1__4 I=branch_metrics[5][1][4]
XFE_OFC2412_backward_metrics_2__2__5 BUF1 $PINS
+ O=FE_OFN1088_backward_metrics_2__2__5 I=backward_metrics[2][2][5]
XFE_OFC2411_N327 INV1S $PINS O=FE_OFN2205_N327 I=n5526
XFE_OFC2409_N327 INV2 $PINS O=n5526 I=N327
XFE_OFC2408_branch_metrics_3__0__5 BUF1 $PINS
+ O=FE_OFN831_branch_metrics_3__0__5 I=branch_metrics[3][0][5]
XFE_OFC2407_backward_metrics_3__3__5 BUF1 $PINS
+ O=FE_OFN1148_backward_metrics_3__3__5 I=backward_metrics[3][3][5]
XFE_OFC2406_branch_metrics_3__0__2 BUF1 $PINS
+ O=FE_OFN834_branch_metrics_3__0__2 I=branch_metrics[3][0][2]
XFE_OFC2404_forward_sum_6__3__10 INV2 $PINS O=n4540 I=forward_sum[6][3][10]
XFE_OFC2403_forward_sum_0__6__2 BUF1 $PINS O=FE_OFN1007_forward_sum_0__6__2
+ I=forward_sum[0][6][2]
XFE_OFC2402_forward_sum_0__5__3 BUF1 $PINS O=FE_OFN996_forward_sum_0__5__3
+ I=forward_sum[0][5][3]
XFE_OFC2400_branch_metrics_4__0__6 BUF1 $PINS
+ O=FE_OFN878_branch_metrics_4__0__6 I=branch_metrics[4][0][6]
XFE_OFC2399_N939 BUF1 $PINS O=FE_OFN2171_N939 I=N939
XFE_OFC2398_branch_metrics_1__3__5 BUF1 $PINS
+ O=FE_OFN771_branch_metrics_1__3__5 I=branch_metrics[1][3][5]
XFE_OFC2397_backward_metrics_5__1__4 BUF1 $PINS
+ O=FE_OFN1221_backward_metrics_5__1__4 I=backward_metrics[5][1][4]
XFE_OFC2395_N689 INV2 $PINS O=n5525 I=N689
XFE_OFC2394_N689 BUF1 $PINS O=FE_OFN2056_N689 I=N689
XFE_OFC2392_N517 INV1S $PINS O=FE_OFN2203_N517 I=n5712
XFE_OFC2391_N517 INV3CK $PINS O=n5712 I=N517
XFE_OFC2386_branch_metrics_5__2__2 BUF1 $PINS
+ O=FE_OFN953_branch_metrics_5__2__2 I=branch_metrics[5][2][2]
XFE_OFC2381_branch_metrics_3__1__3 BUF1 $PINS
+ O=FE_OFN845_branch_metrics_3__1__3 I=branch_metrics[3][1][3]
XFE_OFC2380_n4876 INV1S $PINS O=n4630 I=n4876
XFE_OFC2378_backward_metrics_5__2__5 BUF1 $PINS
+ O=FE_OFN1232_backward_metrics_5__2__5 I=backward_metrics[5][2][5]
XFE_OFC2375_n4671 INV1S $PINS O=FE_OFN2202_n4671 I=n4554
XFE_OFC2373_n4671 INV3CK $PINS O=n4554 I=n4671
XFE_OFC2371_forward_sum_6__6__10 INV2 $PINS O=n4544 I=forward_sum[6][6][10]
XFE_OFC2369_N541 INV1S $PINS O=FE_OFN2200_N541 I=n5746
XFE_OFC2368_N541 INV3CK $PINS O=n5746 I=N541
XFE_OFC2358_N2299 BUF1 $PINS O=FE_OFN1428_FE_DBTN89_N2299 I=FE_OFN1281_N2299
XFE_OFC2355_n1455 BUF1CK $PINS O=FE_OFN1432_FE_DBTN87_n1455 I=FE_OFN1426_n1455
XFE_OFC2351_FE_DBTN90_n1497 BUF8 $PINS O=FE_OFN510_FE_DBTN90_n1497
+ I=FE_DBTN90_n1497
XFE_OFC2350_FE_DBTN90_n1497 BUF1 $PINS O=FE_OFN511_FE_DBTN90_n1497
+ I=FE_DBTN90_n1497
XFE_OFC2349_n983 BUF1 $PINS O=FE_OFN1832_n5419 I=FE_OFN5577_n
XFE_OFC2345_n983 BUF1 $PINS O=FE_OFN1828_n5419 I=FE_OFN1821_n5419
XFE_OFC2344_n983 BUF1 $PINS O=FE_OFN1827_n5419 I=FE_OFN1821_n5419
XFE_OFC2341_n983 BUF1 $PINS O=FE_OFN1823_n5419 I=FE_OFN1820_n5419
XFE_OFC2338_n983 BUF1 $PINS O=FE_OFN1820_n5419 I=FE_OFN1817_n5419
XFE_OFC2335_n983 BUF1 $PINS O=FE_OFN1817_n5419 I=FE_OFN1793_n5419
XFE_OFC2334_n983 BUF1 $PINS O=FE_OFN1816_n5419 I=FE_OFN1793_n5419
XFE_OFC2333_n983 BUF1 $PINS O=FE_OFN1815_n5419 I=FE_OFN1808_n5419
XFE_OFC2332_n983 BUF1 $PINS O=FE_OFN1814_n5419 I=FE_OFN1807_n5419
XFE_OFC2326_n983 BUF1 $PINS O=FE_OFN1807_n5419 I=FE_OFN1794_n5419
XFE_OFC2323_n983 BUF1 $PINS O=FE_OFN1804_n5419 I=FE_OFN1799_n5419
XFE_OFC2320_n983 INV1S $PINS O=FE_OFN1799_n5419 I=FE_OFN1791_n5419
XFE_OFC2319_n983 INV1S $PINS O=FE_OFN1798_n5419 I=FE_OFN1791_n5419
XFE_OFC2318_n983 INV1S $PINS O=FE_OFN1797_n5419 I=FE_OFN1791_n5419
XFE_OFC2315_n983 INV1S $PINS O=FE_OFN1791_n5419 I=FE_OFN1803_n5419
XFE_OFC2314_n983 BUF1 $PINS O=FE_OFN1790_n5419 I=FE_OFN1840_n5419
XFE_OFC2311_n983 INV1S $PINS O=n5419 I=FE_OFN1802_n5419
XFE_OFC2310_n983 BUF1 $PINS O=FE_OFN1840_n5419 I=FE_OFN1802_n5419
XFE_OFC2308_FE_DBTN94_n1513 BUF1 $PINS O=FE_OFN502_FE_DBTN94_n1513
+ I=FE_DBTN94_n1513
XFE_OFC2307_FE_DBTN94_n1513 BUF1 $PINS O=FE_OFN503_FE_DBTN94_n1513
+ I=FE_DBTN94_n1513
XFE_OFC2306_n4217 BUF1 $PINS O=FE_OFN2197_n4217 I=FE_OFN2195_n4217
XFE_OFC2305_n4217 BUF1 $PINS O=FE_OFN2196_n4217 I=FE_OFN2195_n4217
XFE_OFC2304_n4217 BUF1 $PINS O=FE_OFN2195_n4217 I=FE_OFN1758_FE_DBTN71_n4217
XFE_OFC2303_n4217 BUF1 $PINS O=FE_OFN2194_n4217 I=FE_OFN1758_FE_DBTN71_n4217
XFE_OFC2302_n4217 BUF1 $PINS O=FE_OFN1759_FE_DBTN71_n4217
+ I=FE_OFN1757_FE_DBTN71_n4217
XFE_OFC2301_n4217 BUF1 $PINS O=FE_OFN1758_FE_DBTN71_n4217
+ I=FE_OFN1755_FE_DBTN71_n4217
XFE_OFC2300_n4217 BUF1 $PINS O=FE_OFN1757_FE_DBTN71_n4217
+ I=FE_OFN1746_FE_DBTN71_n4217
XFE_OFC2299_n4217 BUF1 $PINS O=FE_OFN1756_FE_DBTN71_n4217
+ I=FE_OFN1745_FE_DBTN71_n4217
XFE_OFC2298_n4217 INV1S $PINS O=FE_OFN1755_FE_DBTN71_n4217
+ I=FE_OFN1742_FE_DBTN71_n4217
XFE_OFC2296_n4217 INV1S $PINS O=FE_OFN1753_FE_DBTN71_n4217
+ I=FE_OFN1742_FE_DBTN71_n4217
XFE_OFC2294_n4217 INV1S $PINS O=FE_OFN1750_FE_DBTN71_n4217
+ I=FE_OFN1742_FE_DBTN71_n4217
XFE_OFC2293_n4217 BUF1 $PINS O=FE_OFN1747_FE_DBTN71_n4217
+ I=FE_OFN5614_FE_OFN1728_FE_DBTN71_n4217
XFE_OFC2292_n4217 BUF1 $PINS O=FE_OFN1746_FE_DBTN71_n4217
+ I=FE_OFN1736_FE_DBTN71_n4217
XFE_OFC2291_n4217 BUF1 $PINS O=FE_OFN1745_FE_DBTN71_n4217
+ I=FE_OFN1734_FE_DBTN71_n4217
XFE_OFC2290_n4217 BUF1 $PINS O=FE_OFN1744_FE_DBTN71_n4217
+ I=FE_OFN1733_FE_DBTN71_n4217
XFE_OFC2289_n4217 INV1S $PINS O=FE_OFN1742_FE_DBTN71_n4217
+ I=FE_OFN1728_FE_DBTN71_n4217
XFE_OFC2287_n4217 BUF1 $PINS O=FE_OFN1738_FE_DBTN71_n4217
+ I=FE_OFN1727_FE_DBTN71_n4217
XFE_OFC2286_n4217 BUF1 $PINS O=FE_OFN1736_FE_DBTN71_n4217 I=FE_DBTN71_n4217
XFE_OFC2284_n4217 INV2 $PINS O=FE_OFN1734_FE_DBTN71_n4217
+ I=FE_OFN1725_FE_DBTN71_n4217
XFE_OFC2283_n4217 INV1S $PINS O=FE_OFN1733_FE_DBTN71_n4217
+ I=FE_OFN1725_FE_DBTN71_n4217
XFE_OFC2281_n4217 INV1S $PINS O=FE_OFN1730_FE_DBTN71_n4217
+ I=FE_OFN1721_FE_DBTN71_n4217
XFE_OFC2280_n4217 INV2 $PINS O=FE_OFN1729_FE_DBTN71_n4217
+ I=FE_OFN1721_FE_DBTN71_n4217
XFE_OFC2279_n4217 BUF1 $PINS O=FE_OFN1728_FE_DBTN71_n4217
+ I=FE_OFN1720_FE_DBTN71_n4217
XFE_OFC2278_n4217 BUF1 $PINS O=FE_OFN1727_FE_DBTN71_n4217
+ I=FE_OFN1715_FE_DBTN71_n4217
XFE_OFC2276_n4217 BUF1 $PINS O=FE_OFN1724_FE_DBTN71_n4217
+ I=FE_OFN1718_FE_DBTN71_n4217
XFE_OFC2273_n4217 INV1S $PINS O=FE_OFN1721_FE_DBTN71_n4217
+ I=FE_OFN1713_FE_DBTN71_n4217
XFE_OFC2272_n4217 BUF1 $PINS O=FE_OFN1720_FE_DBTN71_n4217
+ I=FE_OFN1706_FE_DBTN71_n4217
XFE_OFC2270_n4217 BUF1 $PINS O=FE_OFN1718_FE_DBTN71_n4217
+ I=FE_OFN1709_FE_DBTN71_n4217
XFE_OFC2265_n4217 INV1S $PINS O=FE_OFN1713_FE_DBTN71_n4217
+ I=FE_OFN1711_FE_DBTN71_n4217
XFE_OFC2264_n4217 BUF1 $PINS O=FE_OFN1712_FE_DBTN71_n4217
+ I=FE_OFN1707_FE_DBTN71_n4217
XFE_OFC2261_n4217 INV1S $PINS O=FE_OFN1709_FE_DBTN71_n4217
+ I=FE_OFN1711_FE_DBTN71_n4217
XFE_OFC2259_n4217 BUF1 $PINS O=FE_OFN1707_FE_DBTN71_n4217
+ I=FE_OFN1722_FE_DBTN71_n4217
XFE_OFC2256_n4217 INV1S $PINS O=FE_OFN1564_n4217 I=FE_OFN1722_FE_DBTN71_n4217
XFE_OFC2255_n4217 INV2 $PINS O=FE_OFN1731_FE_DBTN71_n4217 I=n4217
XFE_OFC2254_n4217 BUF1 $PINS O=FE_OFN1737_FE_DBTN71_n4217 I=n4217
XFE_OFC2253_n987 BUF1 $PINS O=FE_OFN1699_FE_DBTN85_n987
+ I=FE_OFN1697_FE_DBTN85_n987
XFE_OFC2244_n987 BUF1 $PINS O=FE_OFN1689_FE_DBTN85_n987
+ I=FE_OFN1683_FE_DBTN85_n987
XFE_OFC2242_n987 BUF2 $PINS O=FE_OFN1687_FE_DBTN85_n987
+ I=FE_OFN1673_FE_DBTN85_n987
XFE_OFC2241_n987 BUF1CK $PINS O=FE_OFN1686_FE_DBTN85_n987
+ I=FE_OFN1678_FE_DBTN85_n987
XFE_OFC2238_n987 INV1S $PINS O=FE_OFN1683_FE_DBTN85_n987
+ I=FE_OFN1677_FE_DBTN85_n987
XFE_OFC2237_n987 BUF1 $PINS O=FE_OFN1682_FE_DBTN85_n987
+ I=FE_OFN1676_FE_DBTN85_n987
XFE_OFC2233_n987 BUF1 $PINS O=FE_OFN1678_FE_DBTN85_n987
+ I=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987
XFE_OFC2232_n987 INV2 $PINS O=FE_OFN1677_FE_DBTN85_n987
+ I=FE_OFN1671_FE_DBTN85_n987
XFE_OFC2231_n987 BUF1 $PINS O=FE_OFN1676_FE_DBTN85_n987
+ I=FE_OFN5619_FE_OFN1672_FE_DBTN85_n987
XFE_OFC2228_n987 BUF2 $PINS O=FE_OFN1673_FE_DBTN85_n987 I=FE_OFN5578_n
XFE_OFC2227_n987 BUF1 $PINS O=FE_OFN1672_FE_DBTN85_n987
+ I=FE_OFN1665_FE_DBTN85_n987
XFE_OFC2226_n987 BUF1 $PINS O=FE_OFN1671_FE_DBTN85_n987
+ I=FE_OFN1665_FE_DBTN85_n987
XFE_OFC2224_n987 BUF3 $PINS O=FE_OFN1669_FE_DBTN85_n987
+ I=FE_OFN1664_FE_DBTN85_n987
XFE_OFC2223_n987 BUF1 $PINS O=FE_OFN1668_FE_DBTN85_n987
+ I=FE_OFN1664_FE_DBTN85_n987
XFE_OFC2221_n987 BUF1 $PINS O=FE_OFN1665_FE_DBTN85_n987
+ I=FE_OFN1659_FE_DBTN85_n987
XFE_OFC2220_n987 BUF2 $PINS O=FE_OFN1664_FE_DBTN85_n987
+ I=FE_OFN1658_FE_DBTN85_n987
XFE_OFC2219_n987 BUF1 $PINS O=FE_OFN1663_FE_DBTN85_n987
+ I=FE_OFN1658_FE_DBTN85_n987
XFE_OFC2213_n987 BUF1 $PINS O=FE_OFN1657_FE_DBTN85_n987 I=FE_OFN1460_n987
XFE_OFC2211_n987 INV1S $PINS O=FE_OFN1461_n987 I=FE_DBTN85_n987
XFE_OFC2210_n987 BUF1 $PINS O=FE_OFN1460_n987 I=FE_OFN1457_n987
XFE_OFC2207_n987 INV1S $PINS O=FE_OFN1700_FE_DBTN85_n987 I=FE_OFN1455_n987
XFE_OFC2206_n987 INV1S $PINS O=FE_OFN1457_n987 I=FE_OFN1455_n987
XFE_OFC2205_n987 INV3 $PINS O=FE_OFN1455_n987 I=n987
XFE_OFC2202_n985 INV1S $PINS O=FE_OFN1651_FE_DBTN86_n985 I=FE_OFN5535_n
XFE_OFC2200_n985 INV1S $PINS O=FE_OFN1649_FE_DBTN86_n985 I=FE_OFN5535_n
XFE_OFC2199_n985 INV1S $PINS O=FE_OFN1648_FE_DBTN86_n985 I=FE_OFN5535_n
XFE_OFC2198_n985 INV1S $PINS O=FE_OFN1647_FE_DBTN86_n985 I=FE_OFN5535_n
XFE_OFC2197_n985 INV1S $PINS O=FE_OFN1646_FE_DBTN86_n985 I=FE_OFN5535_n
XFE_OFC2196_n985 BUF2 $PINS O=FE_OFN1645_FE_DBTN86_n985 I=FE_OFN5676_n
XFE_OFC2194_n985 BUF1 $PINS O=FE_OFN1643_FE_DBTN86_n985
+ I=FE_OFN1637_FE_DBTN86_n985
XFE_OFC2190_n985 BUF1 $PINS O=FE_OFN1638_FE_DBTN86_n985
+ I=FE_OFN1625_FE_DBTN86_n985
XFE_OFC2189_n985 BUF1 $PINS O=FE_OFN1637_FE_DBTN86_n985
+ I=FE_OFN1625_FE_DBTN86_n985
XFE_OFC2188_n985 BUF1 $PINS O=FE_OFN1635_FE_DBTN86_n985
+ I=FE_OFN5655_FE_OFN1628_FE_DBTN86_n985
XFE_OFC2183_n985 BUF1 $PINS O=FE_OFN1630_FE_DBTN86_n985 I=FE_OFN5668_n
XFE_OFC2182_n985 BUF1 $PINS O=FE_OFN1628_FE_DBTN86_n985
+ I=FE_OFN1623_FE_DBTN86_n985
XFE_OFC2178_n985 BUF1 $PINS O=FE_OFN1623_FE_DBTN86_n985
+ I=FE_OFN1604_FE_DBTN86_n985
XFE_OFC2176_n985 BUF1 $PINS O=FE_OFN1621_FE_DBTN86_n985
+ I=FE_OFN1610_FE_DBTN86_n985
XFE_OFC2173_n985 INV1S $PINS O=FE_OFN1618_FE_DBTN86_n985 I=FE_OFN5519_n
XFE_OFC2172_n985 INV1S $PINS O=FE_OFN1617_FE_DBTN86_n985 I=FE_OFN5519_n
XFE_OFC2167_n985 BUF1 $PINS O=FE_OFN1611_FE_DBTN86_n985 I=FE_OFN5550_n
XFE_OFC2165_n985 BUF1 $PINS O=FE_OFN1609_FE_DBTN86_n985
+ I=FE_OFN5585_FE_OFN1620_FE_DBTN86_n985
XFE_OFC2163_n985 BUF1 $PINS O=FE_OFN1607_FE_DBTN86_n985
+ I=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985
XFE_OFC2154_n985 BUF1 $PINS O=FE_OFN1636_FE_DBTN86_n985 I=FE_OFN5521_n
XFE_OFC2150_n985 BUF1 $PINS O=FE_OFN1593_FE_DBTN86_n985
+ I=FE_OFN1589_FE_DBTN86_n985
XFE_OFC2149_n985 BUF1 $PINS O=FE_OFN1452_n985 I=FE_OFN1589_FE_DBTN86_n985
XFE_OFC2145_n985 BUF1 $PINS O=FE_OFN1589_FE_DBTN86_n985
+ I=FE_OFN1587_FE_DBTN86_n985
XFE_OFC2142_n985 INV2 $PINS O=FE_OFN1587_FE_DBTN86_n985
+ I=FE_OFN1656_FE_DBTN86_n985
XFE_OFC2141_n985 INV2 $PINS O=FE_OFN1588_FE_DBTN86_n985 I=n985
XFE_OFC2139_n985 INV1S $PINS O=FE_OFN1656_FE_DBTN86_n985 I=n985
XFE_OFC2138_n985 BUF1 $PINS O=FE_DBTN86_n985 I=n985
XFE_OFC2135_n1452 INV3 $PINS O=FE_DBTN73_n1452 I=n1452
XFE_OFC2134_n1452 INV2 $PINS O=FE_OFN520_FE_DBTN73_n1452 I=n1452
XFE_OFC2130_n3782 BUF6CK $PINS O=FE_OFN1918_n5509 I=FE_OFN5594_FE_OFN1915_n5509
XFE_OFC2128_n3782 BUF2CK $PINS O=FE_OFN1916_n5509 I=FE_OFN1914_n5509
XFE_OFC2127_n3782 BUF6CK $PINS O=FE_OFN1915_n5509 I=FE_OFN5574_n
XFE_OFC2126_n3782 BUF2 $PINS O=FE_OFN1914_n5509 I=FE_OFN1909_n5509
XFE_OFC2125_n3782 BUF1 $PINS O=FE_OFN1913_n5509 I=FE_OFN5610_FE_OFN1897_n5509
XFE_OFC2123_n3782 BUF1 $PINS O=FE_OFN1911_n5509 I=FE_OFN5633_FE_OFN1905_n5509
XFE_OFC2121_n3782 BUF2CK $PINS O=FE_OFN1909_n5509 I=FE_OFN1903_n5509
XFE_OFC2120_n3782 BUF1 $PINS O=FE_OFN1908_n5509 I=FE_OFN1903_n5509
XFE_OFC2118_n3782 BUF1 $PINS O=FE_OFN1906_n5509 I=FE_OFN5607_FE_OFN1897_n5509
XFE_OFC2117_n3782 BUF1 $PINS O=FE_OFN1905_n5509 I=FE_OFN1910_n5509
XFE_OFC2115_n3782 BUF2CK $PINS O=FE_OFN1903_n5509 I=FE_OFN5680_n
XFE_OFC2114_n3782 INV1S $PINS O=FE_OFN1901_n5509 I=FE_OFN5680_n
XFE_OFC2113_n3782 INV1S $PINS O=FE_OFN1900_n5509 I=FE_OFN1894_n5509
XFE_OFC2112_n3782 BUF2 $PINS O=FE_OFN1897_n5509 I=FE_OFN1883_n5509
XFE_OFC2109_n3782 BUF2 $PINS O=FE_OFN1895_n5509 I=FE_OFN1886_n5509
XFE_OFC2108_n3782 INV1S $PINS O=FE_OFN1894_n5509 I=FE_OFN1884_n5509
XFE_OFC2105_n3782 INV1S $PINS O=FE_OFN1890_n5509 I=FE_OFN1904_n5509
XFE_OFC2103_n3782 BUF2CK $PINS O=FE_OFN1886_n5509 I=FE_OFN1878_n5509
XFE_OFC2102_n3782 BUF1 $PINS O=FE_OFN1885_n5509 I=FE_OFN1877_n5509
XFE_OFC2101_n3782 INV1S $PINS O=FE_OFN1884_n5509 I=FE_OFN1880_n5509
XFE_OFC2096_n3782 BUF1 $PINS O=FE_OFN1879_n5509 I=FE_OFN1869_n5509
XFE_OFC2095_n3782 INV2 $PINS O=FE_OFN1878_n5509 I=FE_OFN1848_n5509
XFE_OFC2094_n3782 INV1S $PINS O=FE_OFN1877_n5509 I=FE_OFN1848_n5509
XFE_OFC2092_n3782 INV1S $PINS O=FE_OFN1875_n5509 I=FE_OFN1848_n5509
XFE_OFC2088_n3782 BUF1 $PINS O=FE_OFN1870_n5509 I=FE_OFN1872_n5509
XFE_OFC2087_n3782 BUF1 $PINS O=FE_OFN1869_n5509 I=FE_OFN5567_n
XFE_OFC2085_n3782 BUF1 $PINS O=FE_OFN1867_n5509 I=FE_OFN5566_n
XFE_OFC2084_n3782 INV1S $PINS O=FE_OFN1865_n5509 I=FE_OFN1880_n5509
XFE_OFC2082_n3782 INV1S $PINS O=FE_OFN1862_n5509 I=FE_OFN1880_n5509
XFE_OFC2078_n3782 BUF1 $PINS O=FE_OFN1858_n5509 I=FE_OFN1859_n5509
XFE_OFC2077_n3782 BUF1 $PINS O=FE_OFN1857_n5509 I=FE_OFN1854_n5509
XFE_OFC2073_n3782 BUF1 $PINS O=FE_OFN1854_n5509 I=FE_OFN1846_n5509
XFE_OFC2070_n3782 INV1S $PINS O=FE_OFN1851_n5509 I=FE_OFN1896_n5509
XFE_OFC2069_n3782 INV1S $PINS O=FE_OFN1849_n5509 I=FE_OFN1896_n5509
XFE_OFC2067_n3782 INV1S $PINS O=FE_OFN1846_n5509 I=FE_OFN1845_n5509
XFE_OFC2065_n3782 INV1S $PINS O=FE_OFN1845_n5509 I=FE_OFN1868_n5509
XFE_OFC2063_n3782 INV1S $PINS O=n5509 I=FE_OFN1868_n5509
XFE_OFC2062_n3782 INV1S $PINS O=FE_OFN1921_n5509 I=FE_OFN5511_n
XFE_OFC2061_n3782 INV1S $PINS O=FE_OFN1563_n3782 I=n3782
XFE_OFC2060_N711 BUF1 $PINS O=FE_OFN2192_N711 I=N711
XFE_OFC2059_N710 BUF1 $PINS O=FE_OFN2191_N710 I=N710
XFE_OFC2058_N709 BUF1 $PINS O=FE_OFN2190_N709 I=N709
XFE_OFC2057_N708 BUF1 $PINS O=FE_OFN2189_N708 I=N708
XFE_OFC2056_N707 BUF1 $PINS O=FE_OFN2188_N707 I=N707
XFE_OFC2055_N706 BUF1 $PINS O=FE_OFN2187_N706 I=N706
XFE_OFC2053_N705 BUF1 $PINS O=FE_OFN2185_N705 I=N705
XFE_OFC2051_n4214 BUF1 $PINS O=FE_OFN2183_n4214 I=n4214
XFE_OFC2050_n4205 BUF1 $PINS O=FE_OFN2182_n4205 I=n4205
XFE_OFC2049_n1557 BUF1 $PINS O=FE_OFN2181_n1557 I=n1557
XFE_OFC2048_N1057 BUF2 $PINS O=FE_OFN2180_N1057 I=N1057
XFE_OFC2046_N1055 BUF1 $PINS O=FE_OFN2178_N1055 I=N1055
XFE_OFC2045_N1054 BUF1 $PINS O=FE_OFN2177_N1054 I=N1054
XFE_OFC2044_N1053 BUF1 $PINS O=FE_OFN2176_N1053 I=N1053
XFE_OFC2043_N1052 BUF1 $PINS O=FE_OFN2175_N1052 I=N1052
XFE_OFC2042_N1051 BUF1 $PINS O=FE_OFN2174_N1051 I=N1051
XFE_OFC2041_N941 BUF1 $PINS O=FE_OFN2173_N941 I=N941
XFE_OFC2040_N940 BUF1 $PINS O=FE_OFN2172_N940 I=N940
XFE_OFC2038_N938 BUF1 $PINS O=FE_OFN2170_N938 I=N938
XFE_OFC2037_N937 BUF1 $PINS O=FE_OFN2169_N937 I=N937
XFE_OFC2036_N936 BUF1 $PINS O=FE_OFN2168_N936 I=N936
XFE_OFC2035_N935 BUF1 $PINS O=FE_OFN2167_N935 I=N935
XFE_OFC2033_N826 BUF1 $PINS O=FE_OFN2165_N826 I=N826
XFE_OFC2032_N825 BUF1 $PINS O=FE_OFN2164_N825 I=N825
XFE_OFC2031_N824 BUF1 $PINS O=FE_OFN2163_N824 I=N824
XFE_OFC2030_N823 BUF1 $PINS O=FE_OFN2162_N823 I=N823
XFE_OFC2029_N822 BUF1 $PINS O=FE_OFN2161_N822 I=N822
XFE_OFC2028_N821 BUF1 $PINS O=FE_OFN2160_N821 I=N821
XFE_OFC2027_N820 BUF1 $PINS O=FE_OFN2159_N820 I=N820
XFE_OFC2025_n4253 BUF1 $PINS O=FE_OFN2157_n4253 I=n4253
XFE_OFC2024_n4239 BUF1 $PINS O=FE_OFN2156_n4239 I=n4239
XFE_OFC2023_n4223 BUF1 $PINS O=FE_OFN2155_n4223 I=FE_OFN2154_n4223
XFE_OFC2022_n4223 BUF1 $PINS O=FE_OFN2154_n4223 I=FE_OFN2152_n4223
XFE_OFC2021_n4223 INV1S $PINS O=FE_OFN2153_n4223 I=FE_OFN2151_n4223
XFE_OFC2020_n4223 INV1S $PINS O=FE_OFN2152_n4223 I=FE_OFN2151_n4223
XFE_OFC2019_n4223 INV1S $PINS O=FE_OFN2151_n4223 I=FE_OFN2150_n4223
XFE_OFC2018_n4223 BUF1 $PINS O=FE_OFN2150_n4223 I=FE_OFN2148_n4223
XFE_OFC2017_n4223 BUF1 $PINS O=FE_OFN2149_n4223 I=FE_OFN2148_n4223
XFE_OFC2016_n4223 BUF1 $PINS O=FE_OFN2148_n4223 I=FE_OFN2145_n4223
XFE_OFC2015_n4223 INV1S $PINS O=FE_OFN2147_n4223 I=FE_OFN2144_n4223
XFE_OFC2014_n4223 INV1S $PINS O=FE_OFN2146_n4223 I=FE_OFN2144_n4223
XFE_OFC2013_n4223 BUF1 $PINS O=FE_OFN2145_n4223 I=n4223
XFE_OFC2012_n4223 INV1S $PINS O=FE_OFN2144_n4223 I=n4223
XFE_OFC2011_n4207 BUF1 $PINS O=FE_OFN2143_n4207 I=n4207
XFE_OFC2010_n4206 BUF1 $PINS O=FE_OFN2142_n4206 I=n4206
XFE_OFC2009_n1558 BUF1 $PINS O=FE_OFN2141_n1558 I=n1558
XFE_OFC2008_n1554 BUF1 $PINS O=FE_OFN2140_n1554 I=n1554
XFE_OFC2007_n1553 BUF1 $PINS O=FE_OFN2139_n1553 I=n1553
XFE_OFC2006_n1552 BUF1 $PINS O=FE_OFN2138_n1552 I=n1552
XFE_OFC2005_n1551 BUF1 $PINS O=FE_OFN2137_n1551 I=n1551
XFE_OFC2004_n1550 BUF1 $PINS O=FE_OFN2136_n1550 I=n1550
XFE_OFC2003_n1522 BUF1 $PINS O=FE_OFN2135_n1522 I=n1522
XFE_OFC2002_n1521 BUF1 $PINS O=FE_OFN2134_n1521 I=n1521
XFE_OFC2001_n1520 BUF1 $PINS O=FE_OFN2133_n1520 I=n1521
XFE_OFC2000_n1519 INV1S $PINS O=FE_OFN2132_n1519 I=FE_OFN2128_n1519
XFE_OFC1999_n1519 INV1S $PINS O=FE_OFN2131_n1519 I=FE_OFN2128_n1519
XFE_OFC1998_n1519 BUF1 $PINS O=FE_OFN2130_n1519 I=FE_OFN2127_n1519
XFE_OFC1997_n1519 BUF1 $PINS O=FE_OFN2129_n1519 I=FE_OFN2126_n1519
XFE_OFC1996_n1519 INV1S $PINS O=FE_OFN2128_n1519 I=FE_OFN2125_n1519
XFE_OFC1995_n1519 BUF1 $PINS O=FE_OFN2127_n1519 I=FE_OFN2125_n1519
XFE_OFC1994_n1519 BUF1 $PINS O=FE_OFN2126_n1519 I=FE_OFN2124_n1519
XFE_OFC1993_n1519 BUF1 $PINS O=FE_OFN2125_n1519 I=FE_OFN2123_n1519
XFE_OFC1992_n1519 BUF1 $PINS O=FE_OFN2124_n1519 I=n1519
XFE_OFC1991_n1519 BUF1 $PINS O=FE_OFN2123_n1519 I=n1519
XFE_OFC1990_n1518 INV1S $PINS O=FE_OFN2122_n1518 I=FE_OFN2119_n1518
XFE_OFC1989_n1518 INV1S $PINS O=FE_OFN2121_n1518 I=FE_OFN2119_n1518
XFE_OFC1988_n1518 BUF1 $PINS O=FE_OFN2120_n1518 I=FE_OFN2117_n1518
XFE_OFC1987_n1518 INV1S $PINS O=FE_OFN2119_n1518 I=FE_OFN2117_n1518
XFE_OFC1986_n1518 BUF1 $PINS O=FE_OFN2118_n1518 I=FE_OFN2116_n1518
XFE_OFC1985_n1518 BUF1 $PINS O=FE_OFN2117_n1518 I=FE_OFN2115_n1518
XFE_OFC1984_n1518 BUF1 $PINS O=FE_OFN2116_n1518 I=FE_OFN2114_n1518
XFE_OFC1983_n1518 BUF1 $PINS O=FE_OFN2115_n1518 I=FE_OFN2113_n1518
XFE_OFC1982_n1518 BUF1 $PINS O=FE_OFN2114_n1518 I=n1518
XFE_OFC1981_n1518 BUF1 $PINS O=FE_OFN2113_n1518 I=n1518
XFE_OFC1980_n1517 BUF1 $PINS O=FE_OFN2112_n1517 I=FE_OFN2108_n1517
XFE_OFC1979_n1517 INV1S $PINS O=FE_OFN2111_n1517 I=FE_OFN2106_n1517
XFE_OFC1978_n1517 INV1S $PINS O=FE_OFN2110_n1517 I=FE_OFN2106_n1517
XFE_OFC1977_n1517 INV1S $PINS O=FE_OFN2109_n1517 I=FE_OFN2104_n1517
XFE_OFC1976_n1517 INV1S $PINS O=FE_OFN2108_n1517 I=FE_OFN2104_n1517
XFE_OFC1975_n1517 BUF1 $PINS O=FE_OFN2107_n1517 I=FE_OFN2103_n1517
XFE_OFC1974_n1517 INV1S $PINS O=FE_OFN2106_n1517 I=FE_OFN2102_n1517
XFE_OFC1973_n1517 BUF1 $PINS O=FE_OFN2105_n1517 I=FE_OFN2102_n1517
XFE_OFC1972_n1517 INV1S $PINS O=FE_OFN2104_n1517 I=n1517
XFE_OFC1971_n1517 BUF1 $PINS O=FE_OFN2103_n1517 I=n1517
XFE_OFC1970_n1517 BUF1 $PINS O=FE_OFN2102_n1517 I=n1517
XFE_OFC1969_n1516 BUF1 $PINS O=FE_OFN2101_n1516 I=FE_OFN2100_n1516
XFE_OFC1968_n1516 BUF1 $PINS O=FE_OFN2100_n1516 I=FE_OFN2099_n1516
XFE_OFC1967_n1516 BUF1 $PINS O=FE_OFN2099_n1516 I=FE_OFN2094_n1516
XFE_OFC1966_n1516 INV1S $PINS O=FE_OFN2098_n1516 I=FE_OFN2093_n1516
XFE_OFC1965_n1516 INV1S $PINS O=FE_OFN2097_n1516 I=FE_OFN2093_n1516
XFE_OFC1964_n1516 INV1S $PINS O=FE_OFN2096_n1516 I=FE_OFN2093_n1516
XFE_OFC1963_n1516 INV1S $PINS O=FE_OFN2095_n1516 I=FE_OFN2093_n1516
XFE_OFC1962_n1516 INV1S $PINS O=FE_OFN2094_n1516 I=FE_OFN2093_n1516
XFE_OFC1961_n1516 INV1S $PINS O=FE_OFN2093_n1516 I=n1516
XFE_OFC1960_n1516 BUF1 $PINS O=FE_OFN2092_n1516 I=n1516
XFE_OFC1957_n1515 BUF1 $PINS O=FE_OFN2089_n1515 I=FE_OFN2087_n1515
XFE_OFC1956_n1515 BUF1 $PINS O=FE_OFN2088_n1515 I=FE_OFN2083_n1515
XFE_OFC1955_n1515 BUF1 $PINS O=FE_OFN2087_n1515 I=FE_OFN2083_n1515
XFE_OFC1954_n1515 BUF1 $PINS O=FE_OFN2086_n1515 I=FE_OFN2081_n1515
XFE_OFC1953_n1515 INV1S $PINS O=FE_OFN2085_n1515 I=FE_OFN2080_n1515
XFE_OFC1952_n1515 INV1S $PINS O=FE_OFN2084_n1515 I=FE_OFN2080_n1515
XFE_OFC1951_n1515 INV1S $PINS O=FE_OFN2083_n1515 I=FE_OFN2080_n1515
XFE_OFC1950_n1515 BUF1 $PINS O=FE_OFN2082_n1515 I=FE_OFN2079_n1515
XFE_OFC1949_n1515 BUF1 $PINS O=FE_OFN2081_n1515 I=FE_OFN2079_n1515
XFE_OFC1948_n1515 INV1S $PINS O=FE_OFN2080_n1515 I=n1515
XFE_OFC1947_n1515 BUF1 $PINS O=FE_OFN2079_n1515 I=n1515
XFE_OFC1946_n1514 BUF1 $PINS O=FE_OFN2078_n1514 I=FE_OFN2076_n1514
XFE_OFC1945_n1514 INV1S $PINS O=FE_OFN2077_n1514 I=FE_OFN2072_n1514
XFE_OFC1944_n1514 INV1S $PINS O=FE_OFN2076_n1514 I=FE_OFN2072_n1514
XFE_OFC1943_n1514 BUF1 $PINS O=FE_OFN2075_n1514 I=FE_OFN2071_n1514
XFE_OFC1942_n1514 BUF1 $PINS O=FE_OFN2074_n1514 I=FE_OFN2070_n1514
XFE_OFC1941_n1514 BUF1 $PINS O=FE_OFN2073_n1514 I=FE_OFN2069_n1514
XFE_OFC1940_n1514 INV1S $PINS O=FE_OFN2072_n1514 I=FE_OFN2068_n1514
XFE_OFC1939_n1514 INV1S $PINS O=FE_OFN2071_n1514 I=FE_OFN2067_n1514
XFE_OFC1938_n1514 INV1S $PINS O=FE_OFN2070_n1514 I=FE_OFN2067_n1514
XFE_OFC1937_n1514 INV1S $PINS O=FE_OFN2069_n1514 I=FE_OFN2067_n1514
XFE_OFC1936_n1514 INV1S $PINS O=FE_OFN2068_n1514 I=FE_OFN2067_n1514
XFE_OFC1935_n1514 INV1S $PINS O=FE_OFN2067_n1514 I=n1514
XFE_OFC1933_n1444 BUF1 $PINS O=FE_OFN2065_n1444 I=n1444
XFE_OFC1932_FE_DBTN78_n11 BUF1 $PINS O=FE_OFN2064_FE_DBTN78_n11 I=FE_DBTN78_n11
XFE_OFC1931_FE_DBTN79_n10 BUF1 $PINS O=FE_OFN2063_FE_DBTN79_n10 I=FE_DBTN79_n10
XFE_OFC1929_FE_DBTN95_N336 BUF1 $PINS O=FE_OFN2061_FE_DBTN95_N336
+ I=FE_DBTN95_N336
XFE_OFC1925_n982 BUF1 $PINS O=FE_OFN2057_n982 I=n982
XFE_OFC1923_N357 BUF1 $PINS O=FE_OFN2055_N357 I=N357
XFE_OFC1922_N356 BUF1 $PINS O=FE_OFN2054_N356 I=N356
XFE_OFC1921_N355 BUF1 $PINS O=FE_OFN2053_N355 I=N355
XFE_OFC1920_N336 BUF1 $PINS O=FE_OFN2052_N336 I=FE_OFN2051_N336
XFE_OFC1919_N336 BUF1 $PINS O=FE_OFN2051_N336 I=N336
XFE_OFC1918_N325 BUF1 $PINS O=FE_OFN2050_N325 I=FE_OFN2049_N325
XFE_OFC1917_N325 BUF1 $PINS O=FE_OFN2049_N325 I=N325
XFE_OFC1916_FE_DBTN74_n1535 BUF1 $PINS O=FE_OFN2048_FE_DBTN74_n1535
+ I=FE_OFN2047_FE_DBTN74_n1535
XFE_OFC1915_FE_DBTN74_n1535 BUF1 $PINS O=FE_OFN2047_FE_DBTN74_n1535
+ I=FE_DBTN74_n1535
XFE_OFC1914_n1539 BUF1 $PINS O=FE_OFN2046_n1539 I=FE_OFN2045_n1539
XFE_OFC1913_n1539 BUF1 $PINS O=FE_OFN2045_n1539 I=n1539
XFE_OFC1912_n1538 BUF1 $PINS O=FE_OFN2044_n1538 I=FE_OFN2043_n1538
XFE_OFC1911_n1538 BUF1 $PINS O=FE_OFN2043_n1538 I=n1538
XFE_OFC1910_n1537 BUF1 $PINS O=FE_OFN2042_n1537 I=FE_OFN2041_n1537
XFE_OFC1909_n1537 BUF1 $PINS O=FE_OFN2041_n1537 I=n1537
XFE_OFC1908_n1534 BUF1 $PINS O=FE_OFN2040_n1534 I=FE_OFN2038_n1534
XFE_OFC1907_n1534 BUF1 $PINS O=FE_OFN2039_n1534 I=FE_OFN2038_n1534
XFE_OFC1906_n1534 BUF1 $PINS O=FE_OFN2038_n1534 I=FE_OFN2035_n1534
XFE_OFC1905_n1534 BUF1 $PINS O=FE_OFN2037_n1534 I=FE_OFN2035_n1534
XFE_OFC1904_n1534 BUF1 $PINS O=FE_OFN2036_n1534 I=FE_OFN2035_n1534
XFE_OFC1903_n1534 BUF1 $PINS O=FE_OFN2035_n1534 I=FE_OFN2034_n1534
XFE_OFC1902_n1534 BUF1 $PINS O=FE_OFN2034_n1534 I=FE_OFN2031_n1534
XFE_OFC1901_n1534 BUF1 $PINS O=FE_OFN2033_n1534 I=FE_OFN2031_n1534
XFE_OFC1900_n1534 BUF1 $PINS O=FE_OFN2032_n1534 I=FE_OFN2031_n1534
XFE_OFC1899_n1534 BUF1 $PINS O=FE_OFN2031_n1534 I=FE_OFN2029_n1534
XFE_OFC1898_n1534 BUF1 $PINS O=FE_OFN2030_n1534 I=FE_OFN2028_n1534
XFE_OFC1897_n1534 BUF1 $PINS O=FE_OFN2029_n1534 I=n1534
XFE_OFC1896_n1534 BUF1 $PINS O=FE_OFN2028_n1534 I=n1534
XFE_OFC1895_n1533 INV1S $PINS O=FE_OFN2027_n1533 I=FE_OFN2025_n1533
XFE_OFC1894_n1533 INV1S $PINS O=FE_OFN2026_n1533 I=FE_OFN2025_n1533
XFE_OFC1893_n1533 INV1S $PINS O=FE_OFN2025_n1533 I=FE_OFN2023_n1533
XFE_OFC1892_n1533 BUF1 $PINS O=FE_OFN2024_n1533 I=FE_OFN2023_n1533
XFE_OFC1891_n1533 BUF1 $PINS O=FE_OFN2023_n1533 I=FE_OFN2022_n1533
XFE_OFC1890_n1533 BUF1 $PINS O=FE_OFN2022_n1533 I=FE_OFN2021_n1533
XFE_OFC1889_n1533 INV1S $PINS O=FE_OFN2021_n1533 I=FE_OFN2019_n1533
XFE_OFC1888_n1533 INV1S $PINS O=FE_OFN2020_n1533 I=FE_OFN2019_n1533
XFE_OFC1887_n1533 INV1S $PINS O=FE_OFN2019_n1533 I=FE_OFN2014_n1533
XFE_OFC1885_n1533 BUF1 $PINS O=FE_OFN2017_n1533 I=FE_OFN2014_n1533
XFE_OFC1883_n1533 BUF1 $PINS O=FE_OFN2015_n1533 I=FE_OFN2013_n1533
XFE_OFC1882_n1533 BUF1 $PINS O=FE_OFN2014_n1533 I=n1533
XFE_OFC1881_n1533 BUF1 $PINS O=FE_OFN2013_n1533 I=n1533
XFE_OFC1880_n1532 BUF1 $PINS O=FE_OFN2012_n1532 I=FE_OFN2009_n1532
XFE_OFC1879_n1532 BUF1 $PINS O=FE_OFN2011_n1532 I=FE_OFN2009_n1532
XFE_OFC1878_n1532 BUF1 $PINS O=FE_OFN2010_n1532 I=FE_OFN2008_n1532
XFE_OFC1877_n1532 INV1S $PINS O=FE_OFN2009_n1532 I=FE_OFN2006_n1532
XFE_OFC1876_n1532 INV1S $PINS O=FE_OFN2008_n1532 I=FE_OFN2006_n1532
XFE_OFC1875_n1532 BUF1 $PINS O=FE_OFN2007_n1532 I=FE_OFN2005_n1532
XFE_OFC1874_n1532 INV1S $PINS O=FE_OFN2006_n1532 I=FE_OFN2003_n1532
XFE_OFC1873_n1532 BUF1 $PINS O=FE_OFN2005_n1532 I=n1532
XFE_OFC1872_n1532 BUF1 $PINS O=FE_OFN2004_n1532 I=n1532
XFE_OFC1871_n1532 BUF1 $PINS O=FE_OFN2003_n1532 I=n1532
XFE_OFC1870_n1531 INV1S $PINS O=FE_OFN2002_n1531 I=FE_OFN1998_n1531
XFE_OFC1869_n1531 INV1S $PINS O=FE_OFN2001_n1531 I=FE_OFN1998_n1531
XFE_OFC1868_n1531 BUF1 $PINS O=FE_OFN2000_n1531 I=FE_OFN1997_n1531
XFE_OFC1867_n1531 BUF1 $PINS O=FE_OFN1999_n1531 I=FE_OFN1997_n1531
XFE_OFC1866_n1531 INV1S $PINS O=FE_OFN1998_n1531 I=FE_OFN1995_n1531
XFE_OFC1865_n1531 BUF1 $PINS O=FE_OFN1997_n1531 I=FE_OFN1995_n1531
XFE_OFC1864_n1531 BUF1 $PINS O=FE_OFN1996_n1531 I=FE_OFN1994_n1531
XFE_OFC1863_n1531 BUF1 $PINS O=FE_OFN1995_n1531 I=FE_OFN1994_n1531
XFE_OFC1862_n1531 BUF1 $PINS O=FE_OFN1994_n1531 I=FE_OFN1992_n1531
XFE_OFC1861_n1531 BUF1 $PINS O=FE_OFN1993_n1531 I=n1531
XFE_OFC1860_n1531 BUF1 $PINS O=FE_OFN1992_n1531 I=n1531
XFE_OFC1859_n1530 INV1S $PINS O=FE_OFN1991_n1530 I=FE_OFN1988_n1530
XFE_OFC1858_n1530 INV1S $PINS O=FE_OFN1990_n1530 I=FE_OFN1988_n1530
XFE_OFC1856_n1530 INV1S $PINS O=FE_OFN1988_n1530 I=FE_OFN1986_n1530
XFE_OFC1855_n1530 BUF1 $PINS O=FE_OFN1987_n1530 I=FE_OFN1986_n1530
XFE_OFC1854_n1530 BUF1 $PINS O=FE_OFN1986_n1530 I=FE_OFN1984_n1530
XFE_OFC1853_n1530 BUF1 $PINS O=FE_OFN1985_n1530 I=FE_OFN1982_n1530
XFE_OFC1852_n1530 BUF1 $PINS O=FE_OFN1984_n1530 I=FE_OFN1982_n1530
XFE_OFC1851_n1530 BUF1 $PINS O=FE_OFN1983_n1530 I=FE_OFN1980_n1530
XFE_OFC1850_n1530 BUF1 $PINS O=FE_OFN1982_n1530 I=FE_OFN1980_n1530
XFE_OFC1849_n1530 BUF1 $PINS O=FE_OFN1981_n1530 I=FE_OFN1979_n1530
XFE_OFC1848_n1530 BUF1 $PINS O=FE_OFN1980_n1530 I=n1530
XFE_OFC1847_n1530 BUF1 $PINS O=FE_OFN1979_n1530 I=n1530
XFE_OFC1846_n1529 BUF1 $PINS O=FE_OFN1978_n1529 I=FE_OFN1976_n1529
XFE_OFC1845_n1529 BUF1 $PINS O=FE_OFN1977_n1529 I=FE_OFN1976_n1529
XFE_OFC1844_n1529 BUF1 $PINS O=FE_OFN1976_n1529 I=FE_OFN1975_n1529
XFE_OFC1843_n1529 BUF1 $PINS O=FE_OFN1975_n1529 I=FE_OFN1973_n1529
XFE_OFC1841_n1529 BUF1 $PINS O=FE_OFN1973_n1529 I=FE_OFN1971_n1529
XFE_OFC1840_n1529 BUF1 $PINS O=FE_OFN1972_n1529 I=FE_OFN1971_n1529
XFE_OFC1839_n1529 BUF1 $PINS O=FE_OFN1971_n1529 I=FE_OFN1970_n1529
XFE_OFC1838_n1529 BUF1 $PINS O=FE_OFN1970_n1529 I=FE_OFN1968_n1529
XFE_OFC1837_n1529 BUF1 $PINS O=FE_OFN1969_n1529 I=FE_OFN1967_n1529
XFE_OFC1836_n1529 BUF1 $PINS O=FE_OFN1968_n1529 I=n1529
XFE_OFC1835_n1529 BUF1 $PINS O=FE_OFN1967_n1529 I=n1529
XFE_OFC1834_n1528 BUF1 $PINS O=FE_OFN1966_n1528 I=FE_OFN1964_n1528
XFE_OFC1833_n1528 BUF1 $PINS O=FE_OFN1965_n1528 I=FE_OFN1964_n1528
XFE_OFC1832_n1528 BUF1 $PINS O=FE_OFN1964_n1528 I=FE_OFN1963_n1528
XFE_OFC1831_n1528 BUF1 $PINS O=FE_OFN1963_n1528 I=FE_OFN1961_n1528
XFE_OFC1830_n1528 BUF1 $PINS O=FE_OFN1962_n1528 I=FE_OFN1961_n1528
XFE_OFC1829_n1528 BUF1 $PINS O=FE_OFN1961_n1528 I=FE_OFN1959_n1528
XFE_OFC1828_n1528 BUF1 $PINS O=FE_OFN1960_n1528 I=FE_OFN1958_n1528
XFE_OFC1827_n1528 BUF1 $PINS O=FE_OFN1959_n1528 I=FE_OFN1958_n1528
XFE_OFC1826_n1528 BUF1 $PINS O=FE_OFN1958_n1528 I=FE_OFN1953_n1528
XFE_OFC1823_n1528 INV1S $PINS O=FE_OFN1955_n1528 I=FE_OFN1952_n1528
XFE_OFC1822_n1528 INV1S $PINS O=FE_OFN1954_n1528 I=FE_OFN1952_n1528
XFE_OFC1821_n1528 BUF1 $PINS O=FE_OFN1953_n1528 I=n1528
XFE_OFC1820_n1528 INV1S $PINS O=FE_OFN1952_n1528 I=n1528
XFE_OFC1819_n1526 BUF1 $PINS O=FE_OFN1951_n1526 I=FE_OFN1949_n1526
XFE_OFC1818_n1526 BUF1 $PINS O=FE_OFN1950_n1526 I=FE_OFN1946_n1526
XFE_OFC1817_n1526 INV1S $PINS O=FE_OFN1949_n1526 I=FE_OFN1944_n1526
XFE_OFC1816_n1526 INV1S $PINS O=FE_OFN1948_n1526 I=FE_OFN1944_n1526
XFE_OFC1815_n1526 INV1S $PINS O=FE_OFN1947_n1526 I=FE_OFN1944_n1526
XFE_OFC1814_n1526 INV1S $PINS O=FE_OFN1946_n1526 I=FE_OFN1944_n1526
XFE_OFC1813_n1526 BUF1 $PINS O=FE_OFN1945_n1526 I=FE_OFN1943_n1526
XFE_OFC1812_n1526 INV1S $PINS O=FE_OFN1944_n1526 I=FE_OFN1941_n1526
XFE_OFC1811_n1526 BUF1 $PINS O=FE_OFN1943_n1526 I=FE_OFN1941_n1526
XFE_OFC1810_n1526 BUF1 $PINS O=FE_OFN1942_n1526 I=n1526
XFE_OFC1809_n1526 BUF1 $PINS O=FE_OFN1941_n1526 I=n1526
XFE_OFC1808_n1525 BUF1 $PINS O=FE_OFN1940_n1525 I=FE_OFN1937_n1525
XFE_OFC1807_n1525 BUF1 $PINS O=FE_OFN1939_n1525 I=FE_OFN1936_n1525
XFE_OFC1806_n1525 BUF1 $PINS O=FE_OFN1938_n1525 I=FE_OFN1935_n1525
XFE_OFC1805_n1525 BUF1 $PINS O=FE_OFN1937_n1525 I=FE_OFN1934_n1525
XFE_OFC1804_n1525 BUF1 $PINS O=FE_OFN1936_n1525 I=FE_OFN1934_n1525
XFE_OFC1803_n1525 BUF1 $PINS O=FE_OFN1935_n1525 I=FE_OFN1934_n1525
XFE_OFC1802_n1525 BUF1 $PINS O=FE_OFN1934_n1525 I=FE_OFN1932_n1525
XFE_OFC1801_n1525 BUF1 $PINS O=FE_OFN1933_n1525 I=n1525
XFE_OFC1800_n1525 BUF1 $PINS O=FE_OFN1932_n1525 I=n1525
XFE_OFC1799_n1524 INV1S $PINS O=FE_OFN1931_n1524 I=FE_OFN1928_n1524
XFE_OFC1798_n1524 INV1S $PINS O=FE_OFN1930_n1524 I=FE_OFN1928_n1524
XFE_OFC1797_n1524 BUF1 $PINS O=FE_OFN1929_n1524 I=FE_OFN1927_n1524
XFE_OFC1796_n1524 INV1S $PINS O=FE_OFN1928_n1524 I=FE_OFN1924_n1524
XFE_OFC1795_n1524 BUF1 $PINS O=FE_OFN1927_n1524 I=FE_OFN1924_n1524
XFE_OFC1794_n1524 BUF1 $PINS O=FE_OFN1926_n1524 I=FE_OFN1923_n1524
XFE_OFC1793_n1524 BUF1 $PINS O=FE_OFN1925_n1524 I=FE_OFN1923_n1524
XFE_OFC1792_n1524 BUF1 $PINS O=FE_OFN1924_n1524 I=n1524
XFE_OFC1791_n1524 BUF1 $PINS O=FE_OFN1923_n1524 I=n1524
XFE_OFC1790_n1524 BUF1 $PINS O=FE_OFN1922_n1524 I=n1524
XFE_OFC1770_n5509 INV1S $PINS O=FE_OFN1902_n5509 I=FE_OFN1901_n5509
XFE_OFC1766_n5509 BUF1 $PINS O=FE_OFN1898_n5509 I=FE_OFN5633_FE_OFN1905_n5509
XFE_OFC1757_n5509 INV1S $PINS O=FE_OFN1889_n5509 I=FE_OFN1894_n5509
XFE_OFC1756_n5509 INV1S $PINS O=FE_OFN1888_n5509 I=FE_OFN1890_n5509
XFE_OFC1742_n5509 INV1S $PINS O=FE_OFN1874_n5509 I=FE_OFN1880_n5509
XFE_OFC1732_n5509 BUF1 $PINS O=FE_OFN1864_n5509 I=FE_OFN1867_n5509
XFE_OFC1715_n5509 INV1S $PINS O=FE_OFN1847_n5509 I=FE_OFN1845_n5509
XFE_OFC1712_n5509 INV1S $PINS O=FE_OFN1844_n5509 I=FE_OFN1845_n5509
XFE_OFC1710_n5419 BUF1 $PINS O=FE_OFN1842_n5419 I=FE_OFN5569_n
XFE_OFC1679_n5419 INV1S $PINS O=FE_OFN1811_n5419 I=FE_OFN1791_n5419
XFE_OFC1678_n5419 INV1S $PINS O=FE_OFN1810_n5419 I=FE_OFN1791_n5419
XFE_OFC1669_n5419 BUF1 $PINS O=FE_OFN1801_n5419 I=FE_OFN1796_n5419
XFE_OFC1668_n5419 BUF1 $PINS O=FE_OFN1800_n5419 I=FE_OFN1795_n5419
XFE_OFC1664_n5419 BUF1 $PINS O=FE_OFN1796_n5419 I=FE_OFN1794_n5419
XFE_OFC1663_n5419 BUF1 $PINS O=FE_OFN1795_n5419 I=FE_OFN1792_n5419
XFE_OFC1660_n5419 BUF1 $PINS O=FE_OFN1792_n5419 I=FE_OFN1789_n5419
XFE_OFC1657_n5419 INV1S $PINS O=FE_OFN1789_n5419 I=FE_OFN1802_n5419
XFE_OFC1655_n1527 BUF1 $PINS O=FE_OFN1787_n1527 I=FE_OFN1785_n1527
XFE_OFC1654_n1527 BUF1 $PINS O=FE_OFN1786_n1527 I=FE_OFN1785_n1527
XFE_OFC1653_n1527 BUF1 $PINS O=FE_OFN1785_n1527 I=FE_OFN1783_n1527
XFE_OFC1652_n1527 BUF1 $PINS O=FE_OFN1784_n1527 I=FE_OFN1783_n1527
XFE_OFC1651_n1527 BUF1 $PINS O=FE_OFN1783_n1527 I=FE_OFN1781_n1527
XFE_OFC1649_n1527 BUF1 $PINS O=FE_OFN1781_n1527 I=FE_OFN1778_n1527
XFE_OFC1648_n1527 BUF1 $PINS O=FE_OFN1780_n1527 I=FE_OFN1778_n1527
XFE_OFC1646_n1527 BUF1 $PINS O=FE_OFN1778_n1527 I=FE_OFN1777_n1527
XFE_OFC1645_n1527 BUF1 $PINS O=FE_OFN1777_n1527 I=FE_OFN1774_n1527
XFE_OFC1643_n1527 BUF1 $PINS O=FE_OFN1775_n1527 I=FE_OFN1773_n1527
XFE_OFC1642_n1527 INV1S $PINS O=FE_OFN1774_n1527 I=FE_OFN1772_n1527
XFE_OFC1641_n1527 INV1S $PINS O=FE_OFN1773_n1527 I=FE_OFN1772_n1527
XFE_OFC1640_n1527 INV1S $PINS O=FE_OFN1772_n1527 I=n1527
XFE_OFC1639_n1523 BUF1 $PINS O=FE_OFN1771_n1523 I=FE_OFN1770_n1523
XFE_OFC1638_n1523 INV1S $PINS O=FE_OFN1770_n1523 I=FE_OFN1768_n1523
XFE_OFC1637_n1523 INV1S $PINS O=FE_OFN1769_n1523 I=FE_OFN1768_n1523
XFE_OFC1636_n1523 INV1S $PINS O=FE_OFN1768_n1523 I=FE_OFN1765_n1523
XFE_OFC1635_n1523 BUF1 $PINS O=FE_OFN1767_n1523 I=FE_OFN1764_n1523
XFE_OFC1634_n1523 BUF1 $PINS O=FE_OFN1766_n1523 I=FE_OFN1763_n1523
XFE_OFC1633_n1523 INV1S $PINS O=FE_OFN1765_n1523 I=FE_OFN1762_n1523
XFE_OFC1632_n1523 INV1S $PINS O=FE_OFN1764_n1523 I=FE_OFN1762_n1523
XFE_OFC1631_n1523 BUF1 $PINS O=FE_OFN1763_n1523 I=FE_OFN1761_n1523
XFE_OFC1630_n1523 INV1S $PINS O=FE_OFN1762_n1523 I=n1523
XFE_OFC1629_n1523 BUF1 $PINS O=FE_OFN1761_n1523 I=n1523
XFE_OFC1620_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN1752_FE_DBTN71_n4217
+ I=FE_OFN1756_FE_DBTN71_n4217
XFE_OFC1617_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1749_FE_DBTN71_n4217
+ I=FE_OFN1742_FE_DBTN71_n4217
XFE_OFC1616_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN1748_FE_DBTN71_n4217
+ I=FE_OFN1740_FE_DBTN71_n4217
XFE_OFC1611_FE_DBTN71_n4217 BUF1 $PINS O=FE_OFN1743_FE_DBTN71_n4217
+ I=FE_OFN1747_FE_DBTN71_n4217
XFE_OFC1609_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1741_FE_DBTN71_n4217
+ I=FE_OFN1725_FE_DBTN71_n4217
XFE_OFC1608_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1740_FE_DBTN71_n4217
+ I=FE_OFN1725_FE_DBTN71_n4217
XFE_OFC1594_FE_DBTN71_n4217 INV1S $PINS O=FE_OFN1726_FE_DBTN71_n4217
+ I=FE_OFN1721_FE_DBTN71_n4217
XFE_OFC1573_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1705_FE_DBTN85_n987
+ I=FE_OFN1704_FE_DBTN85_n987
XFE_OFC1572_FE_DBTN85_n987 INV1S $PINS O=FE_OFN1704_FE_DBTN85_n987
+ I=FE_OFN1702_FE_DBTN85_n987
XFE_OFC1571_FE_DBTN85_n987 INV1S $PINS O=FE_OFN1703_FE_DBTN85_n987
+ I=FE_OFN1702_FE_DBTN85_n987
XFE_OFC1570_FE_DBTN85_n987 INV1S $PINS O=FE_OFN1702_FE_DBTN85_n987
+ I=FE_OFN1684_FE_DBTN85_n987
XFE_OFC1564_FE_DBTN85_n987 BUF1 $PINS O=FE_OFN1696_FE_DBTN85_n987
+ I=FE_OFN5665_n
XFE_OFC1523_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1655_FE_DBTN86_n985
+ I=FE_OFN5563_n
XFE_OFC1507_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1639_FE_DBTN86_n985
+ I=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985
XFE_OFC1497_FE_DBTN86_n985 INV1S $PINS O=FE_OFN1629_FE_DBTN86_n985
+ I=FE_OFN5519_n
XFE_OFC1483_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1615_FE_DBTN86_n985
+ I=FE_OFN1620_FE_DBTN86_n985
XFE_OFC1473_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1605_FE_DBTN86_n985
+ I=FE_OFN1598_FE_DBTN86_n985
XFE_OFC1468_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1600_FE_DBTN86_n985
+ I=FE_OFN5678_n
XFE_OFC1466_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1598_FE_DBTN86_n985
+ I=FE_OFN1594_FE_DBTN86_n985
XFE_OFC1462_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1594_FE_DBTN86_n985
+ I=FE_OFN1591_FE_DBTN86_n985
XFE_OFC1459_FE_DBTN86_n985 BUF1 $PINS O=FE_OFN1591_FE_DBTN86_n985
+ I=FE_OFN5520_n
XFE_OFC1454_n4217 INV1S $PINS O=FE_OFN1586_n4217 I=FE_OFN1584_n4217
XFE_OFC1453_n4217 INV1S $PINS O=FE_OFN1585_n4217 I=FE_OFN1584_n4217
XFE_OFC1452_n4217 INV1S $PINS O=FE_OFN1584_n4217 I=FE_OFN1582_n4217
XFE_OFC1451_n4217 BUF1 $PINS O=FE_OFN1583_n4217 I=FE_OFN1579_n4217
XFE_OFC1450_n4217 BUF1 $PINS O=FE_OFN1582_n4217 I=FE_OFN1578_n4217
XFE_OFC1449_n4217 BUF1 $PINS O=FE_OFN1581_n4217 I=FE_OFN1577_n4217
XFE_OFC1448_n4217 BUF1 $PINS O=FE_OFN1580_n4217 I=FE_OFN1577_n4217
XFE_OFC1447_n4217 BUF1 $PINS O=FE_OFN1579_n4217 I=FE_OFN1576_n4217
XFE_OFC1446_n4217 BUF1 $PINS O=FE_OFN1578_n4217 I=FE_OFN1576_n4217
XFE_OFC1445_n4217 BUF1 $PINS O=FE_OFN1577_n4217 I=FE_OFN1572_n4217
XFE_OFC1444_n4217 BUF1 $PINS O=FE_OFN1576_n4217 I=FE_OFN1571_n4217
XFE_OFC1443_n4217 BUF1 $PINS O=FE_OFN1575_n4217 I=FE_OFN1570_n4217
XFE_OFC1442_n4217 BUF1 $PINS O=FE_OFN1574_n4217 I=FE_OFN1568_n4217
XFE_OFC1441_n4217 BUF1 $PINS O=FE_OFN1573_n4217 I=FE_OFN1567_n4217
XFE_OFC1440_n4217 BUF1 $PINS O=FE_OFN1572_n4217 I=FE_OFN1567_n4217
XFE_OFC1439_n4217 INV1S $PINS O=FE_OFN1571_n4217 I=FE_OFN1566_n4217
XFE_OFC1438_n4217 INV1S $PINS O=FE_OFN1570_n4217 I=FE_OFN1566_n4217
XFE_OFC1437_n4217 INV1S $PINS O=FE_OFN1569_n4217 I=FE_OFN1566_n4217
XFE_OFC1436_n4217 INV1S $PINS O=FE_OFN1568_n4217 I=FE_OFN1566_n4217
XFE_OFC1435_n4217 BUF1 $PINS O=FE_OFN1567_n4217 I=FE_OFN1564_n4217
XFE_OFC1434_n4217 INV1S $PINS O=FE_OFN1566_n4217 I=FE_OFN1737_FE_DBTN71_n4217
XFE_OFC1430_n1665 BUF1 $PINS O=FE_OFN1562_n1665 I=n1665
XFE_OFC1429_n1442 INV2 $PINS O=FE_OFN1561_n1442 I=FE_OFN1559_n1442
XFE_OFC1428_n1442 INV1S $PINS O=FE_OFN1560_n1442 I=FE_OFN1559_n1442
XFE_OFC1427_n1442 INV2 $PINS O=FE_OFN1559_n1442 I=FE_OFN5562_n
XFE_OFC1424_n1442 INV1S $PINS O=FE_OFN1556_n1442 I=FE_OFN1550_n1442
XFE_OFC1423_n1442 INV1S $PINS O=FE_OFN1555_n1442 I=FE_OFN1552_n1442
XFE_OFC1422_n1442 INV2 $PINS O=FE_OFN1554_n1442 I=FE_OFN1552_n1442
XFE_OFC1420_n1442 INV2 $PINS O=FE_OFN1552_n1442 I=FE_OFN1548_n1442
XFE_OFC1417_n1442 INV1S $PINS O=FE_OFN1549_n1442 I=FE_OFN1542_n1442
XFE_OFC1416_n1442 INV2 $PINS O=FE_OFN1548_n1442 I=FE_OFN1542_n1442
XFE_OFC1415_n1442 INV1S $PINS O=FE_OFN1547_n1442 I=FE_OFN5646_FE_OFN1530_n1442
XFE_OFC1412_n1442 INV1S $PINS O=FE_OFN1544_n1442 I=FE_OFN1538_n1442
XFE_OFC1411_n1442 INV2 $PINS O=FE_OFN1543_n1442 I=FE_OFN1538_n1442
XFE_OFC1409_n1442 BUF1 $PINS O=FE_OFN1541_n1442 I=FE_OFN1534_n1442
XFE_OFC1406_n1442 INV2 $PINS O=FE_OFN1538_n1442 I=FE_OFN1529_n1442
XFE_OFC1404_n1442 INV1S $PINS O=FE_OFN1536_n1442 I=FE_OFN1525_n1442
XFE_OFC1402_n1442 INV1S $PINS O=FE_OFN1534_n1442 I=FE_OFN1525_n1442
XFE_OFC1399_n1442 INV2 $PINS O=FE_OFN1531_n1442 I=FE_OFN1525_n1442
XFE_OFC1397_n1442 INV2 $PINS O=FE_OFN1529_n1442 I=FE_OFN1524_n1442
XFE_OFC1396_n1442 INV1S $PINS O=FE_OFN1528_n1442 I=FE_OFN1524_n1442
XFE_OFC1392_n1442 INV2 $PINS O=FE_OFN1524_n1442 I=FE_OFN1516_n1442
XFE_OFC1391_n1442 BUF1 $PINS O=FE_OFN1523_n1442 I=FE_OFN1515_n1442
XFE_OFC1390_n1442 INV1S $PINS O=FE_OFN1522_n1442 I=FE_OFN1505_n1442
XFE_OFC1388_n1442 BUF1 $PINS O=FE_OFN1520_n1442 I=FE_OFN1513_n1442
XFE_OFC1386_n1442 BUF1 $PINS O=FE_OFN1518_n1442 I=FE_OFN1517_n1442
XFE_OFC1384_n1442 BUF2CK $PINS O=FE_OFN1516_n1442 I=FE_OFN1508_n1442
XFE_OFC1383_n1442 BUF1 $PINS O=FE_OFN1515_n1442 I=FE_OFN1507_n1442
XFE_OFC1381_n1442 INV1S $PINS O=FE_OFN1513_n1442 I=FE_OFN1504_n1442
XFE_OFC1380_n1442 INV1S $PINS O=FE_OFN1512_n1442 I=FE_OFN1504_n1442
XFE_OFC1379_n1442 BUF1 $PINS O=FE_OFN1511_n1442 I=FE_OFN1503_n1442
XFE_OFC1376_n1442 INV2 $PINS O=FE_OFN1508_n1442 I=FE_OFN1500_n1442
XFE_OFC1375_n1442 INV1S $PINS O=FE_OFN1507_n1442 I=FE_OFN1500_n1442
XFE_OFC1374_n1442 BUF1 $PINS O=FE_OFN1506_n1442 I=FE_OFN1499_n1442
XFE_OFC1372_n1442 INV1S $PINS O=FE_OFN1504_n1442 I=FE_OFN1498_n1442
XFE_OFC1371_n1442 BUF1 $PINS O=FE_OFN1503_n1442 I=FE_OFN5576_n
XFE_OFC1369_n1442 BUF1 $PINS O=FE_OFN1501_n1442 I=FE_OFN1495_n1442
XFE_OFC1368_n1442 INV2 $PINS O=FE_OFN1500_n1442 I=FE_OFN1494_n1442
XFE_OFC1367_n1442 INV2 $PINS O=FE_OFN1499_n1442 I=FE_OFN1493_n1442
XFE_OFC1366_n1442 INV1S $PINS O=FE_OFN1498_n1442 I=FE_OFN1493_n1442
XFE_OFC1365_n1442 BUF1 $PINS O=FE_OFN1497_n1442 I=FE_OFN1492_n1442
XFE_OFC1363_n1442 BUF1 $PINS O=FE_OFN1495_n1442 I=FE_OFN1491_n1442
XFE_OFC1362_n1442 BUF2CK $PINS O=FE_OFN1494_n1442 I=FE_OFN1490_n1442
XFE_OFC1361_n1442 INV1S $PINS O=FE_OFN1493_n1442 I=FE_OFN1489_n1442
XFE_OFC1360_n1442 BUF1 $PINS O=FE_OFN1492_n1442 I=FE_OFN1489_n1442
XFE_OFC1359_n1442 BUF1 $PINS O=FE_OFN1491_n1442 I=FE_OFN1486_n1442
XFE_OFC1358_n1442 BUF1 $PINS O=FE_OFN1490_n1442 I=FE_OFN1485_n1442
XFE_OFC1357_n1442 BUF1 $PINS O=FE_OFN1489_n1442 I=FE_OFN1485_n1442
XFE_OFC1356_n1442 BUF1 $PINS O=FE_OFN1488_n1442 I=FE_OFN1484_n1442
XFE_OFC1355_n1442 BUF1 $PINS O=FE_OFN1487_n1442 I=FE_OFN1484_n1442
XFE_OFC1354_n1442 INV2 $PINS O=FE_OFN1486_n1442 I=FE_OFN1483_n1442
XFE_OFC1353_n1442 INV1S $PINS O=FE_OFN1485_n1442 I=FE_OFN1483_n1442
XFE_OFC1352_n1442 BUF1 $PINS O=FE_OFN1484_n1442 I=FE_OFN1482_n1442
XFE_OFC1351_n1442 INV1S $PINS O=FE_OFN1483_n1442 I=n1442
XFE_OFC1350_n1442 BUF1 $PINS O=FE_OFN1482_n1442 I=n1442
XFE_OFC1349_n987 BUF1 $PINS O=FE_OFN1481_n987 I=FE_OFN1476_n987
XFE_OFC1348_n987 INV1S $PINS O=FE_OFN1480_n987 I=FE_OFN1475_n987
XFE_OFC1347_n987 INV1S $PINS O=FE_OFN1479_n987 I=FE_OFN1475_n987
XFE_OFC1346_n987 BUF1 $PINS O=FE_OFN1478_n987 I=FE_OFN1474_n987
XFE_OFC1345_n987 BUF1 $PINS O=FE_OFN1477_n987 I=FE_OFN1472_n987
XFE_OFC1344_n987 BUF1 $PINS O=FE_OFN1476_n987 I=FE_OFN1471_n987
XFE_OFC1343_n987 INV1S $PINS O=FE_OFN1475_n987 I=FE_OFN1470_n987
XFE_OFC1342_n987 INV1S $PINS O=FE_OFN1474_n987 I=FE_OFN1468_n987
XFE_OFC1341_n987 INV1S $PINS O=FE_OFN1473_n987 I=FE_OFN1468_n987
XFE_OFC1340_n987 BUF1 $PINS O=FE_OFN1472_n987 I=FE_OFN1467_n987
XFE_OFC1339_n987 INV1S $PINS O=FE_OFN1471_n987 I=FE_OFN1466_n987
XFE_OFC1338_n987 INV1S $PINS O=FE_OFN1470_n987 I=FE_OFN1466_n987
XFE_OFC1337_n987 BUF1 $PINS O=FE_OFN1469_n987 I=FE_OFN1465_n987
XFE_OFC1336_n987 INV1S $PINS O=FE_OFN1468_n987 I=FE_OFN1464_n987
XFE_OFC1335_n987 BUF1 $PINS O=FE_OFN1467_n987 I=FE_OFN1463_n987
XFE_OFC1334_n987 INV1S $PINS O=FE_OFN1466_n987 I=FE_OFN1462_n987
XFE_OFC1333_n987 BUF1 $PINS O=FE_OFN1465_n987 I=FE_DBTN85_n987
XFE_OFC1332_n987 BUF1 $PINS O=FE_OFN1464_n987 I=FE_DBTN85_n987
XFE_OFC1331_n987 BUF1 $PINS O=FE_OFN1463_n987 I=FE_OFN1458_n987
XFE_OFC1330_n987 BUF1 $PINS O=FE_OFN1462_n987 I=FE_OFN1458_n987
XFE_OFC1326_n987 INV1S $PINS O=FE_OFN1458_n987 I=FE_OFN1455_n987
XFE_OFC1324_n987 BUF1 $PINS O=FE_OFN1456_n987 I=FE_OFN1457_n987
XFE_OFC1318_n985 INV1S $PINS O=FE_OFN1450_n985 I=FE_OFN1656_FE_DBTN86_n985
XFE_OFC1304_FE_DBTN72_n3966 BUF1 $PINS O=FE_OFN1436_FE_DBTN72_n3966
+ I=FE_OFN1435_FE_DBTN72_n3966
XFE_OFC1303_FE_DBTN72_n3966 BUF1 $PINS O=FE_OFN1435_FE_DBTN72_n3966
+ I=FE_DBTN72_n3966
XFE_OFC1302_FE_DBTN75_n1441 BUF1 $PINS O=FE_OFN1434_FE_DBTN75_n1441
+ I=FE_OFN1433_FE_DBTN75_n1441
XFE_OFC1301_FE_DBTN75_n1441 BUF1 $PINS O=FE_OFN1433_FE_DBTN75_n1441
+ I=FE_DBTN75_n1441
XFE_OFC1292_n1441 BUF1 $PINS O=FE_OFN1424_n1441 I=FE_OFN1420_n1441
XFE_OFC1291_n1441 BUF1 $PINS O=FE_OFN1423_n1441 I=FE_OFN1419_n1441
XFE_OFC1290_n1441 BUF1 $PINS O=FE_OFN1422_n1441 I=FE_OFN5540_n
XFE_OFC1289_n1441 BUF1 $PINS O=FE_OFN1421_n1441 I=FE_OFN1412_n1441
XFE_OFC1288_n1441 INV1S $PINS O=FE_OFN1420_n1441 I=FE_OFN1411_n1441
XFE_OFC1287_n1441 INV2 $PINS O=FE_OFN1419_n1441 I=FE_OFN1411_n1441
XFE_OFC1282_n1441 INV1S $PINS O=FE_OFN1414_n1441 I=FE_OFN1378_n1441
XFE_OFC1280_n1441 INV1S $PINS O=FE_OFN1412_n1441 I=FE_OFN1378_n1441
XFE_OFC1279_n1441 INV2 $PINS O=FE_OFN1411_n1441 I=FE_OFN1404_n1441
XFE_OFC1278_n1441 INV1S $PINS O=FE_OFN1410_n1441 I=FE_OFN1403_n1441
XFE_OFC1277_n1441 INV1S $PINS O=FE_OFN1409_n1441 I=FE_OFN1403_n1441
XFE_OFC1275_n1441 INV1S $PINS O=FE_OFN1407_n1441 I=FE_OFN1399_n1441
XFE_OFC1274_n1441 INV1S $PINS O=FE_OFN1406_n1441 I=FE_OFN1399_n1441
XFE_OFC1272_n1441 BUF2CK $PINS O=FE_OFN1404_n1441 I=FE_OFN1396_n1441
XFE_OFC1271_n1441 INV1S $PINS O=FE_OFN1403_n1441 I=FE_OFN1395_n1441
XFE_OFC1270_n1441 INV1S $PINS O=FE_OFN1402_n1441 I=FE_OFN1394_n1441
XFE_OFC1269_n1441 INV1S $PINS O=FE_OFN1401_n1441 I=FE_OFN1394_n1441
XFE_OFC1267_n1441 INV1S $PINS O=FE_OFN1399_n1441 I=FE_OFN5582_FE_OFN1388_n1441
XFE_OFC1266_n1441 INV1S $PINS O=FE_OFN1398_n1441 I=FE_OFN1378_n1441
XFE_OFC1264_n1441 INV2 $PINS O=FE_OFN1396_n1441 I=FE_OFN1390_n1441
XFE_OFC1263_n1441 INV1S $PINS O=FE_OFN1395_n1441 I=FE_OFN1390_n1441
XFE_OFC1262_n1441 INV1S $PINS O=FE_OFN1394_n1441 I=FE_OFN1389_n1441
XFE_OFC1258_n1441 INV1S $PINS O=FE_OFN1390_n1441 I=FE_OFN1385_n1441
XFE_OFC1257_n1441 BUF1 $PINS O=FE_OFN1389_n1441 I=FE_OFN1381_n1441
XFE_OFC1252_n1441 INV1S $PINS O=FE_OFN1384_n1441 I=FE_OFN1378_n1441
XFE_OFC1250_n1441 BUF1 $PINS O=FE_OFN1382_n1441 I=FE_OFN1376_n1441
XFE_OFC1249_n1441 BUF1 $PINS O=FE_OFN1381_n1441 I=FE_OFN1376_n1441
XFE_OFC1246_n1441 INV3 $PINS O=FE_OFN1378_n1441 I=FE_OFN1369_n1441
XFE_OFC1245_n1441 BUF1 $PINS O=FE_OFN1377_n1441 I=FE_OFN1371_n1441
XFE_OFC1244_n1441 BUF1 $PINS O=FE_OFN1376_n1441 I=FE_OFN1370_n1441
XFE_OFC1243_n1441 INV2 $PINS O=FE_OFN1375_n1441 I=FE_OFN5572_n1441
XFE_OFC1242_n1441 BUF1 $PINS O=FE_OFN1374_n1441 I=FE_OFN1368_n1441
XFE_OFC1241_n1441 BUF1 $PINS O=FE_OFN1373_n1441 I=FE_OFN1367_n1441
XFE_OFC1239_n1441 INV1S $PINS O=FE_OFN1371_n1441 I=FE_OFN1363_n1441
XFE_OFC1238_n1441 INV1S $PINS O=FE_OFN1370_n1441 I=FE_OFN1363_n1441
XFE_OFC1236_n1441 INV1S $PINS O=FE_OFN1368_n1441 I=FE_OFN1365_n1441
XFE_OFC1235_n1441 BUF1 $PINS O=FE_OFN1367_n1441 I=FE_OFN1364_n1441
XFE_OFC1232_n1441 BUF1 $PINS O=FE_OFN1364_n1441 I=FE_OFN1361_n1441
XFE_OFC1229_n1441 INV1S $PINS O=FE_OFN1361_n1441 I=FE_OFN1365_n1441
XFE_OFC1227_n1434 BUF2 $PINS O=FE_OFN1359_n1434 I=n1434
XFE_OFC1226_n1 BUF1 $PINS O=FE_OFN1358_n1 I=FE_OFN1356_n1
XFE_OFC1225_n1 BUF1 $PINS O=FE_OFN1357_n1 I=FE_OFN1355_n1
XFE_OFC1224_n1 BUF1 $PINS O=FE_OFN1356_n1 I=n1
XFE_OFC1223_n1 BUF1 $PINS O=FE_OFN1355_n1 I=n1
XFE_OFC1222_n995 INV1S $PINS O=FE_OFN1354_n995 I=FE_OFN1352_n995
XFE_OFC1221_n995 INV1S $PINS O=FE_OFN1353_n995 I=FE_OFN1352_n995
XFE_OFC1220_n995 INV1S $PINS O=FE_OFN1352_n995 I=FE_OFN1351_n995
XFE_OFC1219_n995 INV1S $PINS O=FE_OFN1351_n995 I=FE_OFN1348_n995
XFE_OFC1218_n995 INV1S $PINS O=FE_OFN1350_n995 I=FE_OFN1348_n995
XFE_OFC1217_n995 BUF1 $PINS O=FE_OFN1349_n995 I=FE_OFN1347_n995
XFE_OFC1216_n995 INV1S $PINS O=FE_OFN1348_n995 I=FE_OFN1347_n995
XFE_OFC1215_n995 BUF1 $PINS O=FE_OFN1347_n995 I=FE_OFN1344_n995
XFE_OFC1213_n995 BUF1 $PINS O=FE_OFN1345_n995 I=FE_OFN1342_n995
XFE_OFC1212_n995 BUF1 $PINS O=FE_OFN1344_n995 I=FE_OFN1341_n995
XFE_OFC1211_n995 BUF1 $PINS O=FE_OFN1343_n995 I=FE_OFN1339_n995
XFE_OFC1210_n995 BUF1 $PINS O=FE_OFN1342_n995 I=FE_OFN1338_n995
XFE_OFC1209_n995 BUF1 $PINS O=FE_OFN1341_n995 I=FE_OFN1338_n995
XFE_OFC1207_n995 BUF1 $PINS O=FE_OFN1339_n995 I=FE_OFN1334_n995
XFE_OFC1206_n995 BUF1 $PINS O=FE_OFN1338_n995 I=FE_OFN1333_n995
XFE_OFC1205_n995 BUF1 $PINS O=FE_OFN1337_n995 I=FE_OFN1328_n995
XFE_OFC1204_n995 INV1S $PINS O=FE_OFN1336_n995 I=FE_OFN1331_n995
XFE_OFC1203_n995 INV1S $PINS O=FE_OFN1335_n995 I=FE_OFN1331_n995
XFE_OFC1202_n995 BUF1 $PINS O=FE_OFN1334_n995 I=FE_OFN1330_n995
XFE_OFC1201_n995 BUF1 $PINS O=FE_OFN1333_n995 I=FE_OFN1329_n995
XFE_OFC1199_n995 INV1S $PINS O=FE_OFN1331_n995 I=FE_OFN1327_n995
XFE_OFC1198_n995 BUF1 $PINS O=FE_OFN1330_n995 I=FE_OFN1326_n995
XFE_OFC1197_n995 BUF1 $PINS O=FE_OFN1329_n995 I=FE_OFN1325_n995
XFE_OFC1196_n995 BUF1 $PINS O=FE_OFN1328_n995 I=FE_OFN1324_n995
XFE_OFC1195_n995 BUF1 $PINS O=FE_OFN1327_n995 I=FE_OFN1323_n995
XFE_OFC1194_n995 BUF1 $PINS O=FE_OFN1326_n995 I=FE_OFN1322_n995
XFE_OFC1193_n995 BUF1 $PINS O=FE_OFN1325_n995 I=FE_OFN1319_n995
XFE_OFC1192_n995 BUF1 $PINS O=FE_OFN1324_n995 I=FE_OFN1318_n995
XFE_OFC1191_n995 BUF1 $PINS O=FE_OFN1323_n995 I=FE_OFN1317_n995
XFE_OFC1190_n995 INV1S $PINS O=FE_OFN1322_n995 I=FE_OFN1316_n995
XFE_OFC1188_n995 INV1S $PINS O=FE_OFN1320_n995 I=FE_OFN1315_n995
XFE_OFC1187_n995 INV1S $PINS O=FE_OFN1319_n995 I=FE_OFN1315_n995
XFE_OFC1186_n995 BUF1 $PINS O=FE_OFN1318_n995 I=FE_OFN1314_n995
XFE_OFC1185_n995 BUF1 $PINS O=FE_OFN1317_n995 I=FE_OFN1314_n995
XFE_OFC1184_n995 INV1S $PINS O=FE_OFN1316_n995 I=FE_OFN1313_n995
XFE_OFC1183_n995 INV1S $PINS O=FE_OFN1315_n995 I=FE_OFN1312_n995
XFE_OFC1182_n995 BUF1 $PINS O=FE_OFN1314_n995 I=FE_OFN1311_n995
XFE_OFC1181_n995 BUF1 $PINS O=FE_OFN1313_n995 I=FE_OFN1309_n995
XFE_OFC1180_n995 BUF1 $PINS O=FE_OFN1312_n995 I=FE_OFN1308_n995
XFE_OFC1179_n995 BUF1 $PINS O=FE_OFN1311_n995 I=FE_OFN1306_n995
XFE_OFC1178_n995 BUF1 $PINS O=FE_OFN1310_n995 I=FE_OFN1300_n995
XFE_OFC1177_n995 BUF1 $PINS O=FE_OFN1309_n995 I=FE_OFN1304_n995
XFE_OFC1176_n995 INV1S $PINS O=FE_OFN1308_n995 I=FE_OFN1301_n995
XFE_OFC1175_n995 INV1S $PINS O=FE_OFN1307_n995 I=FE_OFN1301_n995
XFE_OFC1174_n995 BUF1 $PINS O=FE_OFN1306_n995 I=FE_OFN1300_n995
XFE_OFC1172_n995 INV1S $PINS O=FE_OFN1304_n995 I=FE_OFN1298_n995
XFE_OFC1170_n995 BUF1 $PINS O=FE_OFN1302_n995 I=FE_OFN1297_n995
XFE_OFC1169_n995 INV1S $PINS O=FE_OFN1301_n995 I=FE_OFN1297_n995
XFE_OFC1168_n995 BUF1 $PINS O=FE_OFN1300_n995 I=FE_OFN1296_n995
XFE_OFC1166_n995 INV1S $PINS O=FE_OFN1298_n995 I=FE_OFN1295_n995
XFE_OFC1165_n995 BUF1 $PINS O=FE_OFN1297_n995 I=FE_OFN1294_n995
XFE_OFC1164_n995 BUF1 $PINS O=FE_OFN1296_n995 I=FE_OFN1293_n995
XFE_OFC1163_n995 BUF1 $PINS O=FE_OFN1295_n995 I=FE_OFN1292_n995
XFE_OFC1162_n995 BUF1 $PINS O=FE_OFN1294_n995 I=FE_OFN1290_n995
XFE_OFC1161_n995 BUF1 $PINS O=FE_OFN1293_n995 I=FE_OFN1286_n995
XFE_OFC1160_n995 INV1S $PINS O=FE_OFN1292_n995 I=FE_OFN1288_n995
XFE_OFC1158_n995 BUF1 $PINS O=FE_OFN1290_n995 I=FE_OFN1284_n995
XFE_OFC1156_n995 INV1S $PINS O=FE_OFN1288_n995 I=FE_OFN1285_n995
XFE_OFC1154_n995 INV1S $PINS O=FE_OFN1286_n995 I=FE_OFN1283_n995
XFE_OFC1153_n995 INV1S $PINS O=FE_OFN1285_n995 I=FE_OFN1283_n995
XFE_OFC1152_n995 BUF1 $PINS O=FE_OFN1284_n995 I=n995
XFE_OFC1151_n995 INV1S $PINS O=FE_OFN1283_n995 I=n995
XFE_OFC1147_backward_sum_0__2__10 BUF1 $PINS O=FE_OFN1279_backward_sum_0__2__10
+ I=backward_sum[0][2][10]
XFE_OFC1146_backward_sum_0__2__11 BUF1 $PINS O=FE_OFN1278_backward_sum_0__2__11
+ I=backward_sum[0][2][11]
XFE_OFC1145_backward_sum_0__0__10 BUF1 $PINS O=FE_OFN1277_backward_sum_0__0__10
+ I=backward_sum[0][0][10]
XFE_OFC1144_backward_sum_0__0__11 BUF1 $PINS O=FE_OFN1276_backward_sum_0__0__11
+ I=backward_sum[0][0][11]
XFE_OFC1142_backward_metrics_6__3__1 BUF1 $PINS
+ O=FE_OFN1274_backward_metrics_6__3__1 I=backward_metrics[6][3][1]
XFE_OFC1141_backward_metrics_6__3__2 BUF1 $PINS
+ O=FE_OFN1273_backward_metrics_6__3__2 I=backward_metrics[6][3][2]
XFE_OFC1140_backward_metrics_6__3__3 BUF1 $PINS
+ O=FE_OFN1272_backward_metrics_6__3__3 I=backward_metrics[6][3][3]
XFE_OFC1139_backward_metrics_6__3__4 BUF1 $PINS
+ O=FE_OFN1271_backward_metrics_6__3__4 I=backward_metrics[6][3][4]
XFE_OFC1138_backward_metrics_6__3__5 BUF1 $PINS
+ O=FE_OFN1270_backward_metrics_6__3__5 I=backward_metrics[6][3][5]
XFE_OFC1137_backward_metrics_6__3__6 BUF1 $PINS
+ O=FE_OFN1269_backward_metrics_6__3__6 I=backward_metrics[6][3][6]
XFE_OFC1136_backward_metrics_6__3__7 BUF1 $PINS
+ O=FE_OFN1268_backward_metrics_6__3__7 I=backward_metrics[6][3][7]
XFE_OFC1135_backward_metrics_6__3__8 BUF1 $PINS
+ O=FE_OFN1267_backward_metrics_6__3__8 I=backward_metrics[6][3][8]
XFE_OFC1134_backward_metrics_6__3__9 BUF1 $PINS
+ O=FE_OFN1266_backward_metrics_6__3__9 I=backward_metrics[6][3][9]
XFE_OFC1133_backward_metrics_6__3__10 BUF1 $PINS
+ O=FE_OFN1265_backward_metrics_6__3__10 I=backward_metrics[6][3][10]
XFE_OFC1132_backward_metrics_6__3__11 BUF1 $PINS
+ O=FE_OFN1264_backward_metrics_6__3__11 I=backward_metrics[6][3][11]
XFE_OFC1130_backward_metrics_6__1__0 BUF1 $PINS
+ O=FE_OFN1262_backward_metrics_6__1__0 I=backward_metrics[6][1][0]
XFE_OFC1128_backward_metrics_6__1__2 BUF1 $PINS
+ O=FE_OFN1260_backward_metrics_6__1__2 I=backward_metrics[6][1][2]
XFE_OFC1127_backward_metrics_6__1__3 BUF1 $PINS
+ O=FE_OFN1259_backward_metrics_6__1__3 I=backward_metrics[6][1][3]
XFE_OFC1126_backward_metrics_6__1__4 BUF1 $PINS
+ O=FE_OFN1258_backward_metrics_6__1__4 I=backward_metrics[6][1][4]
XFE_OFC1124_backward_metrics_6__1__6 BUF1 $PINS
+ O=FE_OFN1256_backward_metrics_6__1__6 I=backward_metrics[6][1][6]
XFE_OFC1123_backward_metrics_6__1__7 BUF1 $PINS
+ O=FE_OFN1255_backward_metrics_6__1__7 I=backward_metrics[6][1][7]
XFE_OFC1122_backward_metrics_6__1__8 BUF1 $PINS
+ O=FE_OFN1254_backward_metrics_6__1__8 I=backward_metrics[6][1][8]
XFE_OFC1121_backward_metrics_6__1__9 BUF1 $PINS
+ O=FE_OFN1253_backward_metrics_6__1__9 I=backward_metrics[6][1][9]
XFE_OFC1120_backward_metrics_6__1__10 BUF1 $PINS
+ O=FE_OFN1252_backward_metrics_6__1__10 I=backward_metrics[6][1][10]
XFE_OFC1119_backward_metrics_6__1__11 BUF1 $PINS
+ O=FE_OFN1251_backward_metrics_6__1__11 I=backward_metrics[6][1][11]
XFE_OFC1118_backward_metrics_6__0__0 BUF1 $PINS
+ O=FE_OFN1250_backward_metrics_6__0__0 I=backward_metrics[6][0][0]
XFE_OFC1116_backward_metrics_5__3__1 BUF1 $PINS
+ O=FE_OFN1248_backward_metrics_5__3__1 I=backward_metrics[5][3][1]
XFE_OFC1114_backward_metrics_5__3__3 BUF1 $PINS
+ O=FE_OFN1246_backward_metrics_5__3__3 I=backward_metrics[5][3][3]
XFE_OFC1113_backward_metrics_5__3__4 BUF1 $PINS
+ O=FE_OFN1245_backward_metrics_5__3__4 I=backward_metrics[5][3][4]
XFE_OFC1112_backward_metrics_5__3__5 BUF1 $PINS
+ O=FE_OFN1244_backward_metrics_5__3__5 I=backward_metrics[5][3][5]
XFE_OFC1111_backward_metrics_5__3__6 BUF1 $PINS
+ O=FE_OFN1243_backward_metrics_5__3__6 I=backward_metrics[5][3][6]
XFE_OFC1110_backward_metrics_5__3__7 BUF1 $PINS
+ O=FE_OFN1242_backward_metrics_5__3__7 I=backward_metrics[5][3][7]
XFE_OFC1109_backward_metrics_5__3__8 BUF1 $PINS
+ O=FE_OFN1241_backward_metrics_5__3__8 I=backward_metrics[5][3][8]
XFE_OFC1108_backward_metrics_5__3__9 BUF1 $PINS
+ O=FE_OFN1240_backward_metrics_5__3__9 I=backward_metrics[5][3][9]
XFE_OFC1107_backward_metrics_5__3__10 BUF1 $PINS
+ O=FE_OFN1239_backward_metrics_5__3__10 I=backward_metrics[5][3][10]
XFE_OFC1106_backward_metrics_5__3__11 BUF1 $PINS
+ O=FE_OFN1238_backward_metrics_5__3__11 I=backward_metrics[5][3][11]
XFE_OFC1103_backward_metrics_5__2__2 BUF1 $PINS
+ O=FE_OFN1235_backward_metrics_5__2__2 I=backward_metrics[5][2][2]
XFE_OFC1102_backward_metrics_5__2__3 BUF1 $PINS
+ O=FE_OFN1234_backward_metrics_5__2__3 I=backward_metrics[5][2][3]
XFE_OFC1099_backward_metrics_5__2__6 BUF1 $PINS
+ O=FE_OFN1231_backward_metrics_5__2__6 I=backward_metrics[5][2][6]
XFE_OFC1098_backward_metrics_5__2__7 BUF1 $PINS
+ O=FE_OFN1230_backward_metrics_5__2__7 I=backward_metrics[5][2][7]
XFE_OFC1097_backward_metrics_5__2__8 BUF1 $PINS
+ O=FE_OFN1229_backward_metrics_5__2__8 I=backward_metrics[5][2][8]
XFE_OFC1096_backward_metrics_5__2__9 BUF1 $PINS
+ O=FE_OFN1228_backward_metrics_5__2__9 I=backward_metrics[5][2][9]
XFE_OFC1095_backward_metrics_5__2__10 BUF1 $PINS
+ O=FE_OFN1227_backward_metrics_5__2__10 I=backward_metrics[5][2][10]
XFE_OFC1094_backward_metrics_5__2__11 BUF1 $PINS
+ O=FE_OFN1226_backward_metrics_5__2__11 I=backward_metrics[5][2][11]
XFE_OFC1093_backward_metrics_5__1__0 BUF1 $PINS
+ O=FE_OFN1225_backward_metrics_5__1__0 I=backward_metrics[5][1][0]
XFE_OFC1090_backward_metrics_5__1__3 BUF1 $PINS
+ O=FE_OFN1222_backward_metrics_5__1__3 I=backward_metrics[5][1][3]
XFE_OFC1087_backward_metrics_5__1__6 BUF1 $PINS
+ O=FE_OFN1219_backward_metrics_5__1__6 I=backward_metrics[5][1][6]
XFE_OFC1086_backward_metrics_5__1__7 BUF1 $PINS
+ O=FE_OFN1218_backward_metrics_5__1__7 I=backward_metrics[5][1][7]
XFE_OFC1085_backward_metrics_5__1__8 BUF1 $PINS
+ O=FE_OFN1217_backward_metrics_5__1__8 I=backward_metrics[5][1][8]
XFE_OFC1084_backward_metrics_5__1__9 BUF1 $PINS
+ O=FE_OFN1216_backward_metrics_5__1__9 I=backward_metrics[5][1][9]
XFE_OFC1083_backward_metrics_5__1__10 BUF1 $PINS
+ O=FE_OFN1215_backward_metrics_5__1__10 I=backward_metrics[5][1][10]
XFE_OFC1082_backward_metrics_5__1__11 BUF1 $PINS
+ O=FE_OFN1214_backward_metrics_5__1__11 I=backward_metrics[5][1][11]
XFE_OFC1079_backward_metrics_5__0__2 BUF1 $PINS
+ O=FE_OFN1211_backward_metrics_5__0__2 I=backward_metrics[5][0][2]
XFE_OFC1078_backward_metrics_5__0__3 BUF1 $PINS
+ O=FE_OFN1210_backward_metrics_5__0__3 I=backward_metrics[5][0][3]
XFE_OFC1077_backward_metrics_5__0__4 BUF1 $PINS
+ O=FE_OFN1209_backward_metrics_5__0__4 I=backward_metrics[5][0][4]
XFE_OFC1075_backward_metrics_5__0__6 BUF1 $PINS
+ O=FE_OFN1207_backward_metrics_5__0__6 I=backward_metrics[5][0][6]
XFE_OFC1074_backward_metrics_5__0__7 BUF1 $PINS
+ O=FE_OFN1206_backward_metrics_5__0__7 I=backward_metrics[5][0][7]
XFE_OFC1073_backward_metrics_5__0__8 BUF1 $PINS
+ O=FE_OFN1205_backward_metrics_5__0__8 I=backward_metrics[5][0][8]
XFE_OFC1072_backward_metrics_5__0__9 BUF1 $PINS
+ O=FE_OFN1204_backward_metrics_5__0__9 I=backward_metrics[5][0][9]
XFE_OFC1071_backward_metrics_5__0__10 BUF1 $PINS
+ O=FE_OFN1203_backward_metrics_5__0__10 I=backward_metrics[5][0][10]
XFE_OFC1070_backward_metrics_5__0__11 BUF1 $PINS
+ O=FE_OFN1202_backward_metrics_5__0__11 I=backward_metrics[5][0][11]
XFE_OFC1066_backward_metrics_4__3__3 BUF1 $PINS
+ O=FE_OFN1198_backward_metrics_4__3__3 I=backward_metrics[4][3][3]
XFE_OFC1065_backward_metrics_4__3__4 BUF1 $PINS
+ O=FE_OFN1197_backward_metrics_4__3__4 I=backward_metrics[4][3][4]
XFE_OFC1064_backward_metrics_4__3__5 BUF1 $PINS
+ O=FE_OFN1196_backward_metrics_4__3__5 I=backward_metrics[4][3][5]
XFE_OFC1063_backward_metrics_4__3__6 BUF1 $PINS
+ O=FE_OFN1195_backward_metrics_4__3__6 I=backward_metrics[4][3][6]
XFE_OFC1062_backward_metrics_4__3__7 BUF1 $PINS
+ O=FE_OFN1194_backward_metrics_4__3__7 I=backward_metrics[4][3][7]
XFE_OFC1061_backward_metrics_4__3__8 BUF1 $PINS
+ O=FE_OFN1193_backward_metrics_4__3__8 I=backward_metrics[4][3][8]
XFE_OFC1060_backward_metrics_4__3__9 BUF1 $PINS
+ O=FE_OFN1192_backward_metrics_4__3__9 I=backward_metrics[4][3][9]
XFE_OFC1059_backward_metrics_4__3__10 BUF1 $PINS
+ O=FE_OFN1191_backward_metrics_4__3__10 I=backward_metrics[4][3][10]
XFE_OFC1058_backward_metrics_4__3__11 BUF1 $PINS
+ O=FE_OFN1190_backward_metrics_4__3__11 I=backward_metrics[4][3][11]
XFE_OFC1057_backward_metrics_4__2__0 BUF1 $PINS
+ O=FE_OFN1189_backward_metrics_4__2__0 I=backward_metrics[4][2][0]
XFE_OFC1055_backward_metrics_4__2__2 BUF1 $PINS
+ O=FE_OFN1187_backward_metrics_4__2__2 I=backward_metrics[4][2][2]
XFE_OFC1053_backward_metrics_4__2__4 BUF1 $PINS
+ O=FE_OFN1185_backward_metrics_4__2__4 I=backward_metrics[4][2][4]
XFE_OFC1051_backward_metrics_4__2__6 BUF1 $PINS
+ O=FE_OFN1183_backward_metrics_4__2__6 I=backward_metrics[4][2][6]
XFE_OFC1050_backward_metrics_4__2__7 BUF1 $PINS
+ O=FE_OFN1182_backward_metrics_4__2__7 I=backward_metrics[4][2][7]
XFE_OFC1049_backward_metrics_4__2__8 BUF1 $PINS
+ O=FE_OFN1181_backward_metrics_4__2__8 I=backward_metrics[4][2][8]
XFE_OFC1048_backward_metrics_4__2__9 BUF1 $PINS
+ O=FE_OFN1180_backward_metrics_4__2__9 I=backward_metrics[4][2][9]
XFE_OFC1047_backward_metrics_4__2__10 BUF1 $PINS
+ O=FE_OFN1179_backward_metrics_4__2__10 I=backward_metrics[4][2][10]
XFE_OFC1046_backward_metrics_4__2__11 BUF1 $PINS
+ O=FE_OFN1178_backward_metrics_4__2__11 I=backward_metrics[4][2][11]
XFE_OFC1045_backward_metrics_4__1__0 BUF1 $PINS
+ O=FE_OFN1177_backward_metrics_4__1__0 I=backward_metrics[4][1][0]
XFE_OFC1039_backward_metrics_4__1__6 BUF1 $PINS
+ O=FE_OFN1171_backward_metrics_4__1__6 I=backward_metrics[4][1][6]
XFE_OFC1038_backward_metrics_4__1__7 BUF1 $PINS
+ O=FE_OFN1170_backward_metrics_4__1__7 I=backward_metrics[4][1][7]
XFE_OFC1037_backward_metrics_4__1__8 BUF1 $PINS
+ O=FE_OFN1169_backward_metrics_4__1__8 I=backward_metrics[4][1][8]
XFE_OFC1036_backward_metrics_4__1__9 BUF1 $PINS
+ O=FE_OFN1168_backward_metrics_4__1__9 I=backward_metrics[4][1][9]
XFE_OFC1035_backward_metrics_4__1__10 BUF1 $PINS
+ O=FE_OFN1167_backward_metrics_4__1__10 I=backward_metrics[4][1][10]
XFE_OFC1034_backward_metrics_4__1__11 BUF1 $PINS
+ O=FE_OFN1166_backward_metrics_4__1__11 I=backward_metrics[4][1][11]
XFE_OFC1031_backward_metrics_4__0__2 BUF1 $PINS
+ O=FE_OFN1163_backward_metrics_4__0__2 I=backward_metrics[4][0][2]
XFE_OFC1030_backward_metrics_4__0__3 BUF1 $PINS
+ O=FE_OFN1162_backward_metrics_4__0__3 I=backward_metrics[4][0][3]
XFE_OFC1027_backward_metrics_4__0__6 BUF1 $PINS
+ O=FE_OFN1159_backward_metrics_4__0__6 I=backward_metrics[4][0][6]
XFE_OFC1026_backward_metrics_4__0__7 BUF1 $PINS
+ O=FE_OFN1158_backward_metrics_4__0__7 I=backward_metrics[4][0][7]
XFE_OFC1025_backward_metrics_4__0__8 BUF1 $PINS
+ O=FE_OFN1157_backward_metrics_4__0__8 I=backward_metrics[4][0][8]
XFE_OFC1024_backward_metrics_4__0__9 BUF1 $PINS
+ O=FE_OFN1156_backward_metrics_4__0__9 I=backward_metrics[4][0][9]
XFE_OFC1023_backward_metrics_4__0__10 BUF1 $PINS
+ O=FE_OFN1155_backward_metrics_4__0__10 I=backward_metrics[4][0][10]
XFE_OFC1022_backward_metrics_4__0__11 BUF1 $PINS
+ O=FE_OFN1154_backward_metrics_4__0__11 I=backward_metrics[4][0][11]
XFE_OFC1018_backward_metrics_3__3__3 BUF1 $PINS
+ O=FE_OFN1150_backward_metrics_3__3__3 I=backward_metrics[3][3][3]
XFE_OFC1017_backward_metrics_3__3__4 BUF1 $PINS
+ O=FE_OFN1149_backward_metrics_3__3__4 I=backward_metrics[3][3][4]
XFE_OFC1015_backward_metrics_3__3__6 BUF1 $PINS
+ O=FE_OFN1147_backward_metrics_3__3__6 I=backward_metrics[3][3][6]
XFE_OFC1014_backward_metrics_3__3__7 BUF1 $PINS
+ O=FE_OFN1146_backward_metrics_3__3__7 I=backward_metrics[3][3][7]
XFE_OFC1013_backward_metrics_3__3__8 BUF1 $PINS
+ O=FE_OFN1145_backward_metrics_3__3__8 I=backward_metrics[3][3][8]
XFE_OFC1012_backward_metrics_3__3__9 BUF1 $PINS
+ O=FE_OFN1144_backward_metrics_3__3__9 I=backward_metrics[3][3][9]
XFE_OFC1011_backward_metrics_3__3__10 BUF1 $PINS
+ O=FE_OFN1143_backward_metrics_3__3__10 I=backward_metrics[3][3][10]
XFE_OFC1010_backward_metrics_3__3__11 BUF1 $PINS
+ O=FE_OFN1142_backward_metrics_3__3__11 I=backward_metrics[3][3][11]
XFE_OFC1005_backward_metrics_3__2__4 BUF1 $PINS
+ O=FE_OFN1137_backward_metrics_3__2__4 I=backward_metrics[3][2][4]
XFE_OFC1004_backward_metrics_3__2__5 BUF1 $PINS
+ O=FE_OFN1136_backward_metrics_3__2__5 I=backward_metrics[3][2][5]
XFE_OFC1003_backward_metrics_3__2__6 BUF1 $PINS
+ O=FE_OFN1135_backward_metrics_3__2__6 I=backward_metrics[3][2][6]
XFE_OFC1002_backward_metrics_3__2__7 BUF1 $PINS
+ O=FE_OFN1134_backward_metrics_3__2__7 I=backward_metrics[3][2][7]
XFE_OFC1001_backward_metrics_3__2__8 BUF1 $PINS
+ O=FE_OFN1133_backward_metrics_3__2__8 I=backward_metrics[3][2][8]
XFE_OFC1000_backward_metrics_3__2__9 BUF1 $PINS
+ O=FE_OFN1132_backward_metrics_3__2__9 I=backward_metrics[3][2][9]
XFE_OFC999_backward_metrics_3__2__10 BUF1 $PINS
+ O=FE_OFN1131_backward_metrics_3__2__10 I=backward_metrics[3][2][10]
XFE_OFC998_backward_metrics_3__2__11 BUF1 $PINS
+ O=FE_OFN1130_backward_metrics_3__2__11 I=backward_metrics[3][2][11]
XFE_OFC992_backward_metrics_3__1__5 BUF1 $PINS
+ O=FE_OFN1124_backward_metrics_3__1__5 I=backward_metrics[3][1][5]
XFE_OFC991_backward_metrics_3__1__6 BUF1 $PINS
+ O=FE_OFN1123_backward_metrics_3__1__6 I=backward_metrics[3][1][6]
XFE_OFC990_backward_metrics_3__1__7 BUF1 $PINS
+ O=FE_OFN1122_backward_metrics_3__1__7 I=backward_metrics[3][1][7]
XFE_OFC989_backward_metrics_3__1__8 BUF1 $PINS
+ O=FE_OFN1121_backward_metrics_3__1__8 I=backward_metrics[3][1][8]
XFE_OFC988_backward_metrics_3__1__9 BUF1 $PINS
+ O=FE_OFN1120_backward_metrics_3__1__9 I=backward_metrics[3][1][9]
XFE_OFC987_backward_metrics_3__1__10 BUF1 $PINS
+ O=FE_OFN1119_backward_metrics_3__1__10 I=backward_metrics[3][1][10]
XFE_OFC986_backward_metrics_3__1__11 BUF1 $PINS
+ O=FE_OFN1118_backward_metrics_3__1__11 I=backward_metrics[3][1][11]
XFE_OFC979_backward_metrics_3__0__6 BUF1 $PINS
+ O=FE_OFN1111_backward_metrics_3__0__6 I=backward_metrics[3][0][6]
XFE_OFC978_backward_metrics_3__0__7 BUF1 $PINS
+ O=FE_OFN1110_backward_metrics_3__0__7 I=backward_metrics[3][0][7]
XFE_OFC977_backward_metrics_3__0__8 BUF1 $PINS
+ O=FE_OFN1109_backward_metrics_3__0__8 I=backward_metrics[3][0][8]
XFE_OFC976_backward_metrics_3__0__9 BUF1 $PINS
+ O=FE_OFN1108_backward_metrics_3__0__9 I=backward_metrics[3][0][9]
XFE_OFC975_backward_metrics_3__0__10 BUF1 $PINS
+ O=FE_OFN1107_backward_metrics_3__0__10 I=backward_metrics[3][0][10]
XFE_OFC974_backward_metrics_3__0__11 BUF1 $PINS
+ O=FE_OFN1106_backward_metrics_3__0__11 I=backward_metrics[3][0][11]
XFE_OFC970_backward_metrics_2__3__3 BUF1 $PINS
+ O=FE_OFN1102_backward_metrics_2__3__3 I=backward_metrics[2][3][3]
XFE_OFC969_backward_metrics_2__3__4 BUF1 $PINS
+ O=FE_OFN1101_backward_metrics_2__3__4 I=backward_metrics[2][3][4]
XFE_OFC967_backward_metrics_2__3__6 BUF1 $PINS
+ O=FE_OFN1099_backward_metrics_2__3__6 I=backward_metrics[2][3][6]
XFE_OFC966_backward_metrics_2__3__7 BUF1 $PINS
+ O=FE_OFN1098_backward_metrics_2__3__7 I=backward_metrics[2][3][7]
XFE_OFC965_backward_metrics_2__3__8 BUF1 $PINS
+ O=FE_OFN1097_backward_metrics_2__3__8 I=backward_metrics[2][3][8]
XFE_OFC964_backward_metrics_2__3__9 BUF1 $PINS
+ O=FE_OFN1096_backward_metrics_2__3__9 I=backward_metrics[2][3][9]
XFE_OFC963_backward_metrics_2__3__10 BUF1 $PINS
+ O=FE_OFN1095_backward_metrics_2__3__10 I=backward_metrics[2][3][10]
XFE_OFC962_backward_metrics_2__3__11 BUF1 $PINS
+ O=FE_OFN1094_backward_metrics_2__3__11 I=backward_metrics[2][3][11]
XFE_OFC958_backward_metrics_2__2__3 BUF1 $PINS
+ O=FE_OFN1090_backward_metrics_2__2__3 I=backward_metrics[2][2][3]
XFE_OFC957_backward_metrics_2__2__4 BUF1 $PINS
+ O=FE_OFN1089_backward_metrics_2__2__4 I=backward_metrics[2][2][4]
XFE_OFC955_backward_metrics_2__2__6 BUF1 $PINS
+ O=FE_OFN1087_backward_metrics_2__2__6 I=backward_metrics[2][2][6]
XFE_OFC954_backward_metrics_2__2__7 BUF1 $PINS
+ O=FE_OFN1086_backward_metrics_2__2__7 I=backward_metrics[2][2][7]
XFE_OFC953_backward_metrics_2__2__8 BUF1 $PINS
+ O=FE_OFN1085_backward_metrics_2__2__8 I=backward_metrics[2][2][8]
XFE_OFC952_backward_metrics_2__2__9 BUF1 $PINS
+ O=FE_OFN1084_backward_metrics_2__2__9 I=backward_metrics[2][2][9]
XFE_OFC951_backward_metrics_2__2__10 BUF1 $PINS
+ O=FE_OFN1083_backward_metrics_2__2__10 I=backward_metrics[2][2][10]
XFE_OFC950_backward_metrics_2__2__11 BUF1 $PINS
+ O=FE_OFN1082_backward_metrics_2__2__11 I=backward_metrics[2][2][11]
XFE_OFC947_backward_metrics_2__1__2 BUF1 $PINS
+ O=FE_OFN1079_backward_metrics_2__1__2 I=backward_metrics[2][1][2]
XFE_OFC943_backward_metrics_2__1__6 BUF1 $PINS
+ O=FE_OFN1075_backward_metrics_2__1__6 I=backward_metrics[2][1][6]
XFE_OFC942_backward_metrics_2__1__7 BUF1 $PINS
+ O=FE_OFN1074_backward_metrics_2__1__7 I=backward_metrics[2][1][7]
XFE_OFC941_backward_metrics_2__1__8 BUF1 $PINS
+ O=FE_OFN1073_backward_metrics_2__1__8 I=backward_metrics[2][1][8]
XFE_OFC940_backward_metrics_2__1__9 BUF1 $PINS
+ O=FE_OFN1072_backward_metrics_2__1__9 I=backward_metrics[2][1][9]
XFE_OFC939_backward_metrics_2__1__10 BUF1 $PINS
+ O=FE_OFN1071_backward_metrics_2__1__10 I=backward_metrics[2][1][10]
XFE_OFC938_backward_metrics_2__1__11 BUF1 $PINS
+ O=FE_OFN1070_backward_metrics_2__1__11 I=backward_metrics[2][1][11]
XFE_OFC935_backward_metrics_2__0__2 BUF1 $PINS
+ O=FE_OFN1067_backward_metrics_2__0__2 I=backward_metrics[2][0][2]
XFE_OFC934_backward_metrics_2__0__3 BUF1 $PINS
+ O=FE_OFN1066_backward_metrics_2__0__3 I=backward_metrics[2][0][3]
XFE_OFC933_backward_metrics_2__0__4 BUF1 $PINS
+ O=FE_OFN1065_backward_metrics_2__0__4 I=backward_metrics[2][0][4]
XFE_OFC931_backward_metrics_2__0__6 BUF1 $PINS
+ O=FE_OFN1063_backward_metrics_2__0__6 I=backward_metrics[2][0][6]
XFE_OFC930_backward_metrics_2__0__7 BUF1 $PINS
+ O=FE_OFN1062_backward_metrics_2__0__7 I=backward_metrics[2][0][7]
XFE_OFC929_backward_metrics_2__0__8 BUF1 $PINS
+ O=FE_OFN1061_backward_metrics_2__0__8 I=backward_metrics[2][0][8]
XFE_OFC928_backward_metrics_2__0__9 BUF1 $PINS
+ O=FE_OFN1060_backward_metrics_2__0__9 I=backward_metrics[2][0][9]
XFE_OFC927_backward_metrics_2__0__10 BUF1 $PINS
+ O=FE_OFN1059_backward_metrics_2__0__10 I=backward_metrics[2][0][10]
XFE_OFC926_backward_metrics_2__0__11 BUF1 $PINS
+ O=FE_OFN1058_backward_metrics_2__0__11 I=backward_metrics[2][0][11]
XFE_OFC923_backward_metrics_1__3__2 BUF1 $PINS
+ O=FE_OFN1055_backward_metrics_1__3__2 I=backward_metrics[1][3][2]
XFE_OFC922_backward_metrics_1__3__3 BUF1 $PINS
+ O=FE_OFN1054_backward_metrics_1__3__3 I=backward_metrics[1][3][3]
XFE_OFC921_backward_metrics_1__3__4 BUF1 $PINS
+ O=FE_OFN1053_backward_metrics_1__3__4 I=backward_metrics[1][3][4]
XFE_OFC920_backward_metrics_1__3__5 BUF1 $PINS
+ O=FE_OFN1052_backward_metrics_1__3__5 I=backward_metrics[1][3][5]
XFE_OFC919_backward_metrics_1__3__6 BUF1 $PINS
+ O=FE_OFN1051_backward_metrics_1__3__6 I=backward_metrics[1][3][6]
XFE_OFC918_backward_metrics_1__3__7 BUF1 $PINS
+ O=FE_OFN1050_backward_metrics_1__3__7 I=backward_metrics[1][3][7]
XFE_OFC917_backward_metrics_1__3__8 BUF1 $PINS
+ O=FE_OFN1049_backward_metrics_1__3__8 I=backward_metrics[1][3][8]
XFE_OFC916_backward_metrics_1__3__9 BUF1 $PINS
+ O=FE_OFN1048_backward_metrics_1__3__9 I=backward_metrics[1][3][9]
XFE_OFC915_backward_metrics_1__3__10 BUF1 $PINS
+ O=FE_OFN1047_backward_metrics_1__3__10 I=backward_metrics[1][3][10]
XFE_OFC914_backward_metrics_1__3__11 BUF1 $PINS
+ O=FE_OFN1046_backward_metrics_1__3__11 I=backward_metrics[1][3][11]
XFE_OFC912_backward_metrics_1__2__1 BUF1 $PINS
+ O=FE_OFN1044_backward_metrics_1__2__1 I=backward_metrics[1][2][1]
XFE_OFC911_backward_metrics_1__2__2 BUF1 $PINS
+ O=FE_OFN1043_backward_metrics_1__2__2 I=backward_metrics[1][2][2]
XFE_OFC908_backward_metrics_1__2__5 BUF1 $PINS
+ O=FE_OFN1040_backward_metrics_1__2__5 I=backward_metrics[1][2][5]
XFE_OFC907_backward_metrics_1__2__6 BUF1 $PINS
+ O=FE_OFN1039_backward_metrics_1__2__6 I=backward_metrics[1][2][6]
XFE_OFC906_backward_metrics_1__2__7 BUF1 $PINS
+ O=FE_OFN1038_backward_metrics_1__2__7 I=backward_metrics[1][2][7]
XFE_OFC905_backward_metrics_1__2__8 BUF1 $PINS
+ O=FE_OFN1037_backward_metrics_1__2__8 I=backward_metrics[1][2][8]
XFE_OFC904_backward_metrics_1__2__9 BUF1 $PINS
+ O=FE_OFN1036_backward_metrics_1__2__9 I=backward_metrics[1][2][9]
XFE_OFC903_backward_metrics_1__2__10 BUF1 $PINS
+ O=FE_OFN1035_backward_metrics_1__2__10 I=backward_metrics[1][2][10]
XFE_OFC902_backward_metrics_1__2__11 BUF1 $PINS
+ O=FE_OFN1034_backward_metrics_1__2__11 I=backward_metrics[1][2][11]
XFE_OFC899_backward_metrics_1__1__2 BUF1 $PINS
+ O=FE_OFN1031_backward_metrics_1__1__2 I=backward_metrics[1][1][2]
XFE_OFC898_backward_metrics_1__1__3 BUF1 $PINS
+ O=FE_OFN1030_backward_metrics_1__1__3 I=backward_metrics[1][1][3]
XFE_OFC897_backward_metrics_1__1__4 BUF1 $PINS
+ O=FE_OFN1029_backward_metrics_1__1__4 I=backward_metrics[1][1][4]
XFE_OFC895_backward_metrics_1__1__6 BUF1 $PINS
+ O=FE_OFN1027_backward_metrics_1__1__6 I=backward_metrics[1][1][6]
XFE_OFC894_backward_metrics_1__1__7 BUF1 $PINS
+ O=FE_OFN1026_backward_metrics_1__1__7 I=backward_metrics[1][1][7]
XFE_OFC893_backward_metrics_1__1__8 BUF1 $PINS
+ O=FE_OFN1025_backward_metrics_1__1__8 I=backward_metrics[1][1][8]
XFE_OFC892_backward_metrics_1__1__9 BUF1 $PINS
+ O=FE_OFN1024_backward_metrics_1__1__9 I=backward_metrics[1][1][9]
XFE_OFC891_backward_metrics_1__1__10 BUF1 $PINS
+ O=FE_OFN1023_backward_metrics_1__1__10 I=backward_metrics[1][1][10]
XFE_OFC890_backward_metrics_1__1__11 BUF1 $PINS
+ O=FE_OFN1022_backward_metrics_1__1__11 I=backward_metrics[1][1][11]
XFE_OFC889_backward_metrics_1__0__0 BUF1 $PINS
+ O=FE_OFN1021_backward_metrics_1__0__0 I=backward_metrics[1][0][0]
XFE_OFC886_backward_metrics_1__0__3 BUF1 $PINS
+ O=FE_OFN1018_backward_metrics_1__0__3 I=backward_metrics[1][0][3]
XFE_OFC885_backward_metrics_1__0__4 BUF1 $PINS
+ O=FE_OFN1017_backward_metrics_1__0__4 I=backward_metrics[1][0][4]
XFE_OFC884_backward_metrics_1__0__5 BUF1 $PINS
+ O=FE_OFN1016_backward_metrics_1__0__5 I=backward_metrics[1][0][5]
XFE_OFC883_backward_metrics_1__0__6 BUF1 $PINS
+ O=FE_OFN1015_backward_metrics_1__0__6 I=backward_metrics[1][0][6]
XFE_OFC882_backward_metrics_1__0__7 BUF1 $PINS
+ O=FE_OFN1014_backward_metrics_1__0__7 I=backward_metrics[1][0][7]
XFE_OFC881_backward_metrics_1__0__8 BUF1 $PINS
+ O=FE_OFN1013_backward_metrics_1__0__8 I=backward_metrics[1][0][8]
XFE_OFC880_backward_metrics_1__0__9 BUF1 $PINS
+ O=FE_OFN1012_backward_metrics_1__0__9 I=backward_metrics[1][0][9]
XFE_OFC879_backward_metrics_1__0__10 BUF1 $PINS
+ O=FE_OFN1011_backward_metrics_1__0__10 I=backward_metrics[1][0][10]
XFE_OFC878_backward_metrics_1__0__11 BUF1 $PINS
+ O=FE_OFN1010_backward_metrics_1__0__11 I=backward_metrics[1][0][11]
XFE_OFC877_forward_sum_0__6__0 BUF1 $PINS O=FE_OFN1009_forward_sum_0__6__0
+ I=forward_sum[0][6][0]
XFE_OFC876_forward_sum_0__6__1 BUF1 $PINS O=FE_OFN1008_forward_sum_0__6__1
+ I=forward_sum[0][6][1]
XFE_OFC874_forward_sum_0__6__3 BUF1 $PINS O=FE_OFN1006_forward_sum_0__6__3
+ I=forward_sum[0][6][3]
XFE_OFC873_forward_sum_0__6__4 BUF1 $PINS O=FE_OFN1005_forward_sum_0__6__4
+ I=forward_sum[0][6][4]
XFE_OFC872_forward_sum_0__6__5 BUF1 $PINS O=FE_OFN1004_forward_sum_0__6__5
+ I=forward_sum[0][6][5]
XFE_OFC871_forward_sum_0__6__6 BUF1 $PINS O=FE_OFN1003_forward_sum_0__6__6
+ I=forward_sum[0][6][6]
XFE_OFC870_forward_sum_0__6__7 BUF1 $PINS O=FE_OFN1002_forward_sum_0__6__7
+ I=forward_sum[0][6][7]
XFE_OFC869_forward_sum_0__6__8 BUF1 $PINS O=FE_OFN1001_forward_sum_0__6__8
+ I=forward_sum[0][6][8]
XFE_OFC868_forward_sum_0__6__9 BUF1 $PINS O=FE_OFN1000_forward_sum_0__6__9
+ I=forward_sum[0][6][9]
XFE_OFC867_forward_sum_0__5__0 BUF1 $PINS O=FE_OFN999_forward_sum_0__5__0
+ I=forward_sum[0][5][0]
XFE_OFC865_forward_sum_0__5__2 BUF1 $PINS O=FE_OFN997_forward_sum_0__5__2
+ I=forward_sum[0][5][2]
XFE_OFC863_forward_sum_0__5__4 BUF1 $PINS O=FE_OFN995_forward_sum_0__5__4
+ I=forward_sum[0][5][4]
XFE_OFC862_forward_sum_0__5__5 BUF1 $PINS O=FE_OFN994_forward_sum_0__5__5
+ I=forward_sum[0][5][5]
XFE_OFC861_forward_sum_0__5__6 BUF1 $PINS O=FE_OFN993_forward_sum_0__5__6
+ I=forward_sum[0][5][6]
XFE_OFC860_forward_sum_0__5__7 BUF1 $PINS O=FE_OFN992_forward_sum_0__5__7
+ I=forward_sum[0][5][7]
XFE_OFC859_forward_sum_0__5__8 BUF1 $PINS O=FE_OFN991_forward_sum_0__5__8
+ I=forward_sum[0][5][8]
XFE_OFC858_forward_sum_0__5__9 BUF1 $PINS O=FE_OFN990_forward_sum_0__5__9
+ I=forward_sum[0][5][9]
XFE_OFC856_forward_sum_0__2__1 BUF1 $PINS O=FE_OFN988_forward_sum_0__2__1
+ I=forward_sum[0][2][1]
XFE_OFC853_forward_sum_0__2__4 BUF1 $PINS O=FE_OFN985_forward_sum_0__2__4
+ I=forward_sum[0][2][4]
XFE_OFC852_forward_sum_0__2__5 BUF1 $PINS O=FE_OFN984_forward_sum_0__2__5
+ I=forward_sum[0][2][5]
XFE_OFC851_forward_sum_0__2__6 BUF1 $PINS O=FE_OFN983_forward_sum_0__2__6
+ I=forward_sum[0][2][6]
XFE_OFC850_forward_sum_0__2__7 BUF1 $PINS O=FE_OFN982_forward_sum_0__2__7
+ I=forward_sum[0][2][7]
XFE_OFC849_forward_sum_0__2__8 BUF1 $PINS O=FE_OFN981_forward_sum_0__2__8
+ I=forward_sum[0][2][8]
XFE_OFC848_forward_sum_0__2__9 BUF1 $PINS O=FE_OFN980_forward_sum_0__2__9
+ I=forward_sum[0][2][9]
XFE_OFC847_forward_sum_0__1__0 BUF1 $PINS O=FE_OFN979_forward_sum_0__1__0
+ I=forward_sum[0][1][0]
XFE_OFC842_forward_sum_0__1__5 BUF1 $PINS O=FE_OFN974_forward_sum_0__1__5
+ I=forward_sum[0][1][5]
XFE_OFC841_forward_sum_0__1__6 BUF1 $PINS O=FE_OFN973_forward_sum_0__1__6
+ I=forward_sum[0][1][6]
XFE_OFC840_forward_sum_0__1__7 BUF1 $PINS O=FE_OFN972_forward_sum_0__1__7
+ I=forward_sum[0][1][7]
XFE_OFC839_forward_sum_0__1__8 BUF1 $PINS O=FE_OFN971_forward_sum_0__1__8
+ I=forward_sum[0][1][8]
XFE_OFC838_forward_sum_0__1__9 BUF1 $PINS O=FE_OFN970_forward_sum_0__1__9
+ I=forward_sum[0][1][9]
XFE_OFC837_branch_metrics_6__3__10 BUF1 $PINS
+ O=FE_OFN969_branch_metrics_6__3__10 I=branch_metrics[6][3][10]
XFE_OFC836_branch_metrics_6__1__10 BUF1 $PINS
+ O=FE_OFN968_branch_metrics_6__1__10 I=branch_metrics[6][1][10]
XFE_OFC834_branch_metrics_5__3__1 BUF1 $PINS O=FE_OFN966_branch_metrics_5__3__1
+ I=branch_metrics[5][3][1]
XFE_OFC830_branch_metrics_5__3__5 BUF1 $PINS O=FE_OFN962_branch_metrics_5__3__5
+ I=branch_metrics[5][3][5]
XFE_OFC828_branch_metrics_5__3__7 BUF1 $PINS O=FE_OFN960_branch_metrics_5__3__7
+ I=branch_metrics[5][3][7]
XFE_OFC827_branch_metrics_5__3__8 BUF1 $PINS O=FE_OFN959_branch_metrics_5__3__8
+ I=branch_metrics[5][3][8]
XFE_OFC826_branch_metrics_5__3__9 BUF1 $PINS O=FE_OFN958_branch_metrics_5__3__9
+ I=branch_metrics[5][3][9]
XFE_OFC825_branch_metrics_5__3__10 BUF1 $PINS
+ O=FE_OFN957_branch_metrics_5__3__10 I=branch_metrics[5][3][10]
XFE_OFC824_branch_metrics_5__3__11 BUF1 $PINS
+ O=FE_OFN956_branch_metrics_5__3__11 I=branch_metrics[5][3][11]
XFE_OFC823_branch_metrics_5__2__0 BUF1 $PINS O=FE_OFN955_branch_metrics_5__2__0
+ I=branch_metrics[5][2][0]
XFE_OFC820_branch_metrics_5__2__3 BUF1 $PINS O=FE_OFN952_branch_metrics_5__2__3
+ I=branch_metrics[5][2][3]
XFE_OFC817_branch_metrics_5__2__6 BUF1 $PINS O=FE_OFN949_branch_metrics_5__2__6
+ I=branch_metrics[5][2][6]
XFE_OFC816_branch_metrics_5__2__7 BUF1 $PINS O=FE_OFN948_branch_metrics_5__2__7
+ I=branch_metrics[5][2][7]
XFE_OFC815_branch_metrics_5__2__8 BUF1 $PINS O=FE_OFN947_branch_metrics_5__2__8
+ I=branch_metrics[5][2][8]
XFE_OFC814_branch_metrics_5__2__9 BUF1 $PINS O=FE_OFN946_branch_metrics_5__2__9
+ I=branch_metrics[5][2][9]
XFE_OFC813_branch_metrics_5__2__10 BUF1 $PINS
+ O=FE_OFN945_branch_metrics_5__2__10 I=branch_metrics[5][2][10]
XFE_OFC812_branch_metrics_5__2__11 BUF1 $PINS
+ O=FE_OFN944_branch_metrics_5__2__11 I=branch_metrics[5][2][11]
XFE_OFC809_branch_metrics_5__1__3 BUF1 $PINS O=FE_OFN941_branch_metrics_5__1__3
+ I=branch_metrics[5][1][3]
XFE_OFC807_branch_metrics_5__1__5 BUF1 $PINS O=FE_OFN939_branch_metrics_5__1__5
+ I=branch_metrics[5][1][5]
XFE_OFC806_branch_metrics_5__1__6 BUF1 $PINS O=FE_OFN938_branch_metrics_5__1__6
+ I=branch_metrics[5][1][6]
XFE_OFC805_branch_metrics_5__1__7 BUF1 $PINS O=FE_OFN937_branch_metrics_5__1__7
+ I=branch_metrics[5][1][7]
XFE_OFC804_branch_metrics_5__1__8 BUF1 $PINS O=FE_OFN936_branch_metrics_5__1__8
+ I=branch_metrics[5][1][8]
XFE_OFC803_branch_metrics_5__1__9 BUF1 $PINS O=FE_OFN935_branch_metrics_5__1__9
+ I=branch_metrics[5][1][9]
XFE_OFC802_branch_metrics_5__1__10 BUF1 $PINS
+ O=FE_OFN934_branch_metrics_5__1__10 I=branch_metrics[5][1][10]
XFE_OFC801_branch_metrics_5__1__11 BUF1 $PINS
+ O=FE_OFN933_branch_metrics_5__1__11 I=branch_metrics[5][1][11]
XFE_OFC795_branch_metrics_5__0__5 BUF1 $PINS O=FE_OFN927_branch_metrics_5__0__5
+ I=branch_metrics[5][0][5]
XFE_OFC794_branch_metrics_5__0__6 BUF1 $PINS O=FE_OFN926_branch_metrics_5__0__6
+ I=branch_metrics[5][0][6]
XFE_OFC793_branch_metrics_5__0__7 BUF1 $PINS O=FE_OFN925_branch_metrics_5__0__7
+ I=branch_metrics[5][0][7]
XFE_OFC792_branch_metrics_5__0__8 BUF1 $PINS O=FE_OFN924_branch_metrics_5__0__8
+ I=branch_metrics[5][0][8]
XFE_OFC791_branch_metrics_5__0__9 BUF1 $PINS O=FE_OFN923_branch_metrics_5__0__9
+ I=branch_metrics[5][0][9]
XFE_OFC790_branch_metrics_5__0__10 BUF1 $PINS
+ O=FE_OFN922_branch_metrics_5__0__10 I=branch_metrics[5][0][10]
XFE_OFC789_branch_metrics_5__0__11 BUF1 $PINS
+ O=FE_OFN921_branch_metrics_5__0__11 I=branch_metrics[5][0][11]
XFE_OFC788_branch_metrics_4__3__0 BUF1 $PINS O=FE_OFN920_branch_metrics_4__3__0
+ I=branch_metrics[4][3][0]
XFE_OFC787_branch_metrics_4__3__1 BUF1 $PINS O=FE_OFN919_branch_metrics_4__3__1
+ I=branch_metrics[4][3][1]
XFE_OFC782_branch_metrics_4__3__6 BUF1 $PINS O=FE_OFN914_branch_metrics_4__3__6
+ I=branch_metrics[4][3][6]
XFE_OFC781_branch_metrics_4__3__7 BUF1 $PINS O=FE_OFN913_branch_metrics_4__3__7
+ I=branch_metrics[4][3][7]
XFE_OFC780_branch_metrics_4__3__8 BUF1 $PINS O=FE_OFN912_branch_metrics_4__3__8
+ I=branch_metrics[4][3][8]
XFE_OFC779_branch_metrics_4__3__9 BUF1 $PINS O=FE_OFN911_branch_metrics_4__3__9
+ I=branch_metrics[4][3][9]
XFE_OFC778_branch_metrics_4__3__10 BUF1 $PINS
+ O=FE_OFN910_branch_metrics_4__3__10 I=branch_metrics[4][3][10]
XFE_OFC777_branch_metrics_4__3__11 BUF1 $PINS
+ O=FE_OFN909_branch_metrics_4__3__11 I=branch_metrics[4][3][11]
XFE_OFC775_branch_metrics_4__2__1 BUF2 $PINS O=FE_OFN907_branch_metrics_4__2__1
+ I=branch_metrics[4][2][1]
XFE_OFC769_branch_metrics_4__2__7 BUF1 $PINS O=FE_OFN901_branch_metrics_4__2__7
+ I=branch_metrics[4][2][7]
XFE_OFC768_branch_metrics_4__2__8 BUF1 $PINS O=FE_OFN900_branch_metrics_4__2__8
+ I=branch_metrics[4][2][8]
XFE_OFC767_branch_metrics_4__2__9 BUF1 $PINS O=FE_OFN899_branch_metrics_4__2__9
+ I=branch_metrics[4][2][9]
XFE_OFC766_branch_metrics_4__2__10 BUF1 $PINS
+ O=FE_OFN898_branch_metrics_4__2__10 I=branch_metrics[4][2][10]
XFE_OFC765_branch_metrics_4__2__11 BUF1 $PINS
+ O=FE_OFN897_branch_metrics_4__2__11 I=branch_metrics[4][2][11]
XFE_OFC764_branch_metrics_4__1__0 BUF1 $PINS O=FE_OFN896_branch_metrics_4__1__0
+ I=branch_metrics[4][1][0]
XFE_OFC763_branch_metrics_4__1__1 BUF1 $PINS O=FE_OFN895_branch_metrics_4__1__1
+ I=branch_metrics[4][1][1]
XFE_OFC761_branch_metrics_4__1__3 BUF1 $PINS O=FE_OFN893_branch_metrics_4__1__3
+ I=branch_metrics[4][1][3]
XFE_OFC757_branch_metrics_4__1__7 BUF1 $PINS O=FE_OFN889_branch_metrics_4__1__7
+ I=branch_metrics[4][1][7]
XFE_OFC756_branch_metrics_4__1__8 BUF1 $PINS O=FE_OFN888_branch_metrics_4__1__8
+ I=branch_metrics[4][1][8]
XFE_OFC755_branch_metrics_4__1__9 BUF1 $PINS O=FE_OFN887_branch_metrics_4__1__9
+ I=branch_metrics[4][1][9]
XFE_OFC754_branch_metrics_4__1__10 BUF1 $PINS
+ O=FE_OFN886_branch_metrics_4__1__10 I=branch_metrics[4][1][10]
XFE_OFC753_branch_metrics_4__1__11 BUF1 $PINS
+ O=FE_OFN885_branch_metrics_4__1__11 I=branch_metrics[4][1][11]
XFE_OFC749_branch_metrics_4__0__3 BUF1 $PINS O=FE_OFN881_branch_metrics_4__0__3
+ I=branch_metrics[4][0][3]
XFE_OFC744_branch_metrics_4__0__8 BUF1 $PINS O=FE_OFN876_branch_metrics_4__0__8
+ I=branch_metrics[4][0][8]
XFE_OFC743_branch_metrics_4__0__9 BUF1 $PINS O=FE_OFN875_branch_metrics_4__0__9
+ I=branch_metrics[4][0][9]
XFE_OFC742_branch_metrics_4__0__10 BUF1 $PINS
+ O=FE_OFN874_branch_metrics_4__0__10 I=branch_metrics[4][0][10]
XFE_OFC741_branch_metrics_4__0__11 BUF1 $PINS
+ O=FE_OFN873_branch_metrics_4__0__11 I=branch_metrics[4][0][11]
XFE_OFC740_branch_metrics_3__3__0 BUF2 $PINS O=FE_OFN872_branch_metrics_3__3__0
+ I=branch_metrics[3][3][0]
XFE_OFC739_branch_metrics_3__3__1 BUF2 $PINS O=FE_OFN871_branch_metrics_3__3__1
+ I=branch_metrics[3][3][1]
XFE_OFC738_branch_metrics_3__3__2 BUF1 $PINS O=FE_OFN870_branch_metrics_3__3__2
+ I=branch_metrics[3][3][2]
XFE_OFC736_branch_metrics_3__3__4 BUF1 $PINS O=FE_OFN868_branch_metrics_3__3__4
+ I=branch_metrics[3][3][4]
XFE_OFC735_branch_metrics_3__3__5 BUF1 $PINS O=FE_OFN867_branch_metrics_3__3__5
+ I=branch_metrics[3][3][5]
XFE_OFC733_branch_metrics_3__3__7 BUF1 $PINS O=FE_OFN865_branch_metrics_3__3__7
+ I=branch_metrics[3][3][7]
XFE_OFC732_branch_metrics_3__3__8 BUF1 $PINS O=FE_OFN864_branch_metrics_3__3__8
+ I=branch_metrics[3][3][8]
XFE_OFC731_branch_metrics_3__3__9 BUF1 $PINS O=FE_OFN863_branch_metrics_3__3__9
+ I=branch_metrics[3][3][9]
XFE_OFC730_branch_metrics_3__3__10 BUF1 $PINS
+ O=FE_OFN862_branch_metrics_3__3__10 I=branch_metrics[3][3][10]
XFE_OFC729_branch_metrics_3__3__11 BUF1 $PINS
+ O=FE_OFN861_branch_metrics_3__3__11 I=branch_metrics[3][3][11]
XFE_OFC728_branch_metrics_3__2__0 BUF1 $PINS O=FE_OFN860_branch_metrics_3__2__0
+ I=branch_metrics[3][2][0]
XFE_OFC727_branch_metrics_3__2__1 BUF1 $PINS O=FE_OFN859_branch_metrics_3__2__1
+ I=branch_metrics[3][2][1]
XFE_OFC726_branch_metrics_3__2__2 BUF1 $PINS O=FE_OFN858_branch_metrics_3__2__2
+ I=branch_metrics[3][2][2]
XFE_OFC721_branch_metrics_3__2__7 BUF1 $PINS O=FE_OFN853_branch_metrics_3__2__7
+ I=branch_metrics[3][2][7]
XFE_OFC720_branch_metrics_3__2__8 BUF1 $PINS O=FE_OFN852_branch_metrics_3__2__8
+ I=branch_metrics[3][2][8]
XFE_OFC719_branch_metrics_3__2__9 BUF1 $PINS O=FE_OFN851_branch_metrics_3__2__9
+ I=branch_metrics[3][2][9]
XFE_OFC718_branch_metrics_3__2__10 BUF1 $PINS
+ O=FE_OFN850_branch_metrics_3__2__10 I=branch_metrics[3][2][10]
XFE_OFC717_branch_metrics_3__2__11 BUF1 $PINS
+ O=FE_OFN849_branch_metrics_3__2__11 I=branch_metrics[3][2][11]
XFE_OFC716_branch_metrics_3__1__0 BUF3 $PINS O=FE_OFN848_branch_metrics_3__1__0
+ I=branch_metrics[3][1][0]
XFE_OFC714_branch_metrics_3__1__2 BUF1 $PINS O=FE_OFN846_branch_metrics_3__1__2
+ I=branch_metrics[3][1][2]
XFE_OFC712_branch_metrics_3__1__4 BUF1 $PINS O=FE_OFN844_branch_metrics_3__1__4
+ I=branch_metrics[3][1][4]
XFE_OFC710_branch_metrics_3__1__6 BUF1 $PINS O=FE_OFN842_branch_metrics_3__1__6
+ I=branch_metrics[3][1][6]
XFE_OFC709_branch_metrics_3__1__7 BUF1 $PINS O=FE_OFN841_branch_metrics_3__1__7
+ I=branch_metrics[3][1][7]
XFE_OFC708_branch_metrics_3__1__8 BUF1 $PINS O=FE_OFN840_branch_metrics_3__1__8
+ I=branch_metrics[3][1][8]
XFE_OFC707_branch_metrics_3__1__9 BUF1 $PINS O=FE_OFN839_branch_metrics_3__1__9
+ I=branch_metrics[3][1][9]
XFE_OFC706_branch_metrics_3__1__10 BUF1 $PINS
+ O=FE_OFN838_branch_metrics_3__1__10 I=branch_metrics[3][1][10]
XFE_OFC705_branch_metrics_3__1__11 BUF1 $PINS
+ O=FE_OFN837_branch_metrics_3__1__11 I=branch_metrics[3][1][11]
XFE_OFC704_branch_metrics_3__0__0 BUF1 $PINS O=FE_OFN836_branch_metrics_3__0__0
+ I=branch_metrics[3][0][0]
XFE_OFC698_branch_metrics_3__0__6 BUF1 $PINS O=FE_OFN830_branch_metrics_3__0__6
+ I=branch_metrics[3][0][6]
XFE_OFC697_branch_metrics_3__0__7 BUF1 $PINS O=FE_OFN829_branch_metrics_3__0__7
+ I=branch_metrics[3][0][7]
XFE_OFC696_branch_metrics_3__0__8 BUF1 $PINS O=FE_OFN828_branch_metrics_3__0__8
+ I=branch_metrics[3][0][8]
XFE_OFC695_branch_metrics_3__0__9 BUF1 $PINS O=FE_OFN827_branch_metrics_3__0__9
+ I=branch_metrics[3][0][9]
XFE_OFC694_branch_metrics_3__0__10 BUF1 $PINS
+ O=FE_OFN826_branch_metrics_3__0__10 I=branch_metrics[3][0][10]
XFE_OFC693_branch_metrics_3__0__11 BUF1 $PINS
+ O=FE_OFN825_branch_metrics_3__0__11 I=branch_metrics[3][0][11]
XFE_OFC691_branch_metrics_2__3__1 BUF2 $PINS O=FE_OFN823_branch_metrics_2__3__1
+ I=branch_metrics[2][3][1]
XFE_OFC688_branch_metrics_2__3__4 BUF1 $PINS O=FE_OFN820_branch_metrics_2__3__4
+ I=branch_metrics[2][3][4]
XFE_OFC687_branch_metrics_2__3__5 BUF1 $PINS O=FE_OFN819_branch_metrics_2__3__5
+ I=branch_metrics[2][3][5]
XFE_OFC686_branch_metrics_2__3__6 BUF1 $PINS O=FE_OFN818_branch_metrics_2__3__6
+ I=branch_metrics[2][3][6]
XFE_OFC685_branch_metrics_2__3__7 BUF1 $PINS O=FE_OFN817_branch_metrics_2__3__7
+ I=branch_metrics[2][3][7]
XFE_OFC684_branch_metrics_2__3__8 BUF1 $PINS O=FE_OFN816_branch_metrics_2__3__8
+ I=branch_metrics[2][3][8]
XFE_OFC683_branch_metrics_2__3__9 BUF1 $PINS O=FE_OFN815_branch_metrics_2__3__9
+ I=branch_metrics[2][3][9]
XFE_OFC682_branch_metrics_2__3__10 BUF1 $PINS
+ O=FE_OFN814_branch_metrics_2__3__10 I=branch_metrics[2][3][10]
XFE_OFC681_branch_metrics_2__3__11 BUF1 $PINS
+ O=FE_OFN813_branch_metrics_2__3__11 I=branch_metrics[2][3][11]
XFE_OFC680_branch_metrics_2__2__0 BUF1 $PINS O=FE_OFN812_branch_metrics_2__2__0
+ I=branch_metrics[2][2][0]
XFE_OFC675_branch_metrics_2__2__5 BUF1 $PINS O=FE_OFN807_branch_metrics_2__2__5
+ I=branch_metrics[2][2][5]
XFE_OFC674_branch_metrics_2__2__6 BUF1 $PINS O=FE_OFN806_branch_metrics_2__2__6
+ I=branch_metrics[2][2][6]
XFE_OFC673_branch_metrics_2__2__7 BUF1 $PINS O=FE_OFN805_branch_metrics_2__2__7
+ I=branch_metrics[2][2][7]
XFE_OFC672_branch_metrics_2__2__8 BUF1 $PINS O=FE_OFN804_branch_metrics_2__2__8
+ I=branch_metrics[2][2][8]
XFE_OFC671_branch_metrics_2__2__9 BUF1 $PINS O=FE_OFN803_branch_metrics_2__2__9
+ I=branch_metrics[2][2][9]
XFE_OFC670_branch_metrics_2__2__10 BUF1 $PINS
+ O=FE_OFN802_branch_metrics_2__2__10 I=branch_metrics[2][2][10]
XFE_OFC669_branch_metrics_2__2__11 BUF1 $PINS
+ O=FE_OFN801_branch_metrics_2__2__11 I=branch_metrics[2][2][11]
XFE_OFC667_branch_metrics_2__1__1 BUF3 $PINS O=FE_OFN799_branch_metrics_2__1__1
+ I=branch_metrics[2][1][1]
XFE_OFC666_branch_metrics_2__1__2 BUF1 $PINS O=FE_OFN798_branch_metrics_2__1__2
+ I=branch_metrics[2][1][2]
XFE_OFC665_branch_metrics_2__1__3 BUF1 $PINS O=FE_OFN797_branch_metrics_2__1__3
+ I=branch_metrics[2][1][3]
XFE_OFC662_branch_metrics_2__1__6 BUF1 $PINS O=FE_OFN794_branch_metrics_2__1__6
+ I=branch_metrics[2][1][6]
XFE_OFC661_branch_metrics_2__1__7 BUF1 $PINS O=FE_OFN793_branch_metrics_2__1__7
+ I=branch_metrics[2][1][7]
XFE_OFC660_branch_metrics_2__1__8 BUF1 $PINS O=FE_OFN792_branch_metrics_2__1__8
+ I=branch_metrics[2][1][8]
XFE_OFC659_branch_metrics_2__1__9 BUF1 $PINS O=FE_OFN791_branch_metrics_2__1__9
+ I=branch_metrics[2][1][9]
XFE_OFC658_branch_metrics_2__1__10 BUF1 $PINS
+ O=FE_OFN790_branch_metrics_2__1__10 I=branch_metrics[2][1][10]
XFE_OFC657_branch_metrics_2__1__11 BUF1 $PINS
+ O=FE_OFN789_branch_metrics_2__1__11 I=branch_metrics[2][1][11]
XFE_OFC656_branch_metrics_2__0__0 BUF2CK $PINS
+ O=FE_OFN788_branch_metrics_2__0__0 I=branch_metrics[2][0][0]
XFE_OFC653_branch_metrics_2__0__3 BUF1 $PINS O=FE_OFN785_branch_metrics_2__0__3
+ I=branch_metrics[2][0][3]
XFE_OFC652_branch_metrics_2__0__4 BUF1 $PINS O=FE_OFN784_branch_metrics_2__0__4
+ I=branch_metrics[2][0][4]
XFE_OFC651_branch_metrics_2__0__5 BUF1 $PINS O=FE_OFN783_branch_metrics_2__0__5
+ I=branch_metrics[2][0][5]
XFE_OFC650_branch_metrics_2__0__6 BUF1 $PINS O=FE_OFN782_branch_metrics_2__0__6
+ I=branch_metrics[2][0][6]
XFE_OFC649_branch_metrics_2__0__7 BUF1 $PINS O=FE_OFN781_branch_metrics_2__0__7
+ I=branch_metrics[2][0][7]
XFE_OFC648_branch_metrics_2__0__8 BUF1 $PINS O=FE_OFN780_branch_metrics_2__0__8
+ I=branch_metrics[2][0][8]
XFE_OFC647_branch_metrics_2__0__9 BUF1 $PINS O=FE_OFN779_branch_metrics_2__0__9
+ I=branch_metrics[2][0][9]
XFE_OFC646_branch_metrics_2__0__10 BUF1 $PINS
+ O=FE_OFN778_branch_metrics_2__0__10 I=branch_metrics[2][0][10]
XFE_OFC645_branch_metrics_2__0__11 BUF1 $PINS
+ O=FE_OFN777_branch_metrics_2__0__11 I=branch_metrics[2][0][11]
XFE_OFC644_branch_metrics_1__3__0 BUF2 $PINS O=FE_OFN776_branch_metrics_1__3__0
+ I=branch_metrics[1][3][0]
XFE_OFC643_branch_metrics_1__3__1 BUF3 $PINS O=FE_OFN775_branch_metrics_1__3__1
+ I=branch_metrics[1][3][1]
XFE_OFC641_branch_metrics_1__3__3 BUF1 $PINS O=FE_OFN773_branch_metrics_1__3__3
+ I=branch_metrics[1][3][3]
XFE_OFC640_branch_metrics_1__3__4 BUF1 $PINS O=FE_OFN772_branch_metrics_1__3__4
+ I=branch_metrics[1][3][4]
XFE_OFC638_branch_metrics_1__3__6 BUF1 $PINS O=FE_OFN770_branch_metrics_1__3__6
+ I=branch_metrics[1][3][6]
XFE_OFC637_branch_metrics_1__3__7 BUF1 $PINS O=FE_OFN769_branch_metrics_1__3__7
+ I=branch_metrics[1][3][7]
XFE_OFC636_branch_metrics_1__3__8 BUF1 $PINS O=FE_OFN768_branch_metrics_1__3__8
+ I=branch_metrics[1][3][8]
XFE_OFC635_branch_metrics_1__3__9 BUF1 $PINS O=FE_OFN767_branch_metrics_1__3__9
+ I=branch_metrics[1][3][9]
XFE_OFC634_branch_metrics_1__3__10 BUF1 $PINS
+ O=FE_OFN766_branch_metrics_1__3__10 I=branch_metrics[1][3][10]
XFE_OFC633_branch_metrics_1__3__11 BUF1 $PINS
+ O=FE_OFN765_branch_metrics_1__3__11 I=branch_metrics[1][3][11]
XFE_OFC631_branch_metrics_1__2__1 BUF1 $PINS O=FE_OFN763_branch_metrics_1__2__1
+ I=branch_metrics[1][2][1]
XFE_OFC628_branch_metrics_1__2__4 BUF1 $PINS O=FE_OFN760_branch_metrics_1__2__4
+ I=branch_metrics[1][2][4]
XFE_OFC627_branch_metrics_1__2__5 BUF1 $PINS O=FE_OFN759_branch_metrics_1__2__5
+ I=branch_metrics[1][2][5]
XFE_OFC626_branch_metrics_1__2__6 BUF1 $PINS O=FE_OFN758_branch_metrics_1__2__6
+ I=branch_metrics[1][2][6]
XFE_OFC625_branch_metrics_1__2__7 BUF1 $PINS O=FE_OFN757_branch_metrics_1__2__7
+ I=branch_metrics[1][2][7]
XFE_OFC624_branch_metrics_1__2__8 BUF1 $PINS O=FE_OFN756_branch_metrics_1__2__8
+ I=branch_metrics[1][2][8]
XFE_OFC623_branch_metrics_1__2__9 BUF1 $PINS O=FE_OFN755_branch_metrics_1__2__9
+ I=branch_metrics[1][2][9]
XFE_OFC622_branch_metrics_1__2__10 BUF1 $PINS
+ O=FE_OFN754_branch_metrics_1__2__10 I=branch_metrics[1][2][10]
XFE_OFC621_branch_metrics_1__2__11 BUF1 $PINS
+ O=FE_OFN753_branch_metrics_1__2__11 I=branch_metrics[1][2][11]
XFE_OFC618_branch_metrics_1__1__2 BUF1 $PINS O=FE_OFN750_branch_metrics_1__1__2
+ I=branch_metrics[1][1][2]
XFE_OFC614_branch_metrics_1__1__6 BUF1 $PINS O=FE_OFN746_branch_metrics_1__1__6
+ I=branch_metrics[1][1][6]
XFE_OFC613_branch_metrics_1__1__7 BUF1 $PINS O=FE_OFN745_branch_metrics_1__1__7
+ I=branch_metrics[1][1][7]
XFE_OFC612_branch_metrics_1__1__8 BUF1 $PINS O=FE_OFN744_branch_metrics_1__1__8
+ I=branch_metrics[1][1][8]
XFE_OFC611_branch_metrics_1__1__9 BUF1 $PINS O=FE_OFN743_branch_metrics_1__1__9
+ I=branch_metrics[1][1][9]
XFE_OFC610_branch_metrics_1__1__10 BUF1 $PINS
+ O=FE_OFN742_branch_metrics_1__1__10 I=branch_metrics[1][1][10]
XFE_OFC609_branch_metrics_1__1__11 BUF1 $PINS
+ O=FE_OFN741_branch_metrics_1__1__11 I=branch_metrics[1][1][11]
XFE_OFC608_branch_metrics_1__0__0 BUF2 $PINS O=FE_OFN740_branch_metrics_1__0__0
+ I=branch_metrics[1][0][0]
XFE_OFC607_branch_metrics_1__0__1 BUF2 $PINS O=FE_OFN739_branch_metrics_1__0__1
+ I=branch_metrics[1][0][1]
XFE_OFC603_branch_metrics_1__0__5 BUF1 $PINS O=FE_OFN735_branch_metrics_1__0__5
+ I=branch_metrics[1][0][5]
XFE_OFC602_branch_metrics_1__0__6 BUF1 $PINS O=FE_OFN734_branch_metrics_1__0__6
+ I=branch_metrics[1][0][6]
XFE_OFC601_branch_metrics_1__0__7 BUF1 $PINS O=FE_OFN733_branch_metrics_1__0__7
+ I=branch_metrics[1][0][7]
XFE_OFC600_branch_metrics_1__0__8 BUF1 $PINS O=FE_OFN732_branch_metrics_1__0__8
+ I=branch_metrics[1][0][8]
XFE_OFC599_branch_metrics_1__0__9 BUF1 $PINS O=FE_OFN731_branch_metrics_1__0__9
+ I=branch_metrics[1][0][9]
XFE_OFC598_branch_metrics_1__0__10 BUF1 $PINS
+ O=FE_OFN730_branch_metrics_1__0__10 I=branch_metrics[1][0][10]
XFE_OFC597_branch_metrics_1__0__11 BUF1 $PINS
+ O=FE_OFN729_branch_metrics_1__0__11 I=branch_metrics[1][0][11]
XFE_OFC386_FE_DBTN76_n1536 BUF1 $PINS O=FE_OFN518_FE_DBTN76_n1536
+ I=FE_OFN517_FE_DBTN76_n1536
XFE_OFC385_FE_DBTN76_n1536 BUF1 $PINS O=FE_OFN517_FE_DBTN76_n1536
+ I=FE_DBTN76_n1536
XFE_OFC383_FE_DBTN80_n9 BUF1 $PINS O=FE_OFN515_FE_DBTN80_n9 I=FE_DBTN80_n9
XFE_OFC382_FE_DBTN81_n8 BUF1 $PINS O=FE_OFN514_FE_DBTN81_n8 I=FE_DBTN81_n8
XFE_OFC377_FE_DBTN91_n1503 BUF1 $PINS O=FE_OFN509_FE_DBTN91_n1503
+ I=FE_OFN508_FE_DBTN91_n1503
XFE_OFC376_FE_DBTN91_n1503 BUF1 $PINS O=FE_OFN508_FE_DBTN91_n1503
+ I=FE_DBTN91_n1503
XFE_OFC375_FE_DBTN92_n1501 BUF1 $PINS O=FE_OFN507_FE_DBTN92_n1501
+ I=FE_OFN506_FE_DBTN92_n1501
XFE_OFC374_FE_DBTN92_n1501 BUF1 $PINS O=FE_OFN506_FE_DBTN92_n1501
+ I=FE_DBTN92_n1501
XFE_OFC373_FE_DBTN93_n1502 BUF1 $PINS O=FE_OFN505_FE_DBTN93_n1502
+ I=FE_OFN504_FE_DBTN93_n1502
XFE_OFC372_FE_DBTN93_n1502 BUF1 $PINS O=FE_OFN504_FE_DBTN93_n1502
+ I=FE_DBTN93_n1502
XFE_OFC367_i_reset_n_i BUF1 $PINS O=FE_OFN499_i_reset_n_i
+ I=FE_OFN481_i_reset_n_i
XFE_OFC366_i_reset_n_i BUF1 $PINS O=FE_OFN498_i_reset_n_i
+ I=FE_OFN481_i_reset_n_i
XFE_OFC365_i_reset_n_i BUF1 $PINS O=FE_OFN497_i_reset_n_i
+ I=FE_OFN480_i_reset_n_i
XFE_OFC364_i_reset_n_i BUF1 $PINS O=FE_OFN496_i_reset_n_i
+ I=FE_OFN480_i_reset_n_i
XFE_OFC363_i_reset_n_i BUF1 $PINS O=FE_OFN495_i_reset_n_i
+ I=FE_OFN479_i_reset_n_i
XFE_OFC355_i_reset_n_i BUF1 $PINS O=FE_OFN487_i_reset_n_i
+ I=FE_OFN466_i_reset_n_i
XFE_OFC354_i_reset_n_i BUF1 $PINS O=FE_OFN486_i_reset_n_i
+ I=FE_OFN466_i_reset_n_i
XFE_OFC352_i_reset_n_i BUF1 $PINS O=FE_OFN484_i_reset_n_i
+ I=FE_OFN130_i_reset_n_i
XFE_OFC351_i_reset_n_i BUF1 $PINS O=FE_OFN483_i_reset_n_i
+ I=FE_OFN458_i_reset_n_i
XFE_OFC350_i_reset_n_i BUF1 $PINS O=FE_OFN482_i_reset_n_i
+ I=FE_OFN458_i_reset_n_i
XFE_OFC349_i_reset_n_i BUF1 $PINS O=FE_OFN481_i_reset_n_i
+ I=FE_OFN449_i_reset_n_i
XFE_OFC348_i_reset_n_i BUF1 $PINS O=FE_OFN480_i_reset_n_i
+ I=FE_OFN444_i_reset_n_i
XFE_OFC347_i_reset_n_i BUF1 $PINS O=FE_OFN479_i_reset_n_i
+ I=FE_OFN441_i_reset_n_i
XFE_OFC346_i_reset_n_i BUF1 $PINS O=FE_OFN478_i_reset_n_i
+ I=FE_OFN441_i_reset_n_i
XFE_OFC338_i_reset_n_i BUF1 $PINS O=FE_OFN470_i_reset_n_i
+ I=FE_OFN408_i_reset_n_i
XFE_OFC337_i_reset_n_i BUF1 $PINS O=FE_OFN469_i_reset_n_i
+ I=FE_OFN408_i_reset_n_i
XFE_OFC336_i_reset_n_i BUF1 $PINS O=FE_OFN468_i_reset_n_i
+ I=FE_OFN408_i_reset_n_i
XFE_OFC335_i_reset_n_i BUF1 $PINS O=FE_OFN467_i_reset_n_i
+ I=FE_OFN404_i_reset_n_i
XFE_OFC334_i_reset_n_i BUF1 $PINS O=FE_OFN466_i_reset_n_i
+ I=FE_OFN111_i_reset_n_i
XFE_OFC333_i_reset_n_i BUF1 $PINS O=FE_OFN465_i_reset_n_i
+ I=FE_OFN111_i_reset_n_i
XFE_OFC331_i_reset_n_i BUF1 $PINS O=FE_OFN463_i_reset_n_i
+ I=FE_OFN400_i_reset_n_i
XFE_OFC330_i_reset_n_i BUF1 $PINS O=FE_OFN462_i_reset_n_i
+ I=FE_OFN400_i_reset_n_i
XFE_OFC329_i_reset_n_i BUF1 $PINS O=FE_OFN461_i_reset_n_i
+ I=FE_OFN400_i_reset_n_i
XFE_OFC327_i_reset_n_i BUF1 $PINS O=FE_OFN459_i_reset_n_i
+ I=FE_OFN110_i_reset_n_i
XFE_OFC326_i_reset_n_i BUF1 $PINS O=FE_OFN458_i_reset_n_i
+ I=FE_OFN395_i_reset_n_i
XFE_OFC325_i_reset_n_i BUF1 $PINS O=FE_OFN457_i_reset_n_i
+ I=FE_OFN395_i_reset_n_i
XFE_OFC324_i_reset_n_i BUF1 $PINS O=FE_OFN456_i_reset_n_i
+ I=FE_OFN394_i_reset_n_i
XFE_OFC323_i_reset_n_i BUF1 $PINS O=FE_OFN455_i_reset_n_i
+ I=FE_OFN394_i_reset_n_i
XFE_OFC321_i_reset_n_i BUF1 $PINS O=FE_OFN453_i_reset_n_i
+ I=FE_OFN393_i_reset_n_i
XFE_OFC320_i_reset_n_i BUF1 $PINS O=FE_OFN452_i_reset_n_i
+ I=FE_OFN392_i_reset_n_i
XFE_OFC319_i_reset_n_i BUF1 $PINS O=FE_OFN451_i_reset_n_i
+ I=FE_OFN392_i_reset_n_i
XFE_OFC318_i_reset_n_i BUF1 $PINS O=FE_OFN450_i_reset_n_i
+ I=FE_OFN392_i_reset_n_i
XFE_OFC317_i_reset_n_i BUF1 $PINS O=FE_OFN449_i_reset_n_i
+ I=FE_OFN390_i_reset_n_i
XFE_OFC316_i_reset_n_i BUF1 $PINS O=FE_OFN448_i_reset_n_i
+ I=FE_OFN390_i_reset_n_i
XFE_OFC312_i_reset_n_i BUF1 $PINS O=FE_OFN444_i_reset_n_i
+ I=FE_OFN384_i_reset_n_i
XFE_OFC311_i_reset_n_i BUF1 $PINS O=FE_OFN443_i_reset_n_i
+ I=FE_OFN381_i_reset_n_i
XFE_OFC310_i_reset_n_i BUF1 $PINS O=FE_OFN442_i_reset_n_i
+ I=FE_OFN380_i_reset_n_i
XFE_OFC309_i_reset_n_i BUF1 $PINS O=FE_OFN441_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC302_i_reset_n_i BUF1 $PINS O=FE_OFN434_i_reset_n_i
+ I=FE_OFN100_i_reset_n_i
XFE_OFC289_i_reset_n_i BUF1 $PINS O=FE_OFN421_i_reset_n_i
+ I=FE_OFN95_i_reset_n_i
XFE_OFC288_i_reset_n_i BUF1 $PINS O=FE_OFN420_i_reset_n_i
+ I=FE_OFN93_i_reset_n_i
XFE_OFC287_i_reset_n_i BUF1 $PINS O=FE_OFN419_i_reset_n_i
+ I=FE_OFN93_i_reset_n_i
XFE_OFC283_i_reset_n_i BUF1 $PINS O=FE_OFN415_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OFC282_i_reset_n_i BUF1 $PINS O=FE_OFN414_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OFC280_i_reset_n_i BUF1 $PINS O=FE_OFN412_i_reset_n_i
+ I=FE_OFN352_i_reset_n_i
XFE_OFC279_i_reset_n_i BUF1 $PINS O=FE_OFN411_i_reset_n_i
+ I=FE_OFN352_i_reset_n_i
XFE_OFC278_i_reset_n_i BUF1 $PINS O=FE_OFN410_i_reset_n_i
+ I=FE_OFN350_i_reset_n_i
XFE_OFC277_i_reset_n_i BUF1 $PINS O=FE_OFN409_i_reset_n_i
+ I=FE_OFN350_i_reset_n_i
XFE_OFC276_i_reset_n_i BUF1 $PINS O=FE_OFN408_i_reset_n_i
+ I=FE_OFN349_i_reset_n_i
XFE_OFC275_i_reset_n_i BUF1 $PINS O=FE_OFN407_i_reset_n_i
+ I=FE_OFN348_i_reset_n_i
XFE_OFC274_i_reset_n_i BUF1 $PINS O=FE_OFN406_i_reset_n_i
+ I=FE_OFN348_i_reset_n_i
XFE_OFC273_i_reset_n_i BUF1 $PINS O=FE_OFN405_i_reset_n_i
+ I=FE_OFN346_i_reset_n_i
XFE_OFC272_i_reset_n_i BUF1 $PINS O=FE_OFN404_i_reset_n_i
+ I=FE_OFN346_i_reset_n_i
XFE_OFC269_i_reset_n_i BUF1 $PINS O=FE_OFN401_i_reset_n_i
+ I=FE_OFN92_i_reset_n_i
XFE_OFC268_i_reset_n_i BUF1 $PINS O=FE_OFN400_i_reset_n_i
+ I=FE_OFN342_i_reset_n_i
XFE_OFC267_i_reset_n_i BUF1 $PINS O=FE_OFN399_i_reset_n_i
+ I=FE_OFN342_i_reset_n_i
XFE_OFC266_i_reset_n_i BUF1 $PINS O=FE_OFN398_i_reset_n_i
+ I=FE_OFN340_i_reset_n_i
XFE_OFC264_i_reset_n_i BUF1 $PINS O=FE_OFN396_i_reset_n_i
+ I=FE_OFN91_i_reset_n_i
XFE_OFC263_i_reset_n_i BUF1 $PINS O=FE_OFN395_i_reset_n_i
+ I=FE_OFN337_i_reset_n_i
XFE_OFC262_i_reset_n_i BUF1 $PINS O=FE_OFN394_i_reset_n_i
+ I=FE_OFN334_i_reset_n_i
XFE_OFC261_i_reset_n_i BUF1 $PINS O=FE_OFN393_i_reset_n_i
+ I=FE_OFN334_i_reset_n_i
XFE_OFC260_i_reset_n_i BUF1 $PINS O=FE_OFN392_i_reset_n_i
+ I=FE_OFN332_i_reset_n_i
XFE_OFC259_i_reset_n_i BUF1 $PINS O=FE_OFN391_i_reset_n_i
+ I=FE_OFN332_i_reset_n_i
XFE_OFC258_i_reset_n_i BUF1 $PINS O=FE_OFN390_i_reset_n_i
+ I=FE_OFN330_i_reset_n_i
XFE_OFC257_i_reset_n_i BUF1 $PINS O=FE_OFN389_i_reset_n_i
+ I=FE_OFN330_i_reset_n_i
XFE_OFC254_i_reset_n_i BUF1 $PINS O=FE_OFN386_i_reset_n_i
+ I=FE_OFN89_i_reset_n_i
XFE_OFC253_i_reset_n_i BUF1 $PINS O=FE_OFN385_i_reset_n_i
+ I=FE_OFN323_i_reset_n_i
XFE_OFC252_i_reset_n_i BUF1 $PINS O=FE_OFN384_i_reset_n_i
+ I=FE_OFN322_i_reset_n_i
XFE_OFC251_i_reset_n_i BUF1 $PINS O=FE_OFN383_i_reset_n_i
+ I=FE_OFN322_i_reset_n_i
XFE_OFC250_i_reset_n_i BUF1 $PINS O=FE_OFN382_i_reset_n_i
+ I=FE_OFN322_i_reset_n_i
XFE_OFC249_i_reset_n_i BUF1 $PINS O=FE_OFN381_i_reset_n_i
+ I=FE_OFN320_i_reset_n_i
XFE_OFC248_i_reset_n_i BUF1 $PINS O=FE_OFN380_i_reset_n_i
+ I=FE_OFN320_i_reset_n_i
XFE_OFC247_i_reset_n_i BUF1 $PINS O=FE_OFN379_i_reset_n_i
+ I=FE_OFN87_i_reset_n_i
XFE_OFC238_i_reset_n_i BUF1 $PINS O=FE_OFN370_i_reset_n_i
+ I=FE_OFN82_i_reset_n_i
XFE_OFC237_i_reset_n_i BUF1 $PINS O=FE_OFN369_i_reset_n_i
+ I=FE_OFN82_i_reset_n_i
XFE_OFC221_i_reset_n_i BUF1 $PINS O=FE_OFN353_i_reset_n_i
+ I=FE_OFN298_i_reset_n_i
XFE_OFC220_i_reset_n_i BUF1 $PINS O=FE_OFN352_i_reset_n_i
+ I=FE_OFN296_i_reset_n_i
XFE_OFC219_i_reset_n_i BUF1 $PINS O=FE_OFN351_i_reset_n_i
+ I=FE_OFN296_i_reset_n_i
XFE_OFC218_i_reset_n_i BUF1 $PINS O=FE_OFN350_i_reset_n_i
+ I=FE_OFN295_i_reset_n_i
XFE_OFC217_i_reset_n_i BUF1 $PINS O=FE_OFN349_i_reset_n_i
+ I=FE_OFN291_i_reset_n_i
XFE_OFC216_i_reset_n_i BUF1 $PINS O=FE_OFN348_i_reset_n_i
+ I=FE_OFN291_i_reset_n_i
XFE_OFC215_i_reset_n_i BUF1 $PINS O=FE_OFN347_i_reset_n_i
+ I=FE_OFN291_i_reset_n_i
XFE_OFC214_i_reset_n_i BUF1 $PINS O=FE_OFN346_i_reset_n_i
+ I=FE_OFN289_i_reset_n_i
XFE_OFC213_i_reset_n_i BUF1 $PINS O=FE_OFN345_i_reset_n_i
+ I=FE_OFN289_i_reset_n_i
XFE_OFC211_i_reset_n_i BUF1 $PINS O=FE_OFN343_i_reset_n_i
+ I=FE_OFN76_i_reset_n_i
XFE_OFC210_i_reset_n_i BUF1 $PINS O=FE_OFN342_i_reset_n_i
+ I=FE_OFN284_i_reset_n_i
XFE_OFC209_i_reset_n_i BUF1 $PINS O=FE_OFN341_i_reset_n_i
+ I=FE_OFN284_i_reset_n_i
XFE_OFC208_i_reset_n_i BUF1 $PINS O=FE_OFN340_i_reset_n_i
+ I=FE_OFN283_i_reset_n_i
XFE_OFC207_i_reset_n_i BUF1 $PINS O=FE_OFN339_i_reset_n_i
+ I=FE_OFN283_i_reset_n_i
XFE_OFC205_i_reset_n_i BUF1 $PINS O=FE_OFN337_i_reset_n_i
+ I=FE_OFN74_i_reset_n_i
XFE_OFC204_i_reset_n_i BUF1 $PINS O=FE_OFN336_i_reset_n_i
+ I=FE_OFN279_i_reset_n_i
XFE_OFC203_i_reset_n_i BUF1 $PINS O=FE_OFN335_i_reset_n_i
+ I=FE_OFN278_i_reset_n_i
XFE_OFC202_i_reset_n_i BUF1 $PINS O=FE_OFN334_i_reset_n_i
+ I=FE_OFN278_i_reset_n_i
XFE_OFC201_i_reset_n_i BUF1 $PINS O=FE_OFN333_i_reset_n_i
+ I=FE_OFN279_i_reset_n_i
XFE_OFC200_i_reset_n_i BUF1 $PINS O=FE_OFN332_i_reset_n_i
+ I=FE_OFN275_i_reset_n_i
XFE_OFC199_i_reset_n_i BUF1 $PINS O=FE_OFN331_i_reset_n_i
+ I=FE_OFN274_i_reset_n_i
XFE_OFC198_i_reset_n_i BUF1 $PINS O=FE_OFN330_i_reset_n_i
+ I=FE_OFN273_i_reset_n_i
XFE_OFC191_i_reset_n_i BUF1 $PINS O=FE_OFN323_i_reset_n_i
+ I=FE_OFN267_i_reset_n_i
XFE_OFC190_i_reset_n_i BUF1 $PINS O=FE_OFN322_i_reset_n_i
+ I=FE_OFN266_i_reset_n_i
XFE_OFC189_i_reset_n_i BUF1 $PINS O=FE_OFN321_i_reset_n_i
+ I=FE_OFN266_i_reset_n_i
XFE_OFC188_i_reset_n_i BUF1 $PINS O=FE_OFN320_i_reset_n_i
+ I=FE_OFN265_i_reset_n_i
XFE_OFC186_i_reset_n_i BUF1 $PINS O=FE_OFN318_i_reset_n_i
+ I=FE_OFN263_i_reset_n_i
XFE_OFC175_i_reset_n_i BUF1 $PINS O=FE_OFN307_i_reset_n_i
+ I=FE_OFN62_i_reset_n_i
XFE_OFC172_i_reset_n_i BUF1 $PINS O=FE_OFN304_i_reset_n_i
+ I=FE_OFN56_i_reset_n_i
XFE_OFC166_i_reset_n_i BUF1 $PINS O=FE_OFN298_i_reset_n_i
+ I=FE_OFN245_i_reset_n_i
XFE_OFC165_i_reset_n_i BUF1 $PINS O=FE_OFN297_i_reset_n_i
+ I=FE_OFN245_i_reset_n_i
XFE_OFC164_i_reset_n_i BUF1 $PINS O=FE_OFN296_i_reset_n_i
+ I=FE_OFN243_i_reset_n_i
XFE_OFC163_i_reset_n_i BUF1 $PINS O=FE_OFN295_i_reset_n_i
+ I=FE_OFN243_i_reset_n_i
XFE_OFC162_i_reset_n_i BUF1 $PINS O=FE_OFN294_i_reset_n_i
+ I=FE_OFN54_i_reset_n_i
XFE_OFC160_i_reset_n_i BUF1 $PINS O=FE_OFN292_i_reset_n_i
+ I=FE_OFN238_i_reset_n_i
XFE_OFC159_i_reset_n_i BUF1 $PINS O=FE_OFN291_i_reset_n_i
+ I=FE_OFN237_i_reset_n_i
XFE_OFC158_i_reset_n_i BUF1 $PINS O=FE_OFN290_i_reset_n_i
+ I=FE_OFN237_i_reset_n_i
XFE_OFC157_i_reset_n_i BUF1 $PINS O=FE_OFN289_i_reset_n_i
+ I=FE_OFN236_i_reset_n_i
XFE_OFC156_i_reset_n_i BUF1 $PINS O=FE_OFN288_i_reset_n_i
+ I=FE_OFN236_i_reset_n_i
XFE_OFC155_i_reset_n_i BUF1 $PINS O=FE_OFN287_i_reset_n_i
+ I=FE_OFN196_i_reset_n_i
XFE_OFC152_i_reset_n_i BUF1 $PINS O=FE_OFN284_i_reset_n_i
+ I=FE_OFN233_i_reset_n_i
XFE_OFC151_i_reset_n_i BUF1 $PINS O=FE_OFN283_i_reset_n_i
+ I=FE_OFN232_i_reset_n_i
XFE_OFC149_i_reset_n_i BUF1 $PINS O=FE_OFN281_i_reset_n_i
+ I=FE_OFN230_i_reset_n_i
XFE_OFC147_i_reset_n_i BUF1 $PINS O=FE_OFN279_i_reset_n_i
+ I=FE_OFN226_i_reset_n_i
XFE_OFC146_i_reset_n_i BUF1 $PINS O=FE_OFN278_i_reset_n_i
+ I=FE_OFN226_i_reset_n_i
XFE_OFC143_i_reset_n_i BUF1 $PINS O=FE_OFN275_i_reset_n_i
+ I=FE_OFN224_i_reset_n_i
XFE_OFC142_i_reset_n_i BUF1 $PINS O=FE_OFN274_i_reset_n_i
+ I=FE_OFN224_i_reset_n_i
XFE_OFC141_i_reset_n_i BUF1 $PINS O=FE_OFN273_i_reset_n_i
+ I=FE_OFN222_i_reset_n_i
XFE_OFC135_i_reset_n_i BUF1 $PINS O=FE_OFN267_i_reset_n_i
+ I=FE_OFN218_i_reset_n_i
XFE_OFC134_i_reset_n_i BUF1 $PINS O=FE_OFN266_i_reset_n_i
+ I=FE_OFN217_i_reset_n_i
XFE_OFC133_i_reset_n_i BUF1 $PINS O=FE_OFN265_i_reset_n_i
+ I=FE_OFN215_i_reset_n_i
XFE_OFC131_i_reset_n_i BUF1 $PINS O=FE_OFN263_i_reset_n_i
+ I=FE_OFN44_i_reset_n_i
XFE_OFC125_i_reset_n_i BUF1 $PINS O=FE_OFN257_i_reset_n_i
+ I=FE_OFN41_i_reset_n_i
XFE_OFC117_i_reset_n_i BUF1 $PINS O=FE_OFN249_i_reset_n_i
+ I=FE_OFN38_i_reset_n_i
XFE_OFC113_i_reset_n_i BUF1 $PINS O=FE_OFN245_i_reset_n_i
+ I=FE_OFN202_i_reset_n_i
XFE_OFC112_i_reset_n_i BUF1 $PINS O=FE_OFN244_i_reset_n_i
+ I=FE_OFN202_i_reset_n_i
XFE_OFC111_i_reset_n_i BUF1 $PINS O=FE_OFN243_i_reset_n_i
+ I=FE_OFN201_i_reset_n_i
XFE_OFC110_i_reset_n_i BUF1 $PINS O=FE_OFN242_i_reset_n_i
+ I=FE_OFN201_i_reset_n_i
XFE_OFC107_i_reset_n_i BUF1 $PINS O=FE_OFN239_i_reset_n_i
+ I=FE_OFN199_i_reset_n_i
XFE_OFC106_i_reset_n_i BUF1 $PINS O=FE_OFN238_i_reset_n_i
+ I=FE_OFN198_i_reset_n_i
XFE_OFC105_i_reset_n_i BUF1 $PINS O=FE_OFN237_i_reset_n_i
+ I=FE_OFN197_i_reset_n_i
XFE_OFC104_i_reset_n_i BUF1 $PINS O=FE_OFN236_i_reset_n_i
+ I=FE_OFN196_i_reset_n_i
XFE_OFC101_i_reset_n_i BUF1 $PINS O=FE_OFN233_i_reset_n_i
+ I=FE_OFN192_i_reset_n_i
XFE_OFC100_i_reset_n_i BUF1 $PINS O=FE_OFN232_i_reset_n_i
+ I=FE_OFN192_i_reset_n_i
XFE_OFC98_i_reset_n_i BUF1 $PINS O=FE_OFN230_i_reset_n_i
+ I=FE_OFN190_i_reset_n_i
XFE_OFC96_i_reset_n_i BUF1 $PINS O=FE_OFN228_i_reset_n_i
+ I=FE_OFN188_i_reset_n_i
XFE_OFC94_i_reset_n_i BUF1 $PINS O=FE_OFN226_i_reset_n_i I=FE_OFN30_i_reset_n_i
XFE_OFC92_i_reset_n_i BUF1 $PINS O=FE_OFN224_i_reset_n_i
+ I=FE_OFN184_i_reset_n_i
XFE_OFC91_i_reset_n_i BUF1 $PINS O=FE_OFN223_i_reset_n_i
+ I=FE_OFN183_i_reset_n_i
XFE_OFC90_i_reset_n_i BUF1 $PINS O=FE_OFN222_i_reset_n_i
+ I=FE_OFN182_i_reset_n_i
XFE_OFC86_i_reset_n_i BUF1 $PINS O=FE_OFN218_i_reset_n_i
+ I=FE_OFN178_i_reset_n_i
XFE_OFC85_i_reset_n_i BUF1 $PINS O=FE_OFN217_i_reset_n_i
+ I=FE_OFN177_i_reset_n_i
XFE_OFC84_i_reset_n_i BUF1 $PINS O=FE_OFN216_i_reset_n_i
+ I=FE_OFN177_i_reset_n_i
XFE_OFC83_i_reset_n_i BUF1 $PINS O=FE_OFN215_i_reset_n_i
+ I=FE_OFN176_i_reset_n_i
XFE_OFC82_i_reset_n_i BUF1 $PINS O=FE_OFN214_i_reset_n_i
+ I=FE_OFN176_i_reset_n_i
XFE_OFC70_i_reset_n_i BUF1 $PINS O=FE_OFN202_i_reset_n_i
+ I=FE_OFN163_i_reset_n_i
XFE_OFC69_i_reset_n_i BUF1 $PINS O=FE_OFN201_i_reset_n_i
+ I=FE_OFN161_i_reset_n_i
XFE_OFC67_i_reset_n_i BUF1 $PINS O=FE_OFN199_i_reset_n_i I=FE_OFN16_i_reset_n_i
XFE_OFC66_i_reset_n_i BUF1 $PINS O=FE_OFN198_i_reset_n_i
+ I=FE_OFN159_i_reset_n_i
XFE_OFC65_i_reset_n_i BUF1 $PINS O=FE_OFN197_i_reset_n_i
+ I=FE_OFN159_i_reset_n_i
XFE_OFC64_i_reset_n_i BUF1 $PINS O=FE_OFN196_i_reset_n_i
+ I=FE_OFN159_i_reset_n_i
XFE_OFC62_i_reset_n_i BUF1 $PINS O=FE_OFN194_i_reset_n_i I=FE_OFN15_i_reset_n_i
XFE_OFC61_i_reset_n_i BUF1 $PINS O=FE_OFN193_i_reset_n_i I=FE_OFN15_i_reset_n_i
XFE_OFC60_i_reset_n_i BUF1 $PINS O=FE_OFN192_i_reset_n_i
+ I=FE_OFN157_i_reset_n_i
XFE_OFC58_i_reset_n_i BUF1 $PINS O=FE_OFN190_i_reset_n_i I=FE_OFN13_i_reset_n_i
XFE_OFC56_i_reset_n_i BUF1 $PINS O=FE_OFN188_i_reset_n_i I=FE_OFN12_i_reset_n_i
XFE_OFC55_i_reset_n_i BUF1 $PINS O=FE_OFN187_i_reset_n_i I=FE_OFN12_i_reset_n_i
XFE_OFC52_i_reset_n_i BUF1 $PINS O=FE_OFN184_i_reset_n_i
+ I=FE_OFN150_i_reset_n_i
XFE_OFC51_i_reset_n_i BUF1 $PINS O=FE_OFN183_i_reset_n_i
+ I=FE_OFN150_i_reset_n_i
XFE_OFC50_i_reset_n_i BUF1 $PINS O=FE_OFN182_i_reset_n_i
+ I=FE_OFN149_i_reset_n_i
XFE_OFC46_i_reset_n_i INV1S $PINS O=FE_OFN178_i_reset_n_i
+ I=FE_OFN10_i_reset_n_i
XFE_OFC45_i_reset_n_i BUF1 $PINS O=FE_OFN177_i_reset_n_i
+ I=FE_OFN147_i_reset_n_i
XFE_OFC44_i_reset_n_i BUF1 $PINS O=FE_OFN176_i_reset_n_i
+ I=FE_OFN146_i_reset_n_i
XFE_OFC31_i_reset_n_i BUF1 $PINS O=FE_OFN163_i_reset_n_i
+ I=FE_OFN138_i_reset_n_i
XFE_OFC29_i_reset_n_i BUF1 $PINS O=FE_OFN161_i_reset_n_i
+ I=FE_OFN138_i_reset_n_i
XFE_OFC27_i_reset_n_i BUF1 $PINS O=FE_OFN159_i_reset_n_i I=FE_OFN4_i_reset_n_i
XFE_OFC25_i_reset_n_i BUF1 $PINS O=FE_OFN157_i_reset_n_i I=FE_OFN4_i_reset_n_i
XFE_OFC23_i_reset_n_i BUF1 $PINS O=FE_OFN155_i_reset_n_i I=FE_OFN4_i_reset_n_i
XFE_OFC21_i_reset_n_i BUF1 $PINS O=FE_OFN153_i_reset_n_i I=FE_OFN3_i_reset_n_i
XFE_OFC18_i_reset_n_i BUF1 $PINS O=FE_OFN150_i_reset_n_i I=FE_OFN1_i_reset_n_i
XFE_OFC17_i_reset_n_i INV1S $PINS O=FE_OFN149_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC15_i_reset_n_i INV1S $PINS O=FE_OFN147_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC14_i_reset_n_i INV1S $PINS O=FE_OFN146_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC6_i_reset_n_i BUF1 $PINS O=FE_OFN138_i_reset_n_i I=reset_n_i
XFE_DBTC95_N336 INV1S $PINS O=FE_DBTN95_N336 I=FE_OFN2052_N336
XFE_DBTC94_n1513 INV1S $PINS O=FE_DBTN94_n1513 I=n1513
XFE_DBTC93_n1502 INV1S $PINS O=FE_DBTN93_n1502 I=n1502
XFE_DBTC92_n1501 INV1S $PINS O=FE_DBTN92_n1501 I=n1501
XFE_DBTC91_n1503 INV1S $PINS O=FE_DBTN91_n1503 I=n1503
XFE_DBTC90_n1497 INV4CK $PINS O=FE_DBTN90_n1497 I=n1497
XFE_DBTC81_n8 INV1S $PINS O=FE_DBTN81_n8 I=n8
XFE_DBTC80_n9 INV1S $PINS O=FE_DBTN80_n9 I=n9
XFE_DBTC79_n10 INV1S $PINS O=FE_DBTN79_n10 I=n10
XFE_DBTC78_n11 INV1S $PINS O=FE_DBTN78_n11 I=n11
XFE_DBTC76_n1536 INV1S $PINS O=FE_DBTN76_n1536 I=n1536
XFE_DBTC75_n1441 INV1S $PINS O=FE_DBTN75_n1441 I=FE_OFN1361_n1441
XFE_DBTC74_n1535 INV1S $PINS O=FE_DBTN74_n1535 I=n1535
XFE_DBTC72_n3966 INV1S $PINS O=FE_DBTN72_n3966 I=n3966
XU2418 AN2B1S $PINS O=n982 I1=n1002 B1=n1004
XU2419 ND2 $PINS O=n998 I1=n1002 I2=n996
XU2430 OR3B2 $PINS O=N559 I1=n1023 B1=n1024 B2=n1025
XU2432 OR3B2 $PINS O=N558 I1=n1026 B1=n1027 B2=n1028
XU2434 OR3B2 $PINS O=N557 I1=n1029 B1=n1030 B2=n1031
XU2436 OR3B2 $PINS O=N556 I1=n1032 B1=n1033 B2=n1034
XU2438 OR3B2 $PINS O=N555 I1=n1035 B1=n1036 B2=n1037
XU2440 OR3B2S $PINS O=N554 I1=n1038 B1=n1039 B2=n1040
XU2442 OR3B2 $PINS O=N553 I1=n1041 B1=n1042 B2=n1043
XU2448 OR3B2 $PINS O=N550 I1=n1050 B1=n1051 B2=n1052
XU2450 OR3B2 $PINS O=N549 I1=n1053 B1=n1054 B2=n1055
XU2452 OR3B2 $PINS O=N548 I1=n1056 B1=n1057 B2=n1058
XU2454 OR3B2 $PINS O=N547 I1=n1059 B1=n1060 B2=n1061
XU2456 OR3B2 $PINS O=N546 I1=n1062 B1=n1063 B2=n1064
XU2458 OR3B2 $PINS O=N545 I1=n1065 B1=n1066 B2=n1067
XU2460 OR3B2 $PINS O=N544 I1=n1068 B1=n1069 B2=n1070
XU2462 OR3B2 $PINS O=N543 I1=n1071 B1=n1072 B2=n1073
XU2464 OR3B2 $PINS O=N542 I1=n1074 B1=n1075 B2=n1076
XU2466 OR3B2 $PINS O=N541 I1=n1077 B1=n1078 B2=n1079
XU2472 OR3B2 $PINS O=N538 I1=n1086 B1=n1087 B2=n1088
XU2474 OR3B2 $PINS O=N537 I1=n1089 B1=n1090 B2=n1091
XU2476 OR3B2 $PINS O=N536 I1=n1092 B1=n1093 B2=n1094
XU2478 OR3B2 $PINS O=N535 I1=n1095 B1=n1096 B2=n1097
XU2480 OR3B2 $PINS O=N534 I1=n1098 B1=n1099 B2=n1100
XU2482 OR3B2 $PINS O=N533 I1=n1101 B1=n1102 B2=n1103
XU2484 OR3B2 $PINS O=N532 I1=n1104 B1=n1105 B2=n1106
XU2486 OR3B2 $PINS O=N531 I1=n1107 B1=n1108 B2=n1109
XU2488 OR3B2 $PINS O=N530 I1=n1110 B1=n1111 B2=n1112
XU2490 OR3B2 $PINS O=N529 I1=n1113 B1=n1114 B2=n1115
XU2496 OR3B2 $PINS O=N526 I1=n1122 B1=n1123 B2=n1124
XU2498 OR3B2 $PINS O=N525 I1=n1125 B1=n1126 B2=n1127
XU2500 OR3B2 $PINS O=N524 I1=n1128 B1=n1129 B2=n1130
XU2502 OR3B2 $PINS O=N523 I1=n1131 B1=n1132 B2=n1133
XU2504 OR3B2 $PINS O=N522 I1=n1134 B1=n1135 B2=n1136
XU2506 OR3B2 $PINS O=N521 I1=n1137 B1=n1138 B2=n1139
XU2508 OR3B2 $PINS O=N520 I1=n1140 B1=n1141 B2=n1142
XU2510 OR3B2 $PINS O=N519 I1=n1143 B1=n1144 B2=n1145
XU2512 OR3B2 $PINS O=N518 I1=n1146 B1=n1147 B2=n1148
XU2514 OR3B2 $PINS O=N517 I1=n1149 B1=n1150 B2=n1151
XU2520 OR3B2 $PINS O=N514 I1=n1158 B1=n1159 B2=n1160
XU2522 OR3B2 $PINS O=N513 I1=n1161 B1=n1162 B2=n1163
XU2524 OR3B2 $PINS O=N512 I1=n1164 B1=n1165 B2=n1166
XU2526 OR3B2 $PINS O=N511 I1=n1167 B1=n1168 B2=n1169
XU2528 OR3B2 $PINS O=N510 I1=n1170 B1=n1171 B2=n1172
XU2530 OR3B2 $PINS O=N509 I1=n1173 B1=n1174 B2=n1175
XU2532 OR3B2 $PINS O=N508 I1=n1176 B1=n1177 B2=n1178
XU2534 OR3B2 $PINS O=N507 I1=n1179 B1=n1180 B2=n1181
XU2536 OR3B2 $PINS O=N506 I1=n1182 B1=n1183 B2=n1184
XU2544 OR3B2 $PINS O=N502 I1=n1194 B1=n1195 B2=n1196
XU2546 OR3B2 $PINS O=N501 I1=n1197 B1=n1198 B2=n1199
XU2548 OR3B2 $PINS O=N500 I1=n1200 B1=n1201 B2=n1202
XU2550 OR3B2 $PINS O=N499 I1=n1203 B1=n1204 B2=n1205
XU2552 OR3B2 $PINS O=N498 I1=n1206 B1=n1207 B2=n1208
XU2554 OR3B2 $PINS O=N497 I1=n1209 B1=n1210 B2=n1211
XU2560 OR3B2 $PINS O=N494 I1=n1218 B1=n1219 B2=n1220
XU2562 OR3B2 $PINS O=N493 I1=n1221 B1=n1222 B2=n1223
XU2804 OA222 $PINS O=n1586 A1=FE_OFN1790_n5419 A2=n5801
+ B1=FE_OFN1657_FE_DBTN85_n987 B2=n5825 C1=FE_OFN1593_FE_DBTN86_n985 C2=n5813
XU2805 OA222 $PINS O=n1589 A1=FE_OFN1562_n1665 A2=n5800
+ B1=FE_OFN1657_FE_DBTN85_n987 B2=n5824 C1=FE_OFN1593_FE_DBTN86_n985 C2=n5812
XU2806 OA222 $PINS O=n1592 A1=n1665 A2=n5799 B1=FE_OFN1657_FE_DBTN85_n987
+ B2=n5823 C1=FE_OFN1593_FE_DBTN86_n985 C2=n5811
XU2807 OA222 $PINS O=n1595 A1=FE_OFN1790_n5419 A2=n5798 B1=FE_OFN1460_n987
+ B2=n5822 C1=FE_OFN1589_FE_DBTN86_n985 C2=n5810
XU2808 OA222 $PINS O=n1598 A1=n1665 A2=n5797 B1=FE_OFN1460_n987 B2=n5821
+ C1=FE_OFN1589_FE_DBTN86_n985 C2=n5809
XU2809 OA222 $PINS O=n1601 A1=FE_OFN1790_n5419 A2=n5796 B1=FE_OFN1460_n987
+ B2=n5820 C1=FE_OFN1589_FE_DBTN86_n985 C2=n5808
XU2810 OA222 $PINS O=n1604 A1=FE_OFN1790_n5419 A2=n5795 B1=FE_OFN1460_n987
+ B2=n5819 C1=FE_OFN1589_FE_DBTN86_n985 C2=n5807
XU2811 OA222 $PINS O=n1607 A1=n1665 A2=n5794 B1=FE_OFN1457_n987 B2=n5818
+ C1=FE_OFN1587_FE_DBTN86_n985 C2=n5806
XU2812 OA222 $PINS O=n1610 A1=FE_OFN1840_n5419 A2=n5793 B1=FE_OFN1457_n987
+ B2=n5817 C1=FE_OFN1587_FE_DBTN86_n985 C2=n5805
XU2813 OA222 $PINS O=n1613 A1=FE_OFN1840_n5419 A2=n5792 B1=FE_OFN1457_n987
+ B2=n5816 C1=FE_OFN1587_FE_DBTN86_n985 C2=n5804
XU2814 OA222 $PINS O=n1616 A1=n1665 A2=n5791 B1=FE_OFN1456_n987 B2=n5815
+ C1=FE_OFN1587_FE_DBTN86_n985 C2=n5803
XU2815 OA222 $PINS O=n1619 A1=FE_OFN1840_n5419 A2=n5790 B1=FE_OFN1456_n987
+ B2=n5814 C1=FE_OFN1450_n985 C2=n5802
XU2816 OA222 $PINS O=n1622 A1=FE_OFN1790_n5419 A2=n5765
+ B1=FE_OFN1700_FE_DBTN85_n987 B2=n5773 C1=FE_OFN1452_n985 C2=n5769
XU2817 OA222 $PINS O=n1625 A1=FE_OFN1562_n1665 A2=n5764
+ B1=FE_OFN1700_FE_DBTN85_n987 B2=n5772 C1=FE_OFN1452_n985 C2=n5768
XU2818 OA222 $PINS O=n1628 A1=FE_OFN1562_n1665 A2=n5763
+ B1=FE_OFN1700_FE_DBTN85_n987 B2=n5771 C1=FE_OFN1452_n985 C2=n5767
XU2819 OA222 $PINS O=n1631 A1=FE_OFN1790_n5419 A2=n5762
+ B1=FE_OFN1700_FE_DBTN85_n987 B2=n5770 C1=FE_OFN1452_n985 C2=n5766
XU2820 OA222 $PINS O=n1634 A1=FE_OFN1562_n1665 A2=n5877
+ B1=FE_OFN1657_FE_DBTN85_n987 B2=n5885 C1=FE_OFN1593_FE_DBTN86_n985 C2=n5881
XU2821 OA222 $PINS O=n1637 A1=FE_OFN1562_n1665 A2=n5876
+ B1=FE_OFN1657_FE_DBTN85_n987 B2=n5884 C1=FE_OFN1593_FE_DBTN86_n985 C2=n5880
XU2822 OA222 $PINS O=n1640 A1=FE_OFN1562_n1665 A2=n5875
+ B1=FE_OFN1657_FE_DBTN85_n987 B2=n5883 C1=FE_OFN1593_FE_DBTN86_n985 C2=n5879
XU2823 OA222 $PINS O=n1643 A1=n1665 A2=n5874 B1=FE_OFN1460_n987 B2=n5882
+ C1=FE_OFN1452_n985 C2=n5878
Xadd_103_G7 Siso_DW01_add_6 $PINS A[11]=FE_OFN1264_backward_metrics_6__3__11
+ A[10]=FE_OFN1265_backward_metrics_6__3__10
+ A[9]=FE_OFN1266_backward_metrics_6__3__9
+ A[8]=FE_OFN1267_backward_metrics_6__3__8
+ A[7]=FE_OFN1268_backward_metrics_6__3__7
+ A[6]=FE_OFN1269_backward_metrics_6__3__6
+ A[5]=FE_OFN1270_backward_metrics_6__3__5
+ A[4]=FE_OFN1271_backward_metrics_6__3__4 A[3]=backward_metrics[6][3][3]
+ A[2]=FE_OFN1273_backward_metrics_6__3__2
+ A[1]=FE_OFN1274_backward_metrics_6__3__1 A[0]=backward_metrics[6][3][0]
+ B[11]=branch_metrics[0][3][11] B[10]=branch_metrics[0][3][10]
+ B[9]=FE_OFN990_forward_sum_0__5__9 B[8]=FE_OFN991_forward_sum_0__5__8
+ B[7]=FE_OFN992_forward_sum_0__5__7 B[6]=FE_OFN993_forward_sum_0__5__6
+ B[5]=FE_OFN994_forward_sum_0__5__5 B[4]=FE_OFN995_forward_sum_0__5__4
+ B[3]=FE_OFN996_forward_sum_0__5__3 B[2]=FE_OFN997_forward_sum_0__5__2
+ B[1]=forward_sum[0][5][1] B[0]=forward_sum[0][5][0] CI=n1
+ SUM[11]=backward_sum[6][7][11] SUM[10]=backward_sum[6][7][10]
+ SUM[9]=backward_sum[6][7][9] SUM[8]=backward_sum[6][7][8]
+ SUM[7]=backward_sum[6][7][7] SUM[6]=backward_sum[6][7][6]
+ SUM[5]=backward_sum[6][7][5] SUM[4]=backward_sum[6][7][4]
+ SUM[3]=backward_sum[6][7][3] SUM[2]=backward_sum[6][7][2]
+ SUM[1]=backward_sum[6][7][1] SUM[0]=backward_sum[6][7][0]
+ FE_OFN183_forward_sum_0__5__0=FE_OFN999_forward_sum_0__5__0
+ FE_OFN226_backward_metrics_6__3__0=backward_metrics[6][3][0]
Xadd_102_G7 Siso_DW01_add_7 $PINS A[11]=FE_OFN1251_backward_metrics_6__1__11
+ A[10]=FE_OFN1252_backward_metrics_6__1__10 A[9]=backward_metrics[6][1][9]
+ A[8]=FE_OFN1254_backward_metrics_6__1__8
+ A[7]=FE_OFN1255_backward_metrics_6__1__7
+ A[6]=FE_OFN1256_backward_metrics_6__1__6
+ A[5]=FE_OFN1257_backward_metrics_6__1__5 A[4]=backward_metrics[6][1][4]
+ A[3]=FE_OFN1259_backward_metrics_6__1__3
+ A[2]=FE_OFN1260_backward_metrics_6__1__2
+ A[1]=FE_OFN1261_backward_metrics_6__1__1 A[0]=backward_metrics[6][1][0]
+ B[11]=branch_metrics[0][2][11] B[10]=branch_metrics[0][2][10]
+ B[9]=FE_OFN970_forward_sum_0__1__9 B[8]=forward_sum[0][1][8]
+ B[7]=FE_OFN972_forward_sum_0__1__7 B[6]=FE_OFN973_forward_sum_0__1__6
+ B[5]=FE_OFN974_forward_sum_0__1__5 B[4]=forward_sum[0][1][4]
+ B[3]=forward_sum[0][1][3] B[2]=FE_OFN5649_forward_sum_0__1__2
+ B[1]=FE_OFN978_forward_sum_0__1__1 B[0]=forward_sum[0][1][0] CI=n1
+ SUM[11]=backward_sum[6][6][11] SUM[10]=backward_sum[6][6][10]
+ SUM[9]=backward_sum[6][6][9] SUM[8]=backward_sum[6][6][8]
+ SUM[7]=backward_sum[6][6][7] SUM[6]=backward_sum[6][6][6]
+ SUM[5]=backward_sum[6][6][5] SUM[4]=backward_sum[6][6][4]
+ SUM[3]=backward_sum[6][6][3] SUM[2]=backward_sum[6][6][2]
+ SUM[1]=backward_sum[6][6][1] SUM[0]=backward_sum[6][6][0]
+ FE_OFN176_forward_sum_0__1__0=FE_OFN979_forward_sum_0__1__0
+ FE_OFN223_backward_metrics_6__1__0=FE_OFN1262_backward_metrics_6__1__0
Xadd_101_G7 Siso_DW01_add_8 $PINS A[11]=FE_OFN1264_backward_metrics_6__3__11
+ A[10]=FE_OFN1265_backward_metrics_6__3__10
+ A[9]=FE_OFN1266_backward_metrics_6__3__9
+ A[8]=FE_OFN1267_backward_metrics_6__3__8
+ A[7]=FE_OFN1268_backward_metrics_6__3__7 A[6]=backward_metrics[6][3][6]
+ A[5]=FE_OFN1270_backward_metrics_6__3__5
+ A[4]=FE_OFN1271_backward_metrics_6__3__4
+ A[3]=FE_OFN1272_backward_metrics_6__3__3
+ A[2]=FE_OFN1273_backward_metrics_6__3__2
+ A[1]=FE_OFN1274_backward_metrics_6__3__1
+ A[0]=FE_OFN5547_backward_metrics_6__3__0 B[11]=forward_sum[0][4][11]
+ B[10]=forward_sum[0][4][10] B[9]=FE_OFN1000_forward_sum_0__6__9
+ B[8]=FE_OFN1001_forward_sum_0__6__8 B[7]=FE_OFN1002_forward_sum_0__6__7
+ B[6]=FE_OFN1003_forward_sum_0__6__6 B[5]=FE_OFN1004_forward_sum_0__6__5
+ B[4]=FE_OFN1005_forward_sum_0__6__4 B[3]=FE_OFN1006_forward_sum_0__6__3
+ B[2]=FE_OFN1007_forward_sum_0__6__2 B[1]=FE_OFN1008_forward_sum_0__6__1
+ B[0]=FE_OFN1009_forward_sum_0__6__0 CI=n1 SUM[11]=backward_sum[6][5][11]
+ SUM[10]=backward_sum[6][5][10] SUM[9]=backward_sum[6][5][9]
+ SUM[8]=backward_sum[6][5][8] SUM[7]=backward_sum[6][5][7]
+ SUM[6]=backward_sum[6][5][6] SUM[5]=backward_sum[6][5][5]
+ SUM[4]=backward_sum[6][5][4] SUM[3]=backward_sum[6][5][3]
+ SUM[2]=backward_sum[6][5][2] SUM[1]=backward_sum[6][5][1]
+ SUM[0]=backward_sum[6][5][0]
+ FE_OFN227_backward_metrics_6__3__0=backward_metrics[6][3][0]
Xadd_100_G7 Siso_DW01_add_9 $PINS A[11]=FE_OFN1251_backward_metrics_6__1__11
+ A[10]=FE_OFN1252_backward_metrics_6__1__10
+ A[9]=FE_OFN1253_backward_metrics_6__1__9
+ A[8]=FE_OFN1254_backward_metrics_6__1__8
+ A[7]=FE_OFN1255_backward_metrics_6__1__7
+ A[6]=FE_OFN1256_backward_metrics_6__1__6
+ A[5]=FE_OFN1257_backward_metrics_6__1__5
+ A[4]=FE_OFN1258_backward_metrics_6__1__4
+ A[3]=FE_OFN1259_backward_metrics_6__1__3
+ A[2]=FE_OFN1260_backward_metrics_6__1__2
+ A[1]=FE_OFN1261_backward_metrics_6__1__1 A[0]=backward_metrics[6][1][0]
+ B[11]=forward_sum[0][0][11] B[10]=forward_sum[0][0][10]
+ B[9]=FE_OFN980_forward_sum_0__2__9 B[8]=forward_sum[0][2][8]
+ B[7]=FE_OFN982_forward_sum_0__2__7 B[6]=FE_OFN983_forward_sum_0__2__6
+ B[5]=FE_OFN984_forward_sum_0__2__5 B[4]=forward_sum[0][2][4]
+ B[3]=FE_OFN5659_forward_sum_0__2__3 B[2]=FE_OFN987_forward_sum_0__2__2
+ B[1]=FE_OFN988_forward_sum_0__2__1 B[0]=forward_sum[0][2][0] CI=n1
+ SUM[11]=backward_sum[6][4][11] SUM[10]=backward_sum[6][4][10]
+ SUM[9]=backward_sum[6][4][9] SUM[8]=backward_sum[6][4][8]
+ SUM[7]=backward_sum[6][4][7] SUM[6]=backward_sum[6][4][6]
+ SUM[5]=backward_sum[6][4][5] SUM[4]=backward_sum[6][4][4]
+ SUM[3]=backward_sum[6][4][3] SUM[2]=backward_sum[6][4][2]
+ SUM[1]=backward_sum[6][4][1] SUM[0]=backward_sum[6][4][0]
+ FE_OFN224_backward_metrics_6__1__0=FE_OFN1262_backward_metrics_6__1__0
+ FE_OFN245_forward_sum_0__2__0=FE_OFN5651_forward_sum_0__2__0
Xadd_99_G7 Siso_DW01_add_10 $PINS A[11]=backward_metrics[6][2][11]
+ A[10]=backward_metrics[6][2][10] A[9]=backward_metrics[6][2][9]
+ A[8]=backward_metrics[6][2][8] A[7]=backward_metrics[6][2][7]
+ A[6]=backward_metrics[6][2][6] A[5]=backward_metrics[6][2][5]
+ A[4]=backward_metrics[6][2][4] A[3]=backward_metrics[6][2][3]
+ A[2]=backward_metrics[6][2][2] A[1]=backward_metrics[6][2][1]
+ A[0]=backward_metrics[6][2][0] B[11]=branch_metrics[0][3][11]
+ B[10]=branch_metrics[0][3][10] B[9]=FE_OFN990_forward_sum_0__5__9
+ B[8]=FE_OFN991_forward_sum_0__5__8 B[7]=FE_OFN992_forward_sum_0__5__7
+ B[6]=FE_OFN993_forward_sum_0__5__6 B[5]=FE_OFN994_forward_sum_0__5__5
+ B[4]=FE_OFN995_forward_sum_0__5__4 B[3]=forward_sum[0][5][3]
+ B[2]=FE_OFN997_forward_sum_0__5__2 B[1]=FE_OFN998_forward_sum_0__5__1
+ B[0]=FE_OFN999_forward_sum_0__5__0 CI=n1 SUM[11]=backward_sum[6][3][11]
+ SUM[10]=backward_sum[6][3][10] SUM[9]=backward_sum[6][3][9]
+ SUM[8]=backward_sum[6][3][8] SUM[7]=backward_sum[6][3][7]
+ SUM[6]=backward_sum[6][3][6] SUM[5]=backward_sum[6][3][5]
+ SUM[4]=backward_sum[6][3][4] SUM[3]=backward_sum[6][3][3]
+ SUM[2]=backward_sum[6][3][2] SUM[1]=backward_sum[6][3][1]
+ SUM[0]=backward_sum[6][3][0]
+ FE_OFN225_backward_metrics_6__2__0=backward_metrics[6][2][0]
+ FE_OFN247_backward_metrics_6__2__0=FE_OFN5663_backward_metrics_6__2__0
Xadd_98_G7 Siso_DW01_add_11 $PINS A[11]=backward_metrics[6][0][11]
+ A[10]=backward_metrics[6][0][10] A[9]=backward_metrics[6][0][9]
+ A[8]=backward_metrics[6][0][8] A[7]=backward_metrics[6][0][7]
+ A[6]=backward_metrics[6][0][6] A[5]=backward_metrics[6][0][5]
+ A[4]=backward_metrics[6][0][4] A[3]=backward_metrics[6][0][3]
+ A[2]=backward_metrics[6][0][2] A[1]=backward_metrics[6][0][1]
+ A[0]=backward_metrics[6][0][0] B[11]=branch_metrics[0][2][11]
+ B[10]=branch_metrics[0][2][10] B[9]=FE_OFN970_forward_sum_0__1__9
+ B[8]=FE_OFN971_forward_sum_0__1__8 B[7]=FE_OFN972_forward_sum_0__1__7
+ B[6]=FE_OFN973_forward_sum_0__1__6 B[5]=forward_sum[0][1][5]
+ B[4]=FE_OFN975_forward_sum_0__1__4 B[3]=FE_OFN5648_forward_sum_0__1__3
+ B[2]=forward_sum[0][1][2] B[1]=FE_OFN978_forward_sum_0__1__1
+ B[0]=forward_sum[0][1][0] CI=n1 SUM[11]=backward_sum[6][2][11]
+ SUM[10]=backward_sum[6][2][10] SUM[9]=backward_sum[6][2][9]
+ SUM[8]=backward_sum[6][2][8] SUM[7]=backward_sum[6][2][7]
+ SUM[6]=backward_sum[6][2][6] SUM[5]=backward_sum[6][2][5]
+ SUM[4]=backward_sum[6][2][4] SUM[3]=backward_sum[6][2][3]
+ SUM[2]=backward_sum[6][2][2] SUM[1]=backward_sum[6][2][1]
+ SUM[0]=backward_sum[6][2][0]
+ FE_OFN177_forward_sum_0__1__0=FE_OFN979_forward_sum_0__1__0
+ FE_OFN217_backward_metrics_6__0__0=FE_OFN1250_backward_metrics_6__0__0
Xadd_103_G6 Siso_DW01_add_28 $PINS A[11]=FE_OFN1238_backward_metrics_5__3__11
+ A[10]=FE_OFN1239_backward_metrics_5__3__10
+ A[9]=FE_OFN1240_backward_metrics_5__3__9
+ A[8]=FE_OFN1241_backward_metrics_5__3__8
+ A[7]=FE_OFN1242_backward_metrics_5__3__7
+ A[6]=FE_OFN1243_backward_metrics_5__3__6
+ A[5]=FE_OFN1244_backward_metrics_5__3__5
+ A[4]=FE_OFN1245_backward_metrics_5__3__4
+ A[3]=FE_OFN1246_backward_metrics_5__3__3
+ A[2]=FE_OFN1247_backward_metrics_5__3__2
+ A[1]=FE_OFN1248_backward_metrics_5__3__1 A[0]=backward_metrics[5][3][0]
+ B[11]=FE_OFN765_branch_metrics_1__3__11 B[10]=FE_OFN766_branch_metrics_1__3__10
+ B[9]=branch_metrics[1][3][9] B[8]=branch_metrics[1][3][8]
+ B[7]=branch_metrics[1][3][7] B[6]=FE_OFN770_branch_metrics_1__3__6
+ B[5]=FE_OFN771_branch_metrics_1__3__5 B[4]=FE_OFN772_branch_metrics_1__3__4
+ B[3]=branch_metrics[1][3][3] B[2]=branch_metrics[1][3][2]
+ B[1]=branch_metrics[1][3][1] B[0]=branch_metrics[1][3][0] CI=n1
+ SUM[11]=backward_sum[5][7][11] SUM[10]=backward_sum[5][7][10]
+ SUM[9]=backward_sum[5][7][9] SUM[8]=backward_sum[5][7][8]
+ SUM[7]=backward_sum[5][7][7] SUM[6]=backward_sum[5][7][6]
+ SUM[5]=backward_sum[5][7][5] SUM[4]=backward_sum[5][7][4]
+ SUM[3]=backward_sum[5][7][3] SUM[2]=backward_sum[5][7][2]
+ SUM[1]=backward_sum[5][7][1] SUM[0]=backward_sum[5][7][0]
+ FE_OFN236_backward_metrics_5__3__0=FE_OFN1249_backward_metrics_5__3__0
Xadd_102_G6 Siso_DW01_add_29 $PINS A[11]=FE_OFN1214_backward_metrics_5__1__11
+ A[10]=backward_metrics[5][1][10] A[9]=backward_metrics[5][1][9]
+ A[8]=FE_OFN1217_backward_metrics_5__1__8
+ A[7]=FE_OFN1218_backward_metrics_5__1__7 A[6]=backward_metrics[5][1][6]
+ A[5]=FE_OFN1220_backward_metrics_5__1__5
+ A[4]=FE_OFN1221_backward_metrics_5__1__4
+ A[3]=FE_OFN1222_backward_metrics_5__1__3 A[2]=backward_metrics[5][1][2]
+ A[1]=FE_OFN1224_backward_metrics_5__1__1
+ A[0]=FE_OFN1225_backward_metrics_5__1__0
+ B[11]=FE_OFN753_branch_metrics_1__2__11 B[10]=FE_OFN754_branch_metrics_1__2__10
+ B[9]=FE_OFN755_branch_metrics_1__2__9 B[8]=FE_OFN756_branch_metrics_1__2__8
+ B[7]=FE_OFN757_branch_metrics_1__2__7 B[6]=FE_OFN758_branch_metrics_1__2__6
+ B[5]=FE_OFN759_branch_metrics_1__2__5 B[4]=FE_OFN760_branch_metrics_1__2__4
+ B[3]=FE_OFN761_branch_metrics_1__2__3 B[2]=FE_OFN762_branch_metrics_1__2__2
+ B[1]=FE_OFN763_branch_metrics_1__2__1 B[0]=branch_metrics[1][2][0] CI=n1
+ SUM[11]=backward_sum[5][6][11] SUM[10]=backward_sum[5][6][10]
+ SUM[9]=backward_sum[5][6][9] SUM[8]=backward_sum[5][6][8]
+ SUM[7]=backward_sum[5][6][7] SUM[6]=backward_sum[5][6][6]
+ SUM[5]=backward_sum[5][6][5] SUM[4]=backward_sum[5][6][4]
+ SUM[3]=backward_sum[5][6][3] SUM[2]=backward_sum[5][6][2]
+ SUM[1]=backward_sum[5][6][1] SUM[0]=backward_sum[5][6][0]
+ FE_OFN155_branch_metrics_1__2__0=FE_OFN5640_branch_metrics_1__2__0
Xadd_101_G6 Siso_DW01_add_30 $PINS A[11]=FE_OFN1238_backward_metrics_5__3__11
+ A[10]=FE_OFN1239_backward_metrics_5__3__10 A[9]=backward_metrics[5][3][9]
+ A[8]=FE_OFN1241_backward_metrics_5__3__8
+ A[7]=FE_OFN1242_backward_metrics_5__3__7
+ A[6]=FE_OFN1243_backward_metrics_5__3__6
+ A[5]=FE_OFN1244_backward_metrics_5__3__5
+ A[4]=FE_OFN1245_backward_metrics_5__3__4
+ A[3]=FE_OFN1246_backward_metrics_5__3__3
+ A[2]=FE_OFN1247_backward_metrics_5__3__2
+ A[1]=FE_OFN1248_backward_metrics_5__3__1 A[0]=backward_metrics[5][3][0]
+ B[11]=branch_metrics[1][1][11] B[10]=branch_metrics[1][1][10]
+ B[9]=branch_metrics[1][1][9] B[8]=branch_metrics[1][1][8]
+ B[7]=branch_metrics[1][1][7] B[6]=branch_metrics[1][1][6]
+ B[5]=FE_OFN747_branch_metrics_1__1__5 B[4]=FE_OFN748_branch_metrics_1__1__4
+ B[3]=FE_OFN749_branch_metrics_1__1__3 B[2]=FE_OFN750_branch_metrics_1__1__2
+ B[1]=branch_metrics[1][1][1] B[0]=FE_OFN752_branch_metrics_1__1__0 CI=n1
+ SUM[11]=backward_sum[5][5][11] SUM[10]=backward_sum[5][5][10]
+ SUM[9]=backward_sum[5][5][9] SUM[8]=backward_sum[5][5][8]
+ SUM[7]=backward_sum[5][5][7] SUM[6]=backward_sum[5][5][6]
+ SUM[5]=backward_sum[5][5][5] SUM[4]=backward_sum[5][5][4]
+ SUM[3]=backward_sum[5][5][3] SUM[2]=backward_sum[5][5][2]
+ SUM[1]=backward_sum[5][5][1] SUM[0]=backward_sum[5][5][0]
Xadd_100_G6 Siso_DW01_add_31 $PINS A[11]=FE_OFN1214_backward_metrics_5__1__11
+ A[10]=backward_metrics[5][1][10] A[9]=backward_metrics[5][1][9]
+ A[8]=FE_OFN1217_backward_metrics_5__1__8
+ A[7]=FE_OFN1218_backward_metrics_5__1__7
+ A[6]=FE_OFN1219_backward_metrics_5__1__6
+ A[5]=FE_OFN1220_backward_metrics_5__1__5
+ A[4]=FE_OFN1221_backward_metrics_5__1__4 A[3]=backward_metrics[5][1][3]
+ A[2]=FE_OFN1223_backward_metrics_5__1__2 A[1]=backward_metrics[5][1][1]
+ A[0]=FE_OFN1225_backward_metrics_5__1__0
+ B[11]=FE_OFN729_branch_metrics_1__0__11 B[10]=FE_OFN730_branch_metrics_1__0__10
+ B[9]=FE_OFN731_branch_metrics_1__0__9 B[8]=FE_OFN732_branch_metrics_1__0__8
+ B[7]=FE_OFN733_branch_metrics_1__0__7 B[6]=FE_OFN734_branch_metrics_1__0__6
+ B[5]=FE_OFN735_branch_metrics_1__0__5 B[4]=FE_OFN5656_branch_metrics_1__0__4
+ B[3]=FE_OFN737_branch_metrics_1__0__3 B[2]=FE_OFN738_branch_metrics_1__0__2
+ B[1]=branch_metrics[1][0][1] B[0]=FE_OFN740_branch_metrics_1__0__0 CI=n1
+ SUM[11]=backward_sum[5][4][11] SUM[10]=backward_sum[5][4][10]
+ SUM[9]=backward_sum[5][4][9] SUM[8]=backward_sum[5][4][8]
+ SUM[7]=backward_sum[5][4][7] SUM[6]=backward_sum[5][4][6]
+ SUM[5]=backward_sum[5][4][5] SUM[4]=backward_sum[5][4][4]
+ SUM[3]=backward_sum[5][4][3] SUM[2]=backward_sum[5][4][2]
+ SUM[1]=backward_sum[5][4][1] SUM[0]=backward_sum[5][4][0]
Xadd_99_G6 Siso_DW01_add_32 $PINS A[11]=FE_OFN1226_backward_metrics_5__2__11
+ A[10]=FE_OFN1227_backward_metrics_5__2__10
+ A[9]=FE_OFN1228_backward_metrics_5__2__9
+ A[8]=FE_OFN1229_backward_metrics_5__2__8 A[7]=backward_metrics[5][2][7]
+ A[6]=backward_metrics[5][2][6] A[5]=FE_OFN1232_backward_metrics_5__2__5
+ A[4]=FE_OFN1233_backward_metrics_5__2__4 A[3]=backward_metrics[5][2][3]
+ A[2]=backward_metrics[5][2][2] A[1]=FE_OFN1236_backward_metrics_5__2__1
+ A[0]=backward_metrics[5][2][0] B[11]=FE_OFN765_branch_metrics_1__3__11
+ B[10]=branch_metrics[1][3][10] B[9]=FE_OFN767_branch_metrics_1__3__9
+ B[8]=FE_OFN768_branch_metrics_1__3__8 B[7]=FE_OFN769_branch_metrics_1__3__7
+ B[6]=branch_metrics[1][3][6] B[5]=branch_metrics[1][3][5]
+ B[4]=FE_OFN772_branch_metrics_1__3__4 B[3]=FE_OFN773_branch_metrics_1__3__3
+ B[2]=FE_OFN774_branch_metrics_1__3__2 B[1]=FE_OFN775_branch_metrics_1__3__1
+ B[0]=FE_OFN776_branch_metrics_1__3__0 CI=n1 SUM[11]=backward_sum[5][3][11]
+ SUM[10]=backward_sum[5][3][10] SUM[9]=backward_sum[5][3][9]
+ SUM[8]=backward_sum[5][3][8] SUM[7]=backward_sum[5][3][7]
+ SUM[6]=backward_sum[5][3][6] SUM[5]=backward_sum[5][3][5]
+ SUM[4]=backward_sum[5][3][4] SUM[3]=backward_sum[5][3][3]
+ SUM[2]=backward_sum[5][3][2] SUM[1]=backward_sum[5][3][1]
+ SUM[0]=backward_sum[5][3][0]
Xadd_98_G6 Siso_DW01_add_33 $PINS A[11]=FE_OFN1202_backward_metrics_5__0__11
+ A[10]=FE_OFN1203_backward_metrics_5__0__10 A[9]=backward_metrics[5][0][9]
+ A[8]=backward_metrics[5][0][8] A[7]=FE_OFN1206_backward_metrics_5__0__7
+ A[6]=FE_OFN1207_backward_metrics_5__0__6
+ A[5]=FE_OFN1208_backward_metrics_5__0__5
+ A[4]=FE_OFN1209_backward_metrics_5__0__4 A[3]=backward_metrics[5][0][3]
+ A[2]=FE_OFN1211_backward_metrics_5__0__2
+ A[1]=FE_OFN1212_backward_metrics_5__0__1
+ A[0]=FE_OFN1213_backward_metrics_5__0__0
+ B[11]=FE_OFN753_branch_metrics_1__2__11 B[10]=FE_OFN754_branch_metrics_1__2__10
+ B[9]=FE_OFN755_branch_metrics_1__2__9 B[8]=FE_OFN756_branch_metrics_1__2__8
+ B[7]=FE_OFN757_branch_metrics_1__2__7 B[6]=FE_OFN758_branch_metrics_1__2__6
+ B[5]=FE_OFN759_branch_metrics_1__2__5 B[4]=FE_OFN760_branch_metrics_1__2__4
+ B[3]=FE_OFN761_branch_metrics_1__2__3 B[2]=FE_OFN762_branch_metrics_1__2__2
+ B[1]=FE_OFN763_branch_metrics_1__2__1 B[0]=FE_OFN5640_branch_metrics_1__2__0
+ CI=n1 SUM[11]=backward_sum[5][2][11] SUM[10]=backward_sum[5][2][10]
+ SUM[9]=backward_sum[5][2][9] SUM[8]=backward_sum[5][2][8]
+ SUM[7]=backward_sum[5][2][7] SUM[6]=backward_sum[5][2][6]
+ SUM[5]=backward_sum[5][2][5] SUM[4]=backward_sum[5][2][4]
+ SUM[3]=backward_sum[5][2][3] SUM[2]=backward_sum[5][2][2]
+ SUM[1]=backward_sum[5][2][1] SUM[0]=backward_sum[5][2][0]
Xadd_97_G6 Siso_DW01_add_34 $PINS A[11]=FE_OFN1226_backward_metrics_5__2__11
+ A[10]=FE_OFN1227_backward_metrics_5__2__10 A[9]=backward_metrics[5][2][9]
+ A[8]=FE_OFN1229_backward_metrics_5__2__8
+ A[7]=FE_OFN1230_backward_metrics_5__2__7
+ A[6]=FE_OFN1231_backward_metrics_5__2__6
+ A[5]=FE_OFN1232_backward_metrics_5__2__5
+ A[4]=FE_OFN1233_backward_metrics_5__2__4
+ A[3]=FE_OFN1234_backward_metrics_5__2__3 A[2]=backward_metrics[5][2][2]
+ A[1]=FE_OFN1236_backward_metrics_5__2__1 A[0]=backward_metrics[5][2][0]
+ B[11]=FE_OFN741_branch_metrics_1__1__11 B[10]=FE_OFN742_branch_metrics_1__1__10
+ B[9]=FE_OFN743_branch_metrics_1__1__9 B[8]=FE_OFN744_branch_metrics_1__1__8
+ B[7]=FE_OFN745_branch_metrics_1__1__7 B[6]=FE_OFN746_branch_metrics_1__1__6
+ B[5]=FE_OFN747_branch_metrics_1__1__5 B[4]=FE_OFN748_branch_metrics_1__1__4
+ B[3]=branch_metrics[1][1][3] B[2]=FE_OFN750_branch_metrics_1__1__2
+ B[1]=FE_OFN751_branch_metrics_1__1__1 B[0]=FE_OFN752_branch_metrics_1__1__0
+ CI=n1 SUM[11]=backward_sum[5][1][11] SUM[10]=backward_sum[5][1][10]
+ SUM[9]=backward_sum[5][1][9] SUM[8]=backward_sum[5][1][8]
+ SUM[7]=backward_sum[5][1][7] SUM[6]=backward_sum[5][1][6]
+ SUM[5]=backward_sum[5][1][5] SUM[4]=backward_sum[5][1][4]
+ SUM[3]=backward_sum[5][1][3] SUM[2]=backward_sum[5][1][2]
+ SUM[1]=backward_sum[5][1][1] SUM[0]=backward_sum[5][1][0]
+ FE_OFN211_backward_metrics_5__2__0=FE_OFN1237_backward_metrics_5__2__0
Xadd_96_G6 Siso_DW01_add_35 $PINS A[11]=FE_OFN1202_backward_metrics_5__0__11
+ A[10]=FE_OFN1203_backward_metrics_5__0__10
+ A[9]=FE_OFN1204_backward_metrics_5__0__9
+ A[8]=FE_OFN1205_backward_metrics_5__0__8
+ A[7]=FE_OFN1206_backward_metrics_5__0__7 A[6]=backward_metrics[5][0][6]
+ A[5]=FE_OFN1208_backward_metrics_5__0__5
+ A[4]=FE_OFN1209_backward_metrics_5__0__4 A[3]=backward_metrics[5][0][3]
+ A[2]=FE_OFN1211_backward_metrics_5__0__2
+ A[1]=FE_OFN1212_backward_metrics_5__0__1
+ A[0]=FE_OFN1213_backward_metrics_5__0__0
+ B[11]=FE_OFN729_branch_metrics_1__0__11 B[10]=FE_OFN730_branch_metrics_1__0__10
+ B[9]=FE_OFN731_branch_metrics_1__0__9 B[8]=FE_OFN732_branch_metrics_1__0__8
+ B[7]=FE_OFN733_branch_metrics_1__0__7 B[6]=branch_metrics[1][0][6]
+ B[5]=FE_OFN735_branch_metrics_1__0__5 B[4]=FE_OFN5656_branch_metrics_1__0__4
+ B[3]=FE_OFN737_branch_metrics_1__0__3 B[2]=FE_OFN738_branch_metrics_1__0__2
+ B[1]=FE_OFN739_branch_metrics_1__0__1 B[0]=FE_OFN740_branch_metrics_1__0__0
+ CI=n1 SUM[11]=backward_sum[5][0][11] SUM[10]=backward_sum[5][0][10]
+ SUM[9]=backward_sum[5][0][9] SUM[8]=backward_sum[5][0][8]
+ SUM[7]=backward_sum[5][0][7] SUM[6]=backward_sum[5][0][6]
+ SUM[5]=backward_sum[5][0][5] SUM[4]=backward_sum[5][0][4]
+ SUM[3]=backward_sum[5][0][3] SUM[2]=backward_sum[5][0][2]
+ SUM[1]=backward_sum[5][0][1] SUM[0]=backward_sum[5][0][0]
Xadd_103_G5 Siso_DW01_add_52 $PINS A[11]=FE_OFN1190_backward_metrics_4__3__11
+ A[10]=FE_OFN1191_backward_metrics_4__3__10
+ A[9]=FE_OFN1192_backward_metrics_4__3__9
+ A[8]=FE_OFN1193_backward_metrics_4__3__8 A[7]=backward_metrics[4][3][7]
+ A[6]=backward_metrics[4][3][6] A[5]=FE_OFN1196_backward_metrics_4__3__5
+ A[4]=FE_OFN1197_backward_metrics_4__3__4
+ A[3]=FE_OFN1198_backward_metrics_4__3__3
+ A[2]=FE_OFN1199_backward_metrics_4__3__2
+ A[1]=FE_OFN5662_backward_metrics_4__3__1 A[0]=backward_metrics[4][3][0]
+ B[11]=FE_OFN813_branch_metrics_2__3__11 B[10]=FE_OFN814_branch_metrics_2__3__10
+ B[9]=FE_OFN815_branch_metrics_2__3__9 B[8]=FE_OFN816_branch_metrics_2__3__8
+ B[7]=FE_OFN817_branch_metrics_2__3__7 B[6]=FE_OFN818_branch_metrics_2__3__6
+ B[5]=FE_OFN819_branch_metrics_2__3__5 B[4]=FE_OFN820_branch_metrics_2__3__4
+ B[3]=branch_metrics[2][3][3] B[2]=FE_OFN5553_branch_metrics_2__3__2
+ B[1]=branch_metrics[2][3][1] B[0]=branch_metrics[2][3][0] CI=n1
+ SUM[11]=backward_sum[4][7][11] SUM[10]=backward_sum[4][7][10]
+ SUM[9]=backward_sum[4][7][9] SUM[8]=backward_sum[4][7][8]
+ SUM[7]=backward_sum[4][7][7] SUM[6]=backward_sum[4][7][6]
+ SUM[5]=backward_sum[4][7][5] SUM[4]=backward_sum[4][7][4]
+ SUM[3]=backward_sum[4][7][3] SUM[2]=backward_sum[4][7][2]
+ SUM[1]=backward_sum[4][7][1] SUM[0]=backward_sum[4][7][0]
+ FE_OFN239_backward_metrics_4__3__0=backward_metrics[4][3][0]
Xadd_102_G5 Siso_DW01_add_53 $PINS A[11]=FE_OFN1166_backward_metrics_4__1__11
+ A[10]=FE_OFN1167_backward_metrics_4__1__10
+ A[9]=FE_OFN1168_backward_metrics_4__1__9 A[8]=backward_metrics[4][1][8]
+ A[7]=FE_OFN1170_backward_metrics_4__1__7
+ A[6]=FE_OFN1171_backward_metrics_4__1__6
+ A[5]=FE_OFN1172_backward_metrics_4__1__5
+ A[4]=FE_OFN1173_backward_metrics_4__1__4
+ A[3]=FE_OFN1174_backward_metrics_4__1__3
+ A[2]=FE_OFN1175_backward_metrics_4__1__2
+ A[1]=FE_OFN1176_backward_metrics_4__1__1
+ A[0]=FE_OFN1177_backward_metrics_4__1__0
+ B[11]=FE_OFN801_branch_metrics_2__2__11 B[10]=FE_OFN802_branch_metrics_2__2__10
+ B[9]=FE_OFN803_branch_metrics_2__2__9 B[8]=FE_OFN804_branch_metrics_2__2__8
+ B[7]=FE_OFN805_branch_metrics_2__2__7 B[6]=FE_OFN806_branch_metrics_2__2__6
+ B[5]=FE_OFN807_branch_metrics_2__2__5 B[4]=FE_OFN808_branch_metrics_2__2__4
+ B[3]=FE_OFN809_branch_metrics_2__2__3 B[2]=FE_OFN810_branch_metrics_2__2__2
+ B[1]=FE_OFN811_branch_metrics_2__2__1 B[0]=FE_OFN812_branch_metrics_2__2__0
+ CI=n1 SUM[11]=backward_sum[4][6][11] SUM[10]=backward_sum[4][6][10]
+ SUM[9]=backward_sum[4][6][9] SUM[8]=backward_sum[4][6][8]
+ SUM[7]=backward_sum[4][6][7] SUM[6]=backward_sum[4][6][6]
+ SUM[5]=backward_sum[4][6][5] SUM[4]=backward_sum[4][6][4]
+ SUM[3]=backward_sum[4][6][3] SUM[2]=backward_sum[4][6][2]
+ SUM[1]=backward_sum[4][6][1] SUM[0]=backward_sum[4][6][0]
Xadd_101_G5 Siso_DW01_add_54 $PINS A[11]=FE_OFN1190_backward_metrics_4__3__11
+ A[10]=FE_OFN1191_backward_metrics_4__3__10
+ A[9]=FE_OFN1192_backward_metrics_4__3__9
+ A[8]=FE_OFN1193_backward_metrics_4__3__8 A[7]=backward_metrics[4][3][7]
+ A[6]=backward_metrics[4][3][6] A[5]=FE_OFN1196_backward_metrics_4__3__5
+ A[4]=FE_OFN1197_backward_metrics_4__3__4
+ A[3]=FE_OFN1198_backward_metrics_4__3__3
+ A[2]=FE_OFN1199_backward_metrics_4__3__2
+ A[1]=FE_OFN5662_backward_metrics_4__3__1 A[0]=backward_metrics[4][3][0]
+ B[11]=FE_OFN789_branch_metrics_2__1__11 B[10]=FE_OFN790_branch_metrics_2__1__10
+ B[9]=FE_OFN791_branch_metrics_2__1__9 B[8]=branch_metrics[2][1][8]
+ B[7]=branch_metrics[2][1][7] B[6]=branch_metrics[2][1][6]
+ B[5]=FE_OFN795_branch_metrics_2__1__5 B[4]=FE_OFN796_branch_metrics_2__1__4
+ B[3]=FE_OFN797_branch_metrics_2__1__3 B[2]=FE_OFN798_branch_metrics_2__1__2
+ B[1]=branch_metrics[2][1][1] B[0]=FE_OFN800_branch_metrics_2__1__0 CI=n1
+ SUM[11]=backward_sum[4][5][11] SUM[10]=backward_sum[4][5][10]
+ SUM[9]=backward_sum[4][5][9] SUM[8]=backward_sum[4][5][8]
+ SUM[7]=backward_sum[4][5][7] SUM[6]=backward_sum[4][5][6]
+ SUM[5]=backward_sum[4][5][5] SUM[4]=backward_sum[4][5][4]
+ SUM[3]=backward_sum[4][5][3] SUM[2]=backward_sum[4][5][2]
+ SUM[1]=backward_sum[4][5][1] SUM[0]=backward_sum[4][5][0]
Xadd_100_G5 Siso_DW01_add_55 $PINS A[11]=backward_metrics[4][1][11]
+ A[10]=FE_OFN1167_backward_metrics_4__1__10
+ A[9]=FE_OFN1168_backward_metrics_4__1__9 A[8]=backward_metrics[4][1][8]
+ A[7]=FE_OFN1170_backward_metrics_4__1__7
+ A[6]=FE_OFN1171_backward_metrics_4__1__6
+ A[5]=FE_OFN1172_backward_metrics_4__1__5
+ A[4]=FE_OFN1173_backward_metrics_4__1__4
+ A[3]=FE_OFN1174_backward_metrics_4__1__3
+ A[2]=FE_OFN1175_backward_metrics_4__1__2
+ A[1]=FE_OFN1176_backward_metrics_4__1__1
+ A[0]=FE_OFN1177_backward_metrics_4__1__0
+ B[11]=FE_OFN777_branch_metrics_2__0__11 B[10]=FE_OFN778_branch_metrics_2__0__10
+ B[9]=FE_OFN779_branch_metrics_2__0__9 B[8]=FE_OFN780_branch_metrics_2__0__8
+ B[7]=FE_OFN781_branch_metrics_2__0__7 B[6]=branch_metrics[2][0][6]
+ B[5]=FE_OFN783_branch_metrics_2__0__5 B[4]=FE_OFN784_branch_metrics_2__0__4
+ B[3]=FE_OFN785_branch_metrics_2__0__3 B[2]=FE_OFN786_branch_metrics_2__0__2
+ B[1]=FE_OFN787_branch_metrics_2__0__1 B[0]=FE_OFN788_branch_metrics_2__0__0
+ CI=n1 SUM[11]=backward_sum[4][4][11] SUM[10]=backward_sum[4][4][10]
+ SUM[9]=backward_sum[4][4][9] SUM[8]=backward_sum[4][4][8]
+ SUM[7]=backward_sum[4][4][7] SUM[6]=backward_sum[4][4][6]
+ SUM[5]=backward_sum[4][4][5] SUM[4]=backward_sum[4][4][4]
+ SUM[3]=backward_sum[4][4][3] SUM[2]=backward_sum[4][4][2]
+ SUM[1]=backward_sum[4][4][1] SUM[0]=backward_sum[4][4][0]
Xadd_99_G5 Siso_DW01_add_56 $PINS A[11]=FE_OFN1178_backward_metrics_4__2__11
+ A[10]=FE_OFN1179_backward_metrics_4__2__10
+ A[9]=FE_OFN1180_backward_metrics_4__2__9
+ A[8]=FE_OFN1181_backward_metrics_4__2__8
+ A[7]=FE_OFN1182_backward_metrics_4__2__7
+ A[6]=FE_OFN1183_backward_metrics_4__2__6
+ A[5]=FE_OFN1184_backward_metrics_4__2__5
+ A[4]=FE_OFN1185_backward_metrics_4__2__4
+ A[3]=FE_OFN1186_backward_metrics_4__2__3 A[2]=backward_metrics[4][2][2]
+ A[1]=FE_OFN1188_backward_metrics_4__2__1 A[0]=backward_metrics[4][2][0]
+ B[11]=FE_OFN813_branch_metrics_2__3__11 B[10]=FE_OFN814_branch_metrics_2__3__10
+ B[9]=FE_OFN815_branch_metrics_2__3__9 B[8]=branch_metrics[2][3][8]
+ B[7]=FE_OFN817_branch_metrics_2__3__7 B[6]=FE_OFN818_branch_metrics_2__3__6
+ B[5]=FE_OFN819_branch_metrics_2__3__5 B[4]=FE_OFN820_branch_metrics_2__3__4
+ B[3]=FE_OFN5555_branch_metrics_2__3__3 B[2]=FE_OFN5553_branch_metrics_2__3__2
+ B[1]=FE_OFN823_branch_metrics_2__3__1 B[0]=FE_OFN824_branch_metrics_2__3__0
+ CI=n1 SUM[11]=backward_sum[4][3][11] SUM[10]=backward_sum[4][3][10]
+ SUM[9]=backward_sum[4][3][9] SUM[8]=backward_sum[4][3][8]
+ SUM[7]=backward_sum[4][3][7] SUM[6]=backward_sum[4][3][6]
+ SUM[5]=backward_sum[4][3][5] SUM[4]=backward_sum[4][3][4]
+ SUM[3]=backward_sum[4][3][3] SUM[2]=backward_sum[4][3][2]
+ SUM[1]=backward_sum[4][3][1] SUM[0]=backward_sum[4][3][0]
+ FE_OFN205_backward_metrics_4__2__0=FE_OFN1189_backward_metrics_4__2__0
Xadd_98_G5 Siso_DW01_add_57 $PINS A[11]=FE_OFN1154_backward_metrics_4__0__11
+ A[10]=FE_OFN1155_backward_metrics_4__0__10 A[9]=backward_metrics[4][0][9]
+ A[8]=FE_OFN1157_backward_metrics_4__0__8
+ A[7]=FE_OFN1158_backward_metrics_4__0__7
+ A[6]=FE_OFN1159_backward_metrics_4__0__6
+ A[5]=FE_OFN1160_backward_metrics_4__0__5
+ A[4]=FE_OFN1161_backward_metrics_4__0__4
+ A[3]=FE_OFN1162_backward_metrics_4__0__3
+ A[2]=FE_OFN1163_backward_metrics_4__0__2
+ A[1]=FE_OFN1164_backward_metrics_4__0__1 A[0]=backward_metrics[4][0][0]
+ B[11]=FE_OFN801_branch_metrics_2__2__11 B[10]=FE_OFN802_branch_metrics_2__2__10
+ B[9]=FE_OFN803_branch_metrics_2__2__9 B[8]=FE_OFN804_branch_metrics_2__2__8
+ B[7]=FE_OFN805_branch_metrics_2__2__7 B[6]=FE_OFN806_branch_metrics_2__2__6
+ B[5]=FE_OFN807_branch_metrics_2__2__5 B[4]=FE_OFN808_branch_metrics_2__2__4
+ B[3]=FE_OFN809_branch_metrics_2__2__3 B[2]=FE_OFN810_branch_metrics_2__2__2
+ B[1]=FE_OFN811_branch_metrics_2__2__1 B[0]=FE_OFN812_branch_metrics_2__2__0
+ CI=n1 SUM[11]=backward_sum[4][2][11] SUM[10]=backward_sum[4][2][10]
+ SUM[9]=backward_sum[4][2][9] SUM[8]=backward_sum[4][2][8]
+ SUM[7]=backward_sum[4][2][7] SUM[6]=backward_sum[4][2][6]
+ SUM[5]=backward_sum[4][2][5] SUM[4]=backward_sum[4][2][4]
+ SUM[3]=backward_sum[4][2][3] SUM[2]=backward_sum[4][2][2]
+ SUM[1]=backward_sum[4][2][1] SUM[0]=backward_sum[4][2][0]
Xadd_97_G5 Siso_DW01_add_58 $PINS A[11]=FE_OFN1178_backward_metrics_4__2__11
+ A[10]=FE_OFN1179_backward_metrics_4__2__10
+ A[9]=FE_OFN1180_backward_metrics_4__2__9
+ A[8]=FE_OFN1181_backward_metrics_4__2__8
+ A[7]=FE_OFN1182_backward_metrics_4__2__7
+ A[6]=FE_OFN1183_backward_metrics_4__2__6
+ A[5]=FE_OFN1184_backward_metrics_4__2__5
+ A[4]=FE_OFN1185_backward_metrics_4__2__4
+ A[3]=FE_OFN1186_backward_metrics_4__2__3
+ A[2]=FE_OFN1187_backward_metrics_4__2__2
+ A[1]=FE_OFN1188_backward_metrics_4__2__1 A[0]=backward_metrics[4][2][0]
+ B[11]=FE_OFN789_branch_metrics_2__1__11 B[10]=branch_metrics[2][1][10]
+ B[9]=FE_OFN791_branch_metrics_2__1__9 B[8]=FE_OFN792_branch_metrics_2__1__8
+ B[7]=FE_OFN793_branch_metrics_2__1__7 B[6]=FE_OFN794_branch_metrics_2__1__6
+ B[5]=FE_OFN795_branch_metrics_2__1__5 B[4]=FE_OFN796_branch_metrics_2__1__4
+ B[3]=FE_OFN797_branch_metrics_2__1__3 B[2]=FE_OFN798_branch_metrics_2__1__2
+ B[1]=FE_OFN799_branch_metrics_2__1__1 B[0]=FE_OFN800_branch_metrics_2__1__0
+ CI=n1 SUM[11]=backward_sum[4][1][11] SUM[10]=backward_sum[4][1][10]
+ SUM[9]=backward_sum[4][1][9] SUM[8]=backward_sum[4][1][8]
+ SUM[7]=backward_sum[4][1][7] SUM[6]=backward_sum[4][1][6]
+ SUM[5]=backward_sum[4][1][5] SUM[4]=backward_sum[4][1][4]
+ SUM[3]=backward_sum[4][1][3] SUM[2]=backward_sum[4][1][2]
+ SUM[1]=backward_sum[4][1][1] SUM[0]=backward_sum[4][1][0]
+ FE_OFN204_backward_metrics_4__2__0=FE_OFN1189_backward_metrics_4__2__0
Xadd_96_G5 Siso_DW01_add_59 $PINS A[11]=backward_metrics[4][0][11]
+ A[10]=FE_OFN1155_backward_metrics_4__0__10
+ A[9]=FE_OFN1156_backward_metrics_4__0__9
+ A[8]=FE_OFN1157_backward_metrics_4__0__8
+ A[7]=FE_OFN1158_backward_metrics_4__0__7
+ A[6]=FE_OFN1159_backward_metrics_4__0__6
+ A[5]=FE_OFN1160_backward_metrics_4__0__5
+ A[4]=FE_OFN1161_backward_metrics_4__0__4
+ A[3]=FE_OFN1162_backward_metrics_4__0__3
+ A[2]=FE_OFN1163_backward_metrics_4__0__2
+ A[1]=FE_OFN1164_backward_metrics_4__0__1 A[0]=backward_metrics[4][0][0]
+ B[11]=FE_OFN777_branch_metrics_2__0__11 B[10]=FE_OFN778_branch_metrics_2__0__10
+ B[9]=FE_OFN779_branch_metrics_2__0__9 B[8]=FE_OFN780_branch_metrics_2__0__8
+ B[7]=FE_OFN781_branch_metrics_2__0__7 B[6]=FE_OFN782_branch_metrics_2__0__6
+ B[5]=FE_OFN783_branch_metrics_2__0__5 B[4]=FE_OFN784_branch_metrics_2__0__4
+ B[3]=FE_OFN785_branch_metrics_2__0__3 B[2]=FE_OFN786_branch_metrics_2__0__2
+ B[1]=FE_OFN787_branch_metrics_2__0__1 B[0]=FE_OFN788_branch_metrics_2__0__0
+ CI=n1 SUM[11]=backward_sum[4][0][11] SUM[10]=backward_sum[4][0][10]
+ SUM[9]=backward_sum[4][0][9] SUM[8]=backward_sum[4][0][8]
+ SUM[7]=backward_sum[4][0][7] SUM[6]=backward_sum[4][0][6]
+ SUM[5]=backward_sum[4][0][5] SUM[4]=backward_sum[4][0][4]
+ SUM[3]=backward_sum[4][0][3] SUM[2]=backward_sum[4][0][2]
+ SUM[1]=backward_sum[4][0][1] SUM[0]=backward_sum[4][0][0]
+ FE_OFN240_backward_metrics_4__0__0=backward_metrics[4][0][0]
Xadd_103_G4 Siso_DW01_add_76 $PINS A[11]=FE_OFN1142_backward_metrics_3__3__11
+ A[10]=FE_OFN1143_backward_metrics_3__3__10
+ A[9]=FE_OFN1144_backward_metrics_3__3__9
+ A[8]=FE_OFN1145_backward_metrics_3__3__8
+ A[7]=FE_OFN1146_backward_metrics_3__3__7 A[6]=backward_metrics[3][3][6]
+ A[5]=FE_OFN1148_backward_metrics_3__3__5
+ A[4]=FE_OFN1149_backward_metrics_3__3__4
+ A[3]=FE_OFN1150_backward_metrics_3__3__3
+ A[2]=FE_OFN1151_backward_metrics_3__3__2
+ A[1]=FE_OFN1152_backward_metrics_3__3__1
+ A[0]=FE_OFN1153_backward_metrics_3__3__0 B[11]=branch_metrics[3][3][11]
+ B[10]=branch_metrics[3][3][10] B[9]=branch_metrics[3][3][9]
+ B[8]=FE_OFN864_branch_metrics_3__3__8 B[7]=FE_OFN865_branch_metrics_3__3__7
+ B[6]=FE_OFN866_branch_metrics_3__3__6 B[5]=FE_OFN867_branch_metrics_3__3__5
+ B[4]=FE_OFN868_branch_metrics_3__3__4 B[3]=branch_metrics[3][3][3]
+ B[2]=FE_OFN870_branch_metrics_3__3__2 B[1]=branch_metrics[3][3][1]
+ B[0]=branch_metrics[3][3][0] CI=n1 SUM[11]=backward_sum[3][7][11]
+ SUM[10]=backward_sum[3][7][10] SUM[9]=backward_sum[3][7][9]
+ SUM[8]=backward_sum[3][7][8] SUM[7]=backward_sum[3][7][7]
+ SUM[6]=backward_sum[3][7][6] SUM[5]=backward_sum[3][7][5]
+ SUM[4]=backward_sum[3][7][4] SUM[3]=backward_sum[3][7][3]
+ SUM[2]=backward_sum[3][7][2] SUM[1]=backward_sum[3][7][1]
+ SUM[0]=backward_sum[3][7][0]
Xadd_102_G4 Siso_DW01_add_77 $PINS A[11]=backward_metrics[3][1][11]
+ A[10]=backward_metrics[3][1][10] A[9]=backward_metrics[3][1][9]
+ A[8]=FE_OFN1121_backward_metrics_3__1__8
+ A[7]=FE_OFN1122_backward_metrics_3__1__7
+ A[6]=FE_OFN1123_backward_metrics_3__1__6 A[5]=backward_metrics[3][1][5]
+ A[4]=FE_OFN1125_backward_metrics_3__1__4
+ A[3]=FE_OFN1126_backward_metrics_3__1__3
+ A[2]=FE_OFN1127_backward_metrics_3__1__2
+ A[1]=FE_OFN1128_backward_metrics_3__1__1 A[0]=backward_metrics[3][1][0]
+ B[11]=branch_metrics[3][2][11] B[10]=FE_OFN850_branch_metrics_3__2__10
+ B[9]=FE_OFN851_branch_metrics_3__2__9 B[8]=branch_metrics[3][2][8]
+ B[7]=FE_OFN853_branch_metrics_3__2__7 B[6]=FE_OFN854_branch_metrics_3__2__6
+ B[5]=FE_OFN855_branch_metrics_3__2__5 B[4]=FE_OFN856_branch_metrics_3__2__4
+ B[3]=FE_OFN857_branch_metrics_3__2__3 B[2]=FE_OFN858_branch_metrics_3__2__2
+ B[1]=FE_OFN859_branch_metrics_3__2__1 B[0]=FE_OFN860_branch_metrics_3__2__0
+ CI=n1 SUM[11]=backward_sum[3][6][11] SUM[10]=backward_sum[3][6][10]
+ SUM[9]=backward_sum[3][6][9] SUM[8]=backward_sum[3][6][8]
+ SUM[7]=backward_sum[3][6][7] SUM[6]=backward_sum[3][6][6]
+ SUM[5]=backward_sum[3][6][5] SUM[4]=backward_sum[3][6][4]
+ SUM[3]=backward_sum[3][6][3] SUM[2]=backward_sum[3][6][2]
+ SUM[1]=backward_sum[3][6][1] SUM[0]=backward_sum[3][6][0]
+ FE_OFN195_backward_metrics_3__1__0=FE_OFN1129_backward_metrics_3__1__0
Xadd_101_G4 Siso_DW01_add_78 $PINS A[11]=FE_OFN1142_backward_metrics_3__3__11
+ A[10]=FE_OFN1143_backward_metrics_3__3__10
+ A[9]=FE_OFN1144_backward_metrics_3__3__9
+ A[8]=FE_OFN1145_backward_metrics_3__3__8
+ A[7]=FE_OFN1146_backward_metrics_3__3__7 A[6]=backward_metrics[3][3][6]
+ A[5]=FE_OFN1148_backward_metrics_3__3__5
+ A[4]=FE_OFN1149_backward_metrics_3__3__4
+ A[3]=FE_OFN1150_backward_metrics_3__3__3
+ A[2]=FE_OFN1151_backward_metrics_3__3__2
+ A[1]=FE_OFN1152_backward_metrics_3__3__1 A[0]=backward_metrics[3][3][0]
+ B[11]=branch_metrics[3][1][11] B[10]=branch_metrics[3][1][10]
+ B[9]=FE_OFN839_branch_metrics_3__1__9 B[8]=FE_OFN840_branch_metrics_3__1__8
+ B[7]=FE_OFN841_branch_metrics_3__1__7 B[6]=FE_OFN842_branch_metrics_3__1__6
+ B[5]=FE_OFN843_branch_metrics_3__1__5 B[4]=FE_OFN844_branch_metrics_3__1__4
+ B[3]=FE_OFN845_branch_metrics_3__1__3 B[2]=FE_OFN846_branch_metrics_3__1__2
+ B[1]=branch_metrics[3][1][1] B[0]=branch_metrics[3][1][0] CI=n1
+ SUM[11]=backward_sum[3][5][11] SUM[10]=backward_sum[3][5][10]
+ SUM[9]=backward_sum[3][5][9] SUM[8]=backward_sum[3][5][8]
+ SUM[7]=backward_sum[3][5][7] SUM[6]=backward_sum[3][5][6]
+ SUM[5]=backward_sum[3][5][5] SUM[4]=backward_sum[3][5][4]
+ SUM[3]=backward_sum[3][5][3] SUM[2]=backward_sum[3][5][2]
+ SUM[1]=backward_sum[3][5][1] SUM[0]=backward_sum[3][5][0]
+ FE_OFN198_backward_metrics_3__3__0=FE_OFN1153_backward_metrics_3__3__0
Xadd_100_G4 Siso_DW01_add_79 $PINS A[11]=backward_metrics[3][1][11]
+ A[10]=backward_metrics[3][1][10] A[9]=FE_OFN1120_backward_metrics_3__1__9
+ A[8]=FE_OFN1121_backward_metrics_3__1__8
+ A[7]=FE_OFN1122_backward_metrics_3__1__7
+ A[6]=FE_OFN1123_backward_metrics_3__1__6
+ A[5]=FE_OFN1124_backward_metrics_3__1__5
+ A[4]=FE_OFN1125_backward_metrics_3__1__4
+ A[3]=FE_OFN1126_backward_metrics_3__1__3
+ A[2]=FE_OFN1127_backward_metrics_3__1__2
+ A[1]=FE_OFN1128_backward_metrics_3__1__1 A[0]=backward_metrics[3][1][0]
+ B[11]=FE_OFN825_branch_metrics_3__0__11 B[10]=FE_OFN826_branch_metrics_3__0__10
+ B[9]=FE_OFN827_branch_metrics_3__0__9 B[8]=FE_OFN828_branch_metrics_3__0__8
+ B[7]=FE_OFN829_branch_metrics_3__0__7 B[6]=FE_OFN830_branch_metrics_3__0__6
+ B[5]=FE_OFN831_branch_metrics_3__0__5 B[4]=FE_OFN832_branch_metrics_3__0__4
+ B[3]=FE_OFN833_branch_metrics_3__0__3 B[2]=FE_OFN834_branch_metrics_3__0__2
+ B[1]=FE_OFN835_branch_metrics_3__0__1 B[0]=FE_OFN836_branch_metrics_3__0__0
+ CI=n1 SUM[11]=backward_sum[3][4][11] SUM[10]=backward_sum[3][4][10]
+ SUM[9]=backward_sum[3][4][9] SUM[8]=backward_sum[3][4][8]
+ SUM[7]=backward_sum[3][4][7] SUM[6]=backward_sum[3][4][6]
+ SUM[5]=backward_sum[3][4][5] SUM[4]=backward_sum[3][4][4]
+ SUM[3]=backward_sum[3][4][3] SUM[2]=backward_sum[3][4][2]
+ SUM[1]=backward_sum[3][4][1] SUM[0]=backward_sum[3][4][0]
+ FE_OFN194_backward_metrics_3__1__0=backward_metrics[3][1][0]
Xadd_99_G4 Siso_DW01_add_80 $PINS A[11]=FE_OFN1130_backward_metrics_3__2__11
+ A[10]=backward_metrics[3][2][10] A[9]=backward_metrics[3][2][9]
+ A[8]=FE_OFN1133_backward_metrics_3__2__8
+ A[7]=FE_OFN1134_backward_metrics_3__2__7
+ A[6]=FE_OFN1135_backward_metrics_3__2__6 A[5]=backward_metrics[3][2][5]
+ A[4]=FE_OFN1137_backward_metrics_3__2__4
+ A[3]=FE_OFN1138_backward_metrics_3__2__3
+ A[2]=FE_OFN1139_backward_metrics_3__2__2
+ A[1]=FE_OFN1140_backward_metrics_3__2__1 A[0]=backward_metrics[3][2][0]
+ B[11]=FE_OFN861_branch_metrics_3__3__11 B[10]=FE_OFN862_branch_metrics_3__3__10
+ B[9]=FE_OFN863_branch_metrics_3__3__9 B[8]=FE_OFN864_branch_metrics_3__3__8
+ B[7]=FE_OFN865_branch_metrics_3__3__7 B[6]=FE_OFN866_branch_metrics_3__3__6
+ B[5]=FE_OFN867_branch_metrics_3__3__5 B[4]=FE_OFN868_branch_metrics_3__3__4
+ B[3]=FE_OFN869_branch_metrics_3__3__3 B[2]=FE_OFN870_branch_metrics_3__3__2
+ B[1]=FE_OFN871_branch_metrics_3__3__1 B[0]=FE_OFN872_branch_metrics_3__3__0
+ CI=n1 SUM[11]=backward_sum[3][3][11] SUM[10]=backward_sum[3][3][10]
+ SUM[9]=backward_sum[3][3][9] SUM[8]=backward_sum[3][3][8]
+ SUM[7]=backward_sum[3][3][7] SUM[6]=backward_sum[3][3][6]
+ SUM[5]=backward_sum[3][3][5] SUM[4]=backward_sum[3][3][4]
+ SUM[3]=backward_sum[3][3][3] SUM[2]=backward_sum[3][3][2]
+ SUM[1]=backward_sum[3][3][1] SUM[0]=backward_sum[3][3][0]
+ FE_OFN196_backward_metrics_3__2__0=backward_metrics[3][2][0]
Xadd_98_G4 Siso_DW01_add_81 $PINS A[11]=backward_metrics[3][0][11]
+ A[10]=FE_OFN1107_backward_metrics_3__0__10
+ A[9]=FE_OFN1108_backward_metrics_3__0__9
+ A[8]=FE_OFN1109_backward_metrics_3__0__8
+ A[7]=FE_OFN1110_backward_metrics_3__0__7
+ A[6]=FE_OFN1111_backward_metrics_3__0__6
+ A[5]=FE_OFN1112_backward_metrics_3__0__5
+ A[4]=FE_OFN1113_backward_metrics_3__0__4
+ A[3]=FE_OFN5660_backward_metrics_3__0__3 A[2]=backward_metrics[3][0][2]
+ A[1]=FE_OFN1116_backward_metrics_3__0__1 A[0]=backward_metrics[3][0][0]
+ B[11]=branch_metrics[3][2][11] B[10]=FE_OFN850_branch_metrics_3__2__10
+ B[9]=FE_OFN851_branch_metrics_3__2__9 B[8]=branch_metrics[3][2][8]
+ B[7]=FE_OFN853_branch_metrics_3__2__7 B[6]=FE_OFN854_branch_metrics_3__2__6
+ B[5]=FE_OFN855_branch_metrics_3__2__5 B[4]=FE_OFN856_branch_metrics_3__2__4
+ B[3]=FE_OFN857_branch_metrics_3__2__3 B[2]=FE_OFN858_branch_metrics_3__2__2
+ B[1]=FE_OFN859_branch_metrics_3__2__1 B[0]=FE_OFN860_branch_metrics_3__2__0
+ CI=n1 SUM[11]=backward_sum[3][2][11] SUM[10]=backward_sum[3][2][10]
+ SUM[9]=backward_sum[3][2][9] SUM[8]=backward_sum[3][2][8]
+ SUM[7]=backward_sum[3][2][7] SUM[6]=backward_sum[3][2][6]
+ SUM[5]=backward_sum[3][2][5] SUM[4]=backward_sum[3][2][4]
+ SUM[3]=backward_sum[3][2][3] SUM[2]=backward_sum[3][2][2]
+ SUM[1]=backward_sum[3][2][1] SUM[0]=backward_sum[3][2][0]
+ FE_OFN192_backward_metrics_3__0__0=backward_metrics[3][0][0]
Xadd_97_G4 Siso_DW01_add_82 $PINS A[11]=FE_OFN1130_backward_metrics_3__2__11
+ A[10]=FE_OFN1131_backward_metrics_3__2__10
+ A[9]=FE_OFN1132_backward_metrics_3__2__9
+ A[8]=FE_OFN1133_backward_metrics_3__2__8
+ A[7]=FE_OFN1134_backward_metrics_3__2__7
+ A[6]=FE_OFN1135_backward_metrics_3__2__6 A[5]=backward_metrics[3][2][5]
+ A[4]=FE_OFN1137_backward_metrics_3__2__4
+ A[3]=FE_OFN1138_backward_metrics_3__2__3
+ A[2]=FE_OFN1139_backward_metrics_3__2__2
+ A[1]=FE_OFN1140_backward_metrics_3__2__1 A[0]=backward_metrics[3][2][0]
+ B[11]=FE_OFN837_branch_metrics_3__1__11 B[10]=FE_OFN838_branch_metrics_3__1__10
+ B[9]=FE_OFN839_branch_metrics_3__1__9 B[8]=FE_OFN840_branch_metrics_3__1__8
+ B[7]=FE_OFN841_branch_metrics_3__1__7 B[6]=FE_OFN842_branch_metrics_3__1__6
+ B[5]=FE_OFN843_branch_metrics_3__1__5 B[4]=FE_OFN844_branch_metrics_3__1__4
+ B[3]=branch_metrics[3][1][3] B[2]=FE_OFN846_branch_metrics_3__1__2
+ B[1]=FE_OFN847_branch_metrics_3__1__1 B[0]=FE_OFN848_branch_metrics_3__1__0
+ CI=n1 SUM[11]=backward_sum[3][1][11] SUM[10]=backward_sum[3][1][10]
+ SUM[9]=backward_sum[3][1][9] SUM[8]=backward_sum[3][1][8]
+ SUM[7]=backward_sum[3][1][7] SUM[6]=backward_sum[3][1][6]
+ SUM[5]=backward_sum[3][1][5] SUM[4]=backward_sum[3][1][4]
+ SUM[3]=backward_sum[3][1][3] SUM[2]=backward_sum[3][1][2]
+ SUM[1]=backward_sum[3][1][1] SUM[0]=backward_sum[3][1][0]
+ FE_OFN197_backward_metrics_3__2__0=backward_metrics[3][2][0]
Xadd_96_G4 Siso_DW01_add_83 $PINS A[11]=backward_metrics[3][0][11]
+ A[10]=FE_OFN1107_backward_metrics_3__0__10
+ A[9]=FE_OFN1108_backward_metrics_3__0__9
+ A[8]=FE_OFN1109_backward_metrics_3__0__8
+ A[7]=FE_OFN1110_backward_metrics_3__0__7
+ A[6]=FE_OFN1111_backward_metrics_3__0__6
+ A[5]=FE_OFN1112_backward_metrics_3__0__5
+ A[4]=FE_OFN1113_backward_metrics_3__0__4
+ A[3]=FE_OFN5660_backward_metrics_3__0__3 A[2]=backward_metrics[3][0][2]
+ A[1]=FE_OFN1116_backward_metrics_3__0__1 A[0]=backward_metrics[3][0][0]
+ B[11]=FE_OFN825_branch_metrics_3__0__11 B[10]=FE_OFN826_branch_metrics_3__0__10
+ B[9]=FE_OFN827_branch_metrics_3__0__9 B[8]=FE_OFN828_branch_metrics_3__0__8
+ B[7]=FE_OFN829_branch_metrics_3__0__7 B[6]=FE_OFN830_branch_metrics_3__0__6
+ B[5]=FE_OFN831_branch_metrics_3__0__5 B[4]=FE_OFN832_branch_metrics_3__0__4
+ B[3]=FE_OFN833_branch_metrics_3__0__3 B[2]=FE_OFN834_branch_metrics_3__0__2
+ B[1]=FE_OFN835_branch_metrics_3__0__1 B[0]=FE_OFN836_branch_metrics_3__0__0
+ CI=n1 SUM[11]=backward_sum[3][0][11] SUM[10]=backward_sum[3][0][10]
+ SUM[9]=backward_sum[3][0][9] SUM[8]=backward_sum[3][0][8]
+ SUM[7]=backward_sum[3][0][7] SUM[6]=backward_sum[3][0][6]
+ SUM[5]=backward_sum[3][0][5] SUM[4]=backward_sum[3][0][4]
+ SUM[3]=backward_sum[3][0][3] SUM[2]=backward_sum[3][0][2]
+ SUM[1]=backward_sum[3][0][1] SUM[0]=backward_sum[3][0][0]
+ FE_OFN193_backward_metrics_3__0__0=backward_metrics[3][0][0]
Xadd_103_G3 Siso_DW01_add_100 $PINS A[11]=FE_OFN1094_backward_metrics_2__3__11
+ A[10]=FE_OFN1095_backward_metrics_2__3__10
+ A[9]=FE_OFN1096_backward_metrics_2__3__9
+ A[8]=FE_OFN1097_backward_metrics_2__3__8
+ A[7]=FE_OFN1098_backward_metrics_2__3__7
+ A[6]=FE_OFN1099_backward_metrics_2__3__6
+ A[5]=FE_OFN1100_backward_metrics_2__3__5
+ A[4]=FE_OFN1101_backward_metrics_2__3__4
+ A[3]=FE_OFN1102_backward_metrics_2__3__3
+ A[2]=FE_OFN1103_backward_metrics_2__3__2
+ A[1]=FE_OFN1104_backward_metrics_2__3__1
+ A[0]=FE_OFN1105_backward_metrics_2__3__0
+ B[11]=FE_OFN909_branch_metrics_4__3__11 B[10]=FE_OFN910_branch_metrics_4__3__10
+ B[9]=FE_OFN911_branch_metrics_4__3__9 B[8]=FE_OFN912_branch_metrics_4__3__8
+ B[7]=branch_metrics[4][3][7] B[6]=FE_OFN914_branch_metrics_4__3__6
+ B[5]=FE_OFN915_branch_metrics_4__3__5 B[4]=FE_OFN916_branch_metrics_4__3__4
+ B[3]=FE_OFN917_branch_metrics_4__3__3 B[2]=FE_OFN918_branch_metrics_4__3__2
+ B[1]=FE_OFN919_branch_metrics_4__3__1 B[0]=FE_OFN920_branch_metrics_4__3__0
+ CI=n1 SUM[11]=backward_sum[2][7][11] SUM[10]=backward_sum[2][7][10]
+ SUM[9]=backward_sum[2][7][9] SUM[8]=backward_sum[2][7][8]
+ SUM[7]=backward_sum[2][7][7] SUM[6]=backward_sum[2][7][6]
+ SUM[5]=backward_sum[2][7][5] SUM[4]=backward_sum[2][7][4]
+ SUM[3]=backward_sum[2][7][3] SUM[2]=backward_sum[2][7][2]
+ SUM[1]=backward_sum[2][7][1] SUM[0]=backward_sum[2][7][0]
Xadd_102_G3 Siso_DW01_add_101 $PINS A[11]=backward_metrics[2][1][11]
+ A[10]=FE_OFN1071_backward_metrics_2__1__10
+ A[9]=FE_OFN1072_backward_metrics_2__1__9
+ A[8]=FE_OFN1073_backward_metrics_2__1__8
+ A[7]=FE_OFN1074_backward_metrics_2__1__7
+ A[6]=FE_OFN1075_backward_metrics_2__1__6
+ A[5]=FE_OFN1076_backward_metrics_2__1__5
+ A[4]=FE_OFN1077_backward_metrics_2__1__4
+ A[3]=FE_OFN1078_backward_metrics_2__1__3
+ A[2]=FE_OFN1079_backward_metrics_2__1__2
+ A[1]=FE_OFN1080_backward_metrics_2__1__1
+ A[0]=FE_OFN1081_backward_metrics_2__1__0
+ B[11]=FE_OFN897_branch_metrics_4__2__11 B[10]=FE_OFN898_branch_metrics_4__2__10
+ B[9]=FE_OFN899_branch_metrics_4__2__9 B[8]=FE_OFN900_branch_metrics_4__2__8
+ B[7]=FE_OFN901_branch_metrics_4__2__7 B[6]=FE_OFN902_branch_metrics_4__2__6
+ B[5]=FE_OFN903_branch_metrics_4__2__5 B[4]=FE_OFN904_branch_metrics_4__2__4
+ B[3]=FE_OFN905_branch_metrics_4__2__3 B[2]=FE_OFN906_branch_metrics_4__2__2
+ B[1]=FE_OFN907_branch_metrics_4__2__1 B[0]=FE_OFN3100_branch_metrics_4_2_0
+ CI=n1 SUM[11]=backward_sum[2][6][11] SUM[10]=backward_sum[2][6][10]
+ SUM[9]=backward_sum[2][6][9] SUM[8]=backward_sum[2][6][8]
+ SUM[7]=backward_sum[2][6][7] SUM[6]=backward_sum[2][6][6]
+ SUM[5]=backward_sum[2][6][5] SUM[4]=backward_sum[2][6][4]
+ SUM[3]=backward_sum[2][6][3] SUM[2]=backward_sum[2][6][2]
+ SUM[1]=backward_sum[2][6][1] SUM[0]=backward_sum[2][6][0]
Xadd_101_G3 Siso_DW01_add_102 $PINS A[11]=FE_OFN1094_backward_metrics_2__3__11
+ A[10]=FE_OFN1095_backward_metrics_2__3__10
+ A[9]=FE_OFN1096_backward_metrics_2__3__9
+ A[8]=FE_OFN1097_backward_metrics_2__3__8
+ A[7]=FE_OFN1098_backward_metrics_2__3__7
+ A[6]=FE_OFN1099_backward_metrics_2__3__6
+ A[5]=FE_OFN1100_backward_metrics_2__3__5
+ A[4]=FE_OFN1101_backward_metrics_2__3__4
+ A[3]=FE_OFN1102_backward_metrics_2__3__3
+ A[2]=FE_OFN1103_backward_metrics_2__3__2
+ A[1]=FE_OFN1104_backward_metrics_2__3__1
+ A[0]=FE_OFN1105_backward_metrics_2__3__0
+ B[11]=FE_OFN885_branch_metrics_4__1__11 B[10]=FE_OFN886_branch_metrics_4__1__10
+ B[9]=FE_OFN887_branch_metrics_4__1__9 B[8]=FE_OFN888_branch_metrics_4__1__8
+ B[7]=branch_metrics[4][1][7] B[6]=FE_OFN890_branch_metrics_4__1__6
+ B[5]=FE_OFN891_branch_metrics_4__1__5 B[4]=FE_OFN892_branch_metrics_4__1__4
+ B[3]=FE_OFN893_branch_metrics_4__1__3 B[2]=FE_OFN894_branch_metrics_4__1__2
+ B[1]=FE_OFN895_branch_metrics_4__1__1 B[0]=FE_OFN896_branch_metrics_4__1__0
+ CI=n1 SUM[11]=backward_sum[2][5][11] SUM[10]=backward_sum[2][5][10]
+ SUM[9]=backward_sum[2][5][9] SUM[8]=backward_sum[2][5][8]
+ SUM[7]=backward_sum[2][5][7] SUM[6]=backward_sum[2][5][6]
+ SUM[5]=backward_sum[2][5][5] SUM[4]=backward_sum[2][5][4]
+ SUM[3]=backward_sum[2][5][3] SUM[2]=backward_sum[2][5][2]
+ SUM[1]=backward_sum[2][5][1] SUM[0]=backward_sum[2][5][0]
Xadd_100_G3 Siso_DW01_add_103 $PINS A[11]=backward_metrics[2][1][11]
+ A[10]=FE_OFN1071_backward_metrics_2__1__10
+ A[9]=FE_OFN1072_backward_metrics_2__1__9
+ A[8]=FE_OFN1073_backward_metrics_2__1__8
+ A[7]=FE_OFN1074_backward_metrics_2__1__7
+ A[6]=FE_OFN1075_backward_metrics_2__1__6
+ A[5]=FE_OFN1076_backward_metrics_2__1__5
+ A[4]=FE_OFN1077_backward_metrics_2__1__4
+ A[3]=FE_OFN1078_backward_metrics_2__1__3
+ A[2]=FE_OFN1079_backward_metrics_2__1__2
+ A[1]=FE_OFN1080_backward_metrics_2__1__1
+ A[0]=FE_OFN1081_backward_metrics_2__1__0 B[11]=branch_metrics[4][0][11]
+ B[10]=FE_OFN874_branch_metrics_4__0__10 B[9]=FE_OFN875_branch_metrics_4__0__9
+ B[8]=FE_OFN876_branch_metrics_4__0__8 B[7]=FE_OFN877_branch_metrics_4__0__7
+ B[6]=FE_OFN878_branch_metrics_4__0__6 B[5]=FE_OFN879_branch_metrics_4__0__5
+ B[4]=FE_OFN880_branch_metrics_4__0__4 B[3]=FE_OFN881_branch_metrics_4__0__3
+ B[2]=branch_metrics[4][0][2] B[1]=FE_OFN5657_branch_metrics_4__0__1
+ B[0]=FE_OFN5641_branch_metrics_4__0__0 CI=n1 SUM[11]=backward_sum[2][4][11]
+ SUM[10]=backward_sum[2][4][10] SUM[9]=backward_sum[2][4][9]
+ SUM[8]=backward_sum[2][4][8] SUM[7]=backward_sum[2][4][7]
+ SUM[6]=backward_sum[2][4][6] SUM[5]=backward_sum[2][4][5]
+ SUM[4]=backward_sum[2][4][4] SUM[3]=backward_sum[2][4][3]
+ SUM[2]=backward_sum[2][4][2] SUM[1]=backward_sum[2][4][1]
+ SUM[0]=backward_sum[2][4][0]
Xadd_99_G3 Siso_DW01_add_104 $PINS A[11]=FE_OFN1082_backward_metrics_2__2__11
+ A[10]=FE_OFN1083_backward_metrics_2__2__10
+ A[9]=FE_OFN1084_backward_metrics_2__2__9
+ A[8]=FE_OFN1085_backward_metrics_2__2__8
+ A[7]=FE_OFN1086_backward_metrics_2__2__7
+ A[6]=FE_OFN1087_backward_metrics_2__2__6
+ A[5]=FE_OFN1088_backward_metrics_2__2__5
+ A[4]=FE_OFN1089_backward_metrics_2__2__4
+ A[3]=FE_OFN1090_backward_metrics_2__2__3 A[2]=backward_metrics[2][2][2]
+ A[1]=FE_OFN1092_backward_metrics_2__2__1
+ A[0]=FE_OFN1093_backward_metrics_2__2__0
+ B[11]=FE_OFN909_branch_metrics_4__3__11 B[10]=branch_metrics[4][3][10]
+ B[9]=FE_OFN911_branch_metrics_4__3__9 B[8]=FE_OFN912_branch_metrics_4__3__8
+ B[7]=FE_OFN913_branch_metrics_4__3__7 B[6]=FE_OFN914_branch_metrics_4__3__6
+ B[5]=FE_OFN915_branch_metrics_4__3__5 B[4]=FE_OFN916_branch_metrics_4__3__4
+ B[3]=FE_OFN917_branch_metrics_4__3__3 B[2]=FE_OFN918_branch_metrics_4__3__2
+ B[1]=FE_OFN919_branch_metrics_4__3__1 B[0]=FE_OFN920_branch_metrics_4__3__0
+ CI=n1 SUM[11]=backward_sum[2][3][11] SUM[10]=backward_sum[2][3][10]
+ SUM[9]=backward_sum[2][3][9] SUM[8]=backward_sum[2][3][8]
+ SUM[7]=backward_sum[2][3][7] SUM[6]=backward_sum[2][3][6]
+ SUM[5]=backward_sum[2][3][5] SUM[4]=backward_sum[2][3][4]
+ SUM[3]=backward_sum[2][3][3] SUM[2]=backward_sum[2][3][2]
+ SUM[1]=backward_sum[2][3][1] SUM[0]=backward_sum[2][3][0]
Xadd_98_G3 Siso_DW01_add_105 $PINS A[11]=backward_metrics[2][0][11]
+ A[10]=FE_OFN1059_backward_metrics_2__0__10
+ A[9]=FE_OFN1060_backward_metrics_2__0__9
+ A[8]=FE_OFN1061_backward_metrics_2__0__8
+ A[7]=FE_OFN1062_backward_metrics_2__0__7
+ A[6]=FE_OFN1063_backward_metrics_2__0__6 A[5]=backward_metrics[2][0][5]
+ A[4]=FE_OFN1065_backward_metrics_2__0__4
+ A[3]=FE_OFN1066_backward_metrics_2__0__3
+ A[2]=FE_OFN1067_backward_metrics_2__0__2
+ A[1]=FE_OFN1068_backward_metrics_2__0__1
+ A[0]=FE_OFN1069_backward_metrics_2__0__0
+ B[11]=FE_OFN897_branch_metrics_4__2__11 B[10]=FE_OFN898_branch_metrics_4__2__10
+ B[9]=FE_OFN899_branch_metrics_4__2__9 B[8]=FE_OFN900_branch_metrics_4__2__8
+ B[7]=FE_OFN901_branch_metrics_4__2__7 B[6]=FE_OFN902_branch_metrics_4__2__6
+ B[5]=branch_metrics[4][2][5] B[4]=FE_OFN904_branch_metrics_4__2__4
+ B[3]=FE_OFN905_branch_metrics_4__2__3 B[2]=FE_OFN906_branch_metrics_4__2__2
+ B[1]=FE_OFN907_branch_metrics_4__2__1 B[0]=FE_OFN3100_branch_metrics_4_2_0
+ CI=n1 SUM[11]=backward_sum[2][2][11] SUM[10]=backward_sum[2][2][10]
+ SUM[9]=backward_sum[2][2][9] SUM[8]=backward_sum[2][2][8]
+ SUM[7]=backward_sum[2][2][7] SUM[6]=backward_sum[2][2][6]
+ SUM[5]=backward_sum[2][2][5] SUM[4]=backward_sum[2][2][4]
+ SUM[3]=backward_sum[2][2][3] SUM[2]=backward_sum[2][2][2]
+ SUM[1]=backward_sum[2][2][1] SUM[0]=backward_sum[2][2][0]
Xadd_97_G3 Siso_DW01_add_106 $PINS A[11]=FE_OFN1082_backward_metrics_2__2__11
+ A[10]=FE_OFN1083_backward_metrics_2__2__10
+ A[9]=FE_OFN1084_backward_metrics_2__2__9
+ A[8]=FE_OFN1085_backward_metrics_2__2__8
+ A[7]=FE_OFN1086_backward_metrics_2__2__7
+ A[6]=FE_OFN1087_backward_metrics_2__2__6
+ A[5]=FE_OFN1088_backward_metrics_2__2__5
+ A[4]=FE_OFN1089_backward_metrics_2__2__4
+ A[3]=FE_OFN1090_backward_metrics_2__2__3
+ A[2]=FE_OFN1091_backward_metrics_2__2__2
+ A[1]=FE_OFN1092_backward_metrics_2__2__1
+ A[0]=FE_OFN1093_backward_metrics_2__2__0
+ B[11]=FE_OFN885_branch_metrics_4__1__11 B[10]=FE_OFN886_branch_metrics_4__1__10
+ B[9]=FE_OFN887_branch_metrics_4__1__9 B[8]=FE_OFN888_branch_metrics_4__1__8
+ B[7]=FE_OFN889_branch_metrics_4__1__7 B[6]=FE_OFN890_branch_metrics_4__1__6
+ B[5]=FE_OFN891_branch_metrics_4__1__5 B[4]=FE_OFN892_branch_metrics_4__1__4
+ B[3]=FE_OFN893_branch_metrics_4__1__3 B[2]=FE_OFN894_branch_metrics_4__1__2
+ B[1]=FE_OFN895_branch_metrics_4__1__1 B[0]=FE_OFN896_branch_metrics_4__1__0
+ CI=n1 SUM[11]=backward_sum[2][1][11] SUM[10]=backward_sum[2][1][10]
+ SUM[9]=backward_sum[2][1][9] SUM[8]=backward_sum[2][1][8]
+ SUM[7]=backward_sum[2][1][7] SUM[6]=backward_sum[2][1][6]
+ SUM[5]=backward_sum[2][1][5] SUM[4]=backward_sum[2][1][4]
+ SUM[3]=backward_sum[2][1][3] SUM[2]=backward_sum[2][1][2]
+ SUM[1]=backward_sum[2][1][1] SUM[0]=backward_sum[2][1][0]
Xadd_96_G3 Siso_DW01_add_107 $PINS A[11]=backward_metrics[2][0][11]
+ A[10]=FE_OFN1059_backward_metrics_2__0__10
+ A[9]=FE_OFN1060_backward_metrics_2__0__9
+ A[8]=FE_OFN1061_backward_metrics_2__0__8
+ A[7]=FE_OFN1062_backward_metrics_2__0__7
+ A[6]=FE_OFN1063_backward_metrics_2__0__6 A[5]=backward_metrics[2][0][5]
+ A[4]=FE_OFN1065_backward_metrics_2__0__4
+ A[3]=FE_OFN1066_backward_metrics_2__0__3
+ A[2]=FE_OFN1067_backward_metrics_2__0__2
+ A[1]=FE_OFN1068_backward_metrics_2__0__1
+ A[0]=FE_OFN1069_backward_metrics_2__0__0 B[11]=branch_metrics[4][0][11]
+ B[10]=FE_OFN874_branch_metrics_4__0__10 B[9]=FE_OFN875_branch_metrics_4__0__9
+ B[8]=FE_OFN876_branch_metrics_4__0__8 B[7]=FE_OFN877_branch_metrics_4__0__7
+ B[6]=FE_OFN878_branch_metrics_4__0__6 B[5]=FE_OFN879_branch_metrics_4__0__5
+ B[4]=FE_OFN880_branch_metrics_4__0__4 B[3]=FE_OFN881_branch_metrics_4__0__3
+ B[2]=FE_OFN882_branch_metrics_4__0__2 B[1]=FE_OFN5657_branch_metrics_4__0__1
+ B[0]=FE_OFN5641_branch_metrics_4__0__0 CI=n1 SUM[11]=backward_sum[2][0][11]
+ SUM[10]=backward_sum[2][0][10] SUM[9]=backward_sum[2][0][9]
+ SUM[8]=backward_sum[2][0][8] SUM[7]=backward_sum[2][0][7]
+ SUM[6]=backward_sum[2][0][6] SUM[5]=backward_sum[2][0][5]
+ SUM[4]=backward_sum[2][0][4] SUM[3]=backward_sum[2][0][3]
+ SUM[2]=backward_sum[2][0][2] SUM[1]=backward_sum[2][0][1]
+ SUM[0]=backward_sum[2][0][0]
Xadd_103_G2 Siso_DW01_add_124 $PINS A[11]=FE_OFN1046_backward_metrics_1__3__11
+ A[10]=FE_OFN1047_backward_metrics_1__3__10
+ A[9]=FE_OFN1048_backward_metrics_1__3__9
+ A[8]=FE_OFN1049_backward_metrics_1__3__8
+ A[7]=FE_OFN1050_backward_metrics_1__3__7
+ A[6]=FE_OFN1051_backward_metrics_1__3__6
+ A[5]=FE_OFN1052_backward_metrics_1__3__5
+ A[4]=FE_OFN1053_backward_metrics_1__3__4
+ A[3]=FE_OFN1054_backward_metrics_1__3__3
+ A[2]=FE_OFN1055_backward_metrics_1__3__2
+ A[1]=FE_OFN1056_backward_metrics_1__3__1 A[0]=backward_metrics[1][3][0]
+ B[11]=branch_metrics[5][3][11] B[10]=FE_OFN957_branch_metrics_5__3__10
+ B[9]=FE_OFN958_branch_metrics_5__3__9 B[8]=FE_OFN959_branch_metrics_5__3__8
+ B[7]=branch_metrics[5][3][7] B[6]=FE_OFN961_branch_metrics_5__3__6
+ B[5]=FE_OFN962_branch_metrics_5__3__5 B[4]=branch_metrics[5][3][4]
+ B[3]=FE_OFN964_branch_metrics_5__3__3 B[2]=branch_metrics[5][3][2]
+ B[1]=branch_metrics[5][3][1] B[0]=branch_metrics[5][3][0] CI=n1
+ SUM[11]=backward_sum[1][7][11] SUM[10]=backward_sum[1][7][10]
+ SUM[9]=backward_sum[1][7][9] SUM[8]=backward_sum[1][7][8]
+ SUM[7]=backward_sum[1][7][7] SUM[6]=backward_sum[1][7][6]
+ SUM[5]=backward_sum[1][7][5] SUM[4]=backward_sum[1][7][4]
+ SUM[3]=backward_sum[1][7][3] SUM[2]=backward_sum[1][7][2]
+ SUM[1]=backward_sum[1][7][1] SUM[0]=backward_sum[1][7][0]
Xadd_102_G2 Siso_DW01_add_125 $PINS A[11]=backward_metrics[1][1][11]
+ A[10]=FE_OFN1023_backward_metrics_1__1__10 A[9]=backward_metrics[1][1][9]
+ A[8]=FE_OFN1025_backward_metrics_1__1__8
+ A[7]=FE_OFN1026_backward_metrics_1__1__7
+ A[6]=FE_OFN1027_backward_metrics_1__1__6
+ A[5]=FE_OFN1028_backward_metrics_1__1__5
+ A[4]=FE_OFN1029_backward_metrics_1__1__4
+ A[3]=FE_OFN1030_backward_metrics_1__1__3
+ A[2]=FE_OFN1031_backward_metrics_1__1__2
+ A[1]=FE_OFN1032_backward_metrics_1__1__1 A[0]=backward_metrics[1][1][0]
+ B[11]=FE_OFN944_branch_metrics_5__2__11 B[10]=FE_OFN945_branch_metrics_5__2__10
+ B[9]=branch_metrics[5][2][9] B[8]=FE_OFN947_branch_metrics_5__2__8
+ B[7]=FE_OFN948_branch_metrics_5__2__7 B[6]=branch_metrics[5][2][6]
+ B[5]=FE_OFN950_branch_metrics_5__2__5 B[4]=FE_OFN951_branch_metrics_5__2__4
+ B[3]=FE_OFN952_branch_metrics_5__2__3 B[2]=FE_OFN953_branch_metrics_5__2__2
+ B[1]=FE_OFN954_branch_metrics_5__2__1 B[0]=FE_OFN955_branch_metrics_5__2__0
+ CI=n1 SUM[11]=backward_sum[1][6][11] SUM[10]=backward_sum[1][6][10]
+ SUM[9]=backward_sum[1][6][9] SUM[8]=backward_sum[1][6][8]
+ SUM[7]=backward_sum[1][6][7] SUM[6]=backward_sum[1][6][6]
+ SUM[5]=backward_sum[1][6][5] SUM[4]=backward_sum[1][6][4]
+ SUM[3]=backward_sum[1][6][3] SUM[2]=backward_sum[1][6][2]
+ SUM[1]=backward_sum[1][6][1] SUM[0]=backward_sum[1][6][0]
+ FE_OFN243_backward_metrics_1__1__0=FE_OFN5642_backward_metrics_1__1__0
Xadd_101_G2 Siso_DW01_add_126 $PINS A[11]=FE_OFN1046_backward_metrics_1__3__11
+ A[10]=FE_OFN1047_backward_metrics_1__3__10
+ A[9]=FE_OFN1048_backward_metrics_1__3__9
+ A[8]=FE_OFN1049_backward_metrics_1__3__8
+ A[7]=FE_OFN1050_backward_metrics_1__3__7
+ A[6]=FE_OFN1051_backward_metrics_1__3__6
+ A[5]=FE_OFN1052_backward_metrics_1__3__5
+ A[4]=FE_OFN1053_backward_metrics_1__3__4
+ A[3]=FE_OFN1054_backward_metrics_1__3__3
+ A[2]=FE_OFN1055_backward_metrics_1__3__2
+ A[1]=FE_OFN1056_backward_metrics_1__3__1 A[0]=backward_metrics[1][3][0]
+ B[11]=branch_metrics[5][1][11] B[10]=FE_OFN934_branch_metrics_5__1__10
+ B[9]=FE_OFN935_branch_metrics_5__1__9 B[8]=FE_OFN936_branch_metrics_5__1__8
+ B[7]=FE_OFN937_branch_metrics_5__1__7 B[6]=FE_OFN938_branch_metrics_5__1__6
+ B[5]=FE_OFN939_branch_metrics_5__1__5 B[4]=FE_OFN940_branch_metrics_5__1__4
+ B[3]=FE_OFN941_branch_metrics_5__1__3 B[2]=FE_OFN942_branch_metrics_5__1__2
+ B[1]=FE_OFN943_branch_metrics_5__1__1 B[0]=n1434 CI=n1
+ SUM[11]=backward_sum[1][5][11] SUM[10]=backward_sum[1][5][10]
+ SUM[9]=backward_sum[1][5][9] SUM[8]=backward_sum[1][5][8]
+ SUM[7]=backward_sum[1][5][7] SUM[6]=backward_sum[1][5][6]
+ SUM[5]=backward_sum[1][5][5] SUM[4]=backward_sum[1][5][4]
+ SUM[3]=backward_sum[1][5][3] SUM[2]=backward_sum[1][5][2]
+ SUM[1]=backward_sum[1][5][1] SUM[0]=backward_sum[1][5][0]
Xadd_100_G2 Siso_DW01_add_127 $PINS A[11]=backward_metrics[1][1][11]
+ A[10]=FE_OFN1023_backward_metrics_1__1__10
+ A[9]=FE_OFN1024_backward_metrics_1__1__9 A[8]=backward_metrics[1][1][8]
+ A[7]=FE_OFN1026_backward_metrics_1__1__7 A[6]=backward_metrics[1][1][6]
+ A[5]=FE_OFN1028_backward_metrics_1__1__5
+ A[4]=FE_OFN1029_backward_metrics_1__1__4
+ A[3]=FE_OFN1030_backward_metrics_1__1__3
+ A[2]=FE_OFN1031_backward_metrics_1__1__2
+ A[1]=FE_OFN1032_backward_metrics_1__1__1 A[0]=backward_metrics[1][1][0]
+ B[11]=branch_metrics[5][0][11] B[10]=branch_metrics[5][0][10]
+ B[9]=FE_OFN923_branch_metrics_5__0__9 B[8]=branch_metrics[5][0][8]
+ B[7]=FE_OFN925_branch_metrics_5__0__7 B[6]=FE_OFN926_branch_metrics_5__0__6
+ B[5]=FE_OFN927_branch_metrics_5__0__5 B[4]=FE_OFN5658_branch_metrics_5__0__4
+ B[3]=FE_OFN929_branch_metrics_5__0__3 B[2]=branch_metrics[5][0][2]
+ B[1]=FE_OFN931_branch_metrics_5__0__1 B[0]=FE_OFN932_branch_metrics_5__0__0
+ CI=n1 SUM[11]=backward_sum[1][4][11] SUM[10]=backward_sum[1][4][10]
+ SUM[9]=backward_sum[1][4][9] SUM[8]=backward_sum[1][4][8]
+ SUM[7]=backward_sum[1][4][7] SUM[6]=backward_sum[1][4][6]
+ SUM[5]=backward_sum[1][4][5] SUM[4]=backward_sum[1][4][4]
+ SUM[3]=backward_sum[1][4][3] SUM[2]=backward_sum[1][4][2]
+ SUM[1]=backward_sum[1][4][1] SUM[0]=backward_sum[1][4][0]
+ FE_OFN230_backward_metrics_1__1__0=backward_metrics[1][1][0]
+ FE_OFN244_backward_metrics_1__1__0=FE_OFN5642_backward_metrics_1__1__0
Xadd_99_G2 Siso_DW01_add_128 $PINS A[11]=FE_OFN1034_backward_metrics_1__2__11
+ A[10]=FE_OFN1035_backward_metrics_1__2__10
+ A[9]=FE_OFN1036_backward_metrics_1__2__9
+ A[8]=FE_OFN1037_backward_metrics_1__2__8
+ A[7]=FE_OFN1038_backward_metrics_1__2__7
+ A[6]=FE_OFN1039_backward_metrics_1__2__6
+ A[5]=FE_OFN1040_backward_metrics_1__2__5
+ A[4]=FE_OFN1041_backward_metrics_1__2__4
+ A[3]=FE_OFN1042_backward_metrics_1__2__3
+ A[2]=FE_OFN1043_backward_metrics_1__2__2
+ A[1]=FE_OFN1044_backward_metrics_1__2__1
+ A[0]=FE_OFN1045_backward_metrics_1__2__0 B[11]=branch_metrics[5][3][11]
+ B[10]=FE_OFN957_branch_metrics_5__3__10 B[9]=FE_OFN958_branch_metrics_5__3__9
+ B[8]=FE_OFN959_branch_metrics_5__3__8 B[7]=FE_OFN960_branch_metrics_5__3__7
+ B[6]=FE_OFN961_branch_metrics_5__3__6 B[5]=FE_OFN962_branch_metrics_5__3__5
+ B[4]=branch_metrics[5][3][4] B[3]=FE_OFN964_branch_metrics_5__3__3
+ B[2]=FE_OFN965_branch_metrics_5__3__2 B[1]=FE_OFN966_branch_metrics_5__3__1
+ B[0]=FE_OFN967_branch_metrics_5__3__0 CI=n1 SUM[11]=backward_sum[1][3][11]
+ SUM[10]=backward_sum[1][3][10] SUM[9]=backward_sum[1][3][9]
+ SUM[8]=backward_sum[1][3][8] SUM[7]=backward_sum[1][3][7]
+ SUM[6]=backward_sum[1][3][6] SUM[5]=backward_sum[1][3][5]
+ SUM[4]=backward_sum[1][3][4] SUM[3]=backward_sum[1][3][3]
+ SUM[2]=backward_sum[1][3][2] SUM[1]=backward_sum[1][3][1]
+ SUM[0]=backward_sum[1][3][0]
+ FE_OFN189_backward_metrics_1__2__0=backward_metrics[1][2][0]
Xadd_98_G2 Siso_DW01_add_129 $PINS A[11]=backward_metrics[1][0][11]
+ A[10]=backward_metrics[1][0][10] A[9]=backward_metrics[1][0][9]
+ A[8]=FE_OFN1013_backward_metrics_1__0__8
+ A[7]=FE_OFN1014_backward_metrics_1__0__7
+ A[6]=FE_OFN1015_backward_metrics_1__0__6
+ A[5]=FE_OFN1016_backward_metrics_1__0__5
+ A[4]=FE_OFN1017_backward_metrics_1__0__4
+ A[3]=FE_OFN1018_backward_metrics_1__0__3
+ A[2]=FE_OFN1019_backward_metrics_1__0__2
+ A[1]=FE_OFN1020_backward_metrics_1__0__1 A[0]=backward_metrics[1][0][0]
+ B[11]=FE_OFN944_branch_metrics_5__2__11 B[10]=FE_OFN945_branch_metrics_5__2__10
+ B[9]=branch_metrics[5][2][9] B[8]=FE_OFN947_branch_metrics_5__2__8
+ B[7]=FE_OFN948_branch_metrics_5__2__7 B[6]=branch_metrics[5][2][6]
+ B[5]=FE_OFN950_branch_metrics_5__2__5 B[4]=FE_OFN951_branch_metrics_5__2__4
+ B[3]=FE_OFN952_branch_metrics_5__2__3 B[2]=FE_OFN953_branch_metrics_5__2__2
+ B[1]=FE_OFN954_branch_metrics_5__2__1 B[0]=FE_OFN955_branch_metrics_5__2__0
+ CI=n1 SUM[11]=backward_sum[1][2][11] SUM[10]=backward_sum[1][2][10]
+ SUM[9]=backward_sum[1][2][9] SUM[8]=backward_sum[1][2][8]
+ SUM[7]=backward_sum[1][2][7] SUM[6]=backward_sum[1][2][6]
+ SUM[5]=backward_sum[1][2][5] SUM[4]=backward_sum[1][2][4]
+ SUM[3]=backward_sum[1][2][3] SUM[2]=backward_sum[1][2][2]
+ SUM[1]=backward_sum[1][2][1] SUM[0]=backward_sum[1][2][0]
+ FE_OFN187_backward_metrics_1__0__0=FE_OFN1021_backward_metrics_1__0__0
Xadd_97_G2 Siso_DW01_add_130 $PINS A[11]=FE_OFN1034_backward_metrics_1__2__11
+ A[10]=FE_OFN1035_backward_metrics_1__2__10
+ A[9]=FE_OFN1036_backward_metrics_1__2__9
+ A[8]=FE_OFN1037_backward_metrics_1__2__8
+ A[7]=FE_OFN1038_backward_metrics_1__2__7
+ A[6]=FE_OFN1039_backward_metrics_1__2__6
+ A[5]=FE_OFN1040_backward_metrics_1__2__5
+ A[4]=FE_OFN1041_backward_metrics_1__2__4
+ A[3]=FE_OFN1042_backward_metrics_1__2__3
+ A[2]=FE_OFN1043_backward_metrics_1__2__2
+ A[1]=FE_OFN1044_backward_metrics_1__2__1
+ A[0]=FE_OFN1045_backward_metrics_1__2__0 B[11]=branch_metrics[5][1][11]
+ B[10]=FE_OFN934_branch_metrics_5__1__10 B[9]=FE_OFN935_branch_metrics_5__1__9
+ B[8]=FE_OFN936_branch_metrics_5__1__8 B[7]=FE_OFN937_branch_metrics_5__1__7
+ B[6]=FE_OFN938_branch_metrics_5__1__6 B[5]=FE_OFN939_branch_metrics_5__1__5
+ B[4]=FE_OFN940_branch_metrics_5__1__4 B[3]=FE_OFN941_branch_metrics_5__1__3
+ B[2]=FE_OFN942_branch_metrics_5__1__2 B[1]=FE_OFN943_branch_metrics_5__1__1
+ B[0]=FE_OFN1359_n1434 CI=n1 SUM[11]=backward_sum[1][1][11]
+ SUM[10]=backward_sum[1][1][10] SUM[9]=backward_sum[1][1][9]
+ SUM[8]=backward_sum[1][1][8] SUM[7]=backward_sum[1][1][7]
+ SUM[6]=backward_sum[1][1][6] SUM[5]=backward_sum[1][1][5]
+ SUM[4]=backward_sum[1][1][4] SUM[3]=backward_sum[1][1][3]
+ SUM[2]=backward_sum[1][1][2] SUM[1]=backward_sum[1][1][1]
+ SUM[0]=backward_sum[1][1][0]
Xadd_96_G2 Siso_DW01_add_131 $PINS A[11]=backward_metrics[1][0][11]
+ A[10]=backward_metrics[1][0][10] A[9]=backward_metrics[1][0][9]
+ A[8]=FE_OFN1013_backward_metrics_1__0__8
+ A[7]=FE_OFN1014_backward_metrics_1__0__7
+ A[6]=FE_OFN1015_backward_metrics_1__0__6
+ A[5]=FE_OFN1016_backward_metrics_1__0__5
+ A[4]=FE_OFN1017_backward_metrics_1__0__4
+ A[3]=FE_OFN1018_backward_metrics_1__0__3
+ A[2]=FE_OFN1019_backward_metrics_1__0__2
+ A[1]=FE_OFN1020_backward_metrics_1__0__1
+ A[0]=FE_OFN1021_backward_metrics_1__0__0 B[11]=branch_metrics[5][0][11]
+ B[10]=branch_metrics[5][0][10] B[9]=FE_OFN923_branch_metrics_5__0__9
+ B[8]=branch_metrics[5][0][8] B[7]=FE_OFN925_branch_metrics_5__0__7
+ B[6]=branch_metrics[5][0][6] B[5]=branch_metrics[5][0][5]
+ B[4]=FE_OFN5658_branch_metrics_5__0__4 B[3]=FE_OFN929_branch_metrics_5__0__3
+ B[2]=FE_OFN930_branch_metrics_5__0__2 B[1]=FE_OFN931_branch_metrics_5__0__1
+ B[0]=FE_OFN932_branch_metrics_5__0__0 CI=n1 SUM[11]=backward_sum[1][0][11]
+ SUM[10]=backward_sum[1][0][10] SUM[9]=backward_sum[1][0][9]
+ SUM[8]=backward_sum[1][0][8] SUM[7]=backward_sum[1][0][7]
+ SUM[6]=backward_sum[1][0][6] SUM[5]=backward_sum[1][0][5]
+ SUM[4]=backward_sum[1][0][4] SUM[3]=backward_sum[1][0][3]
+ SUM[2]=backward_sum[1][0][2] SUM[1]=backward_sum[1][0][1]
+ SUM[0]=backward_sum[1][0][0]
Xsub_236 Siso_DW01_sub_6 $PINS A[11]=N2932 A[10]=N2931 A[9]=N2930 A[8]=N2929
+ A[7]=N2928 A[6]=N2927 A[5]=N2926 A[4]=N2925 A[3]=N2924 A[2]=N2923 A[1]=N2922
+ A[0]=N2921 B[11]=N2974 B[10]=N2973 B[9]=N2972 B[8]=N2971 B[7]=N2970 B[6]=N2969
+ B[5]=N2968 B[4]=N2967 B[3]=N2966 B[2]=N2965 B[1]=N2964 B[0]=N2963 CI=n1
+ DIFF[11]=N2986 DIFF[10]=N2985 DIFF[9]=N2984 DIFF[8]=N2983 DIFF[7]=N2982
+ DIFF[6]=N2981 DIFF[5]=N2980 DIFF[4]=N2979 DIFF[3]=N2978 DIFF[2]=N2977
+ DIFF[1]=N2976 DIFF[0]=N2975
Xadd_94_G7 Siso_DW01_add_240 $PINS A[11]=forward_metrics[6][3][11]
+ A[10]=forward_metrics[6][3][10] A[9]=forward_metrics[6][3][9]
+ A[8]=forward_metrics[6][3][8] A[7]=forward_metrics[6][3][7]
+ A[6]=forward_metrics[6][3][6] A[5]=forward_metrics[6][3][5]
+ A[4]=forward_metrics[6][3][4] A[3]=forward_metrics[6][3][3]
+ A[2]=forward_metrics[6][3][2] A[1]=forward_metrics[6][3][1]
+ A[0]=forward_metrics[6][3][0] B[11]=branch_metrics[6][3][11]
+ B[10]=FE_OFN969_branch_metrics_6__3__10 B[9]=backward_sum[0][3][9]
+ B[8]=backward_sum[0][3][8] B[7]=backward_sum[0][3][7]
+ B[6]=backward_sum[0][3][6] B[5]=backward_sum[0][3][5]
+ B[4]=backward_sum[0][3][4] B[3]=backward_sum[0][3][3]
+ B[2]=backward_sum[0][3][2] B[1]=backward_sum[0][3][1]
+ B[0]=backward_sum[0][3][0] CI=n1 SUM[11]=forward_sum[6][7][11]
+ SUM[10]=forward_sum[6][7][10] SUM[9]=LLR_sum[6][3][9] SUM[8]=LLR_sum[6][3][8]
+ SUM[7]=LLR_sum[6][3][7] SUM[6]=LLR_sum[6][3][6] SUM[5]=LLR_sum[6][3][5]
+ SUM[4]=LLR_sum[6][3][4] SUM[3]=LLR_sum[6][3][3] SUM[2]=LLR_sum[6][3][2]
+ SUM[1]=LLR_sum[6][3][1] SUM[0]=LLR_sum[6][3][0]
Xadd_89_G7 Siso_DW01_add_241 $PINS A[11]=forward_metrics[6][2][11]
+ A[10]=forward_metrics[6][2][10] A[9]=forward_metrics[6][2][9]
+ A[8]=forward_metrics[6][2][8] A[7]=forward_metrics[6][2][7]
+ A[6]=forward_metrics[6][2][6] A[5]=forward_metrics[6][2][5]
+ A[4]=forward_metrics[6][2][4] A[3]=forward_metrics[6][2][3]
+ A[2]=forward_metrics[6][2][2] A[1]=forward_metrics[6][2][1]
+ A[0]=forward_metrics[6][2][0] B[11]=FE_OFN1276_backward_sum_0__0__11
+ B[10]=FE_UNCONNECTED_2 B[9]=backward_sum[0][4][9] B[8]=backward_sum[0][4][8]
+ B[7]=backward_sum[0][4][7] B[6]=backward_sum[0][4][6]
+ B[5]=backward_sum[0][4][5] B[4]=backward_sum[0][4][4]
+ B[3]=backward_sum[0][4][3] B[2]=backward_sum[0][4][2]
+ B[1]=backward_sum[0][4][1] B[0]=backward_sum[0][4][0] CI=n1
+ SUM[11]=forward_sum[6][2][11] SUM[10]=forward_sum[6][2][10]
+ SUM[9]=LLR_sum[6][2][9] SUM[8]=LLR_sum[6][2][8] SUM[7]=LLR_sum[6][2][7]
+ SUM[6]=LLR_sum[6][2][6] SUM[5]=LLR_sum[6][2][5] SUM[4]=LLR_sum[6][2][4]
+ SUM[3]=LLR_sum[6][2][3] SUM[2]=LLR_sum[6][2][2] SUM[1]=LLR_sum[6][2][1]
+ SUM[0]=LLR_sum[6][2][0] _backward_sum_0_0_10=FE_OFN1277_backward_sum_0__0__10
Xadd_92_G7 Siso_DW01_add_242 $PINS A[11]=forward_metrics[6][1][11]
+ A[10]=forward_metrics[6][1][10] A[9]=forward_metrics[6][1][9]
+ A[8]=forward_metrics[6][1][8] A[7]=forward_metrics[6][1][7]
+ A[6]=forward_metrics[6][1][6] A[5]=forward_metrics[6][1][5]
+ A[4]=forward_metrics[6][1][4] A[3]=forward_metrics[6][1][3]
+ A[2]=forward_metrics[6][1][2] A[1]=forward_metrics[6][1][1]
+ A[0]=forward_metrics[6][1][0] B[11]=branch_metrics[6][3][11]
+ B[10]=FE_OFN969_branch_metrics_6__3__10 B[9]=backward_sum[0][3][9]
+ B[8]=backward_sum[0][3][8] B[7]=backward_sum[0][3][7]
+ B[6]=backward_sum[0][3][6] B[5]=backward_sum[0][3][5]
+ B[4]=backward_sum[0][3][4] B[3]=backward_sum[0][3][3]
+ B[2]=backward_sum[0][3][2] B[1]=backward_sum[0][3][1]
+ B[0]=backward_sum[0][3][0] CI=n1 SUM[11]=forward_sum[6][5][11]
+ SUM[10]=forward_sum[6][5][10] SUM[9]=LLR_sum[6][1][9] SUM[8]=LLR_sum[6][1][8]
+ SUM[7]=LLR_sum[6][1][7] SUM[6]=LLR_sum[6][1][6] SUM[5]=LLR_sum[6][1][5]
+ SUM[4]=LLR_sum[6][1][4] SUM[3]=LLR_sum[6][1][3] SUM[2]=LLR_sum[6][1][2]
+ SUM[1]=LLR_sum[6][1][1] SUM[0]=LLR_sum[6][1][0]
Xadd_93_G7 Siso_DW01_add_243 $PINS A[11]=forward_metrics[6][2][11]
+ A[10]=forward_metrics[6][2][10] A[9]=forward_metrics[6][2][9]
+ A[8]=forward_metrics[6][2][8] A[7]=forward_metrics[6][2][7]
+ A[6]=forward_metrics[6][2][6] A[5]=forward_metrics[6][2][5]
+ A[4]=forward_metrics[6][2][4] A[3]=forward_metrics[6][2][3]
+ A[2]=forward_metrics[6][2][2] A[1]=forward_metrics[6][2][1]
+ A[0]=forward_metrics[6][2][0] B[11]=branch_metrics[6][1][11]
+ B[10]=branch_metrics[6][1][10] B[9]=backward_sum[0][1][9]
+ B[8]=backward_sum[0][1][8] B[7]=backward_sum[0][1][7]
+ B[6]=backward_sum[0][1][6] B[5]=backward_sum[0][1][5]
+ B[4]=backward_sum[0][1][4] B[3]=backward_sum[0][1][3]
+ B[2]=backward_sum[0][1][2] B[1]=backward_sum[0][1][1]
+ B[0]=backward_sum[0][1][0] CI=n1 SUM[11]=forward_sum[6][6][11]
+ SUM[10]=forward_sum[6][6][10] SUM[9]=LLR_sum[6][6][9] SUM[8]=LLR_sum[6][6][8]
+ SUM[7]=LLR_sum[6][6][7] SUM[6]=LLR_sum[6][6][6] SUM[5]=LLR_sum[6][6][5]
+ SUM[4]=LLR_sum[6][6][4] SUM[3]=LLR_sum[6][6][3] SUM[2]=LLR_sum[6][6][2]
+ SUM[1]=LLR_sum[6][6][1] SUM[0]=LLR_sum[6][6][0]
Xadd_90_G7 Siso_DW01_add_244 $PINS A[11]=forward_metrics[6][3][11]
+ A[10]=forward_metrics[6][3][10] A[9]=forward_metrics[6][3][9]
+ A[8]=forward_metrics[6][3][8] A[7]=forward_metrics[6][3][7]
+ A[6]=forward_metrics[6][3][6] A[5]=forward_metrics[6][3][5]
+ A[4]=forward_metrics[6][3][4] A[3]=forward_metrics[6][3][3]
+ A[2]=forward_metrics[6][3][2] A[1]=forward_metrics[6][3][1]
+ A[0]=forward_metrics[6][3][0] B[11]=FE_OFN1278_backward_sum_0__2__11
+ B[10]=FE_UNCONNECTED_1 B[9]=backward_sum[0][6][9] B[8]=backward_sum[0][6][8]
+ B[7]=backward_sum[0][6][7] B[6]=backward_sum[0][6][6]
+ B[5]=backward_sum[0][6][5] B[4]=backward_sum[0][6][4]
+ B[3]=backward_sum[0][6][3] B[2]=backward_sum[0][6][2]
+ B[1]=backward_sum[0][6][1] B[0]=backward_sum[0][6][0] CI=n1
+ SUM[11]=forward_sum[6][3][11] SUM[10]=forward_sum[6][3][10]
+ SUM[9]=LLR_sum[6][7][9] SUM[8]=LLR_sum[6][7][8] SUM[7]=LLR_sum[6][7][7]
+ SUM[6]=LLR_sum[6][7][6] SUM[5]=LLR_sum[6][7][5] SUM[4]=LLR_sum[6][7][4]
+ SUM[3]=LLR_sum[6][7][3] SUM[2]=LLR_sum[6][7][2] SUM[1]=LLR_sum[6][7][1]
+ SUM[0]=LLR_sum[6][7][0] _backward_sum_0_2_10=FE_OFN1279_backward_sum_0__2__10
Xadd_91_G7 Siso_DW01_add_245 $PINS A[11]=forward_metrics[6][0][11]
+ A[10]=forward_metrics[6][0][10] A[9]=forward_metrics[6][0][9]
+ A[8]=forward_metrics[6][0][8] A[7]=forward_metrics[6][0][7]
+ A[6]=forward_metrics[6][0][6] A[5]=forward_metrics[6][0][5]
+ A[4]=forward_metrics[6][0][4] A[3]=forward_metrics[6][0][3]
+ A[2]=forward_metrics[6][0][2] A[1]=forward_metrics[6][0][1]
+ A[0]=forward_metrics[6][0][0] B[11]=branch_metrics[6][1][11]
+ B[10]=branch_metrics[6][1][10] B[9]=backward_sum[0][1][9]
+ B[8]=backward_sum[0][1][8] B[7]=backward_sum[0][1][7]
+ B[6]=backward_sum[0][1][6] B[5]=backward_sum[0][1][5]
+ B[4]=backward_sum[0][1][4] B[3]=backward_sum[0][1][3]
+ B[2]=backward_sum[0][1][2] B[1]=backward_sum[0][1][1]
+ B[0]=backward_sum[0][1][0] CI=n1 SUM[11]=forward_sum[6][4][11]
+ SUM[10]=forward_sum[6][4][10] SUM[9]=LLR_sum[6][4][9] SUM[8]=LLR_sum[6][4][8]
+ SUM[7]=LLR_sum[6][4][7] SUM[6]=LLR_sum[6][4][6] SUM[5]=LLR_sum[6][4][5]
+ SUM[4]=LLR_sum[6][4][4] SUM[3]=LLR_sum[6][4][3] SUM[2]=LLR_sum[6][4][2]
+ SUM[1]=LLR_sum[6][4][1] SUM[0]=LLR_sum[6][4][0]
Xr1490 Siso_DW01_add_246 $PINS A[11]=forward_sum[0][0][11]
+ A[10]=forward_sum[0][0][10] A[9]=FE_OFN980_forward_sum_0__2__9
+ A[8]=FE_OFN981_forward_sum_0__2__8 A[7]=forward_sum[0][2][7]
+ A[6]=forward_sum[0][2][6] A[5]=FE_OFN984_forward_sum_0__2__5
+ A[4]=FE_OFN985_forward_sum_0__2__4 A[3]=FE_OFN5659_forward_sum_0__2__3
+ A[2]=forward_sum[0][2][2] A[1]=FE_OFN988_forward_sum_0__2__1
+ A[0]=forward_sum[0][2][0] B[11]=backward_metrics[6][0][11]
+ B[10]=backward_metrics[6][0][10] B[9]=backward_metrics[6][0][9]
+ B[8]=backward_metrics[6][0][8] B[7]=backward_metrics[6][0][7]
+ B[6]=backward_metrics[6][0][6] B[5]=backward_metrics[6][0][5]
+ B[4]=backward_metrics[6][0][4] B[3]=backward_metrics[6][0][3]
+ B[2]=backward_metrics[6][0][2] B[1]=backward_metrics[6][0][1]
+ B[0]=FE_OFN1250_backward_metrics_6__0__0 CI=n1 SUM[11]=LLR_sum[0][0][11]
+ SUM[10]=LLR_sum[0][0][10] SUM[9]=LLR_sum[0][0][9] SUM[8]=LLR_sum[0][0][8]
+ SUM[7]=LLR_sum[0][0][7] SUM[6]=LLR_sum[0][0][6] SUM[5]=LLR_sum[0][0][5]
+ SUM[4]=LLR_sum[0][0][4] SUM[3]=LLR_sum[0][0][3] SUM[2]=LLR_sum[0][0][2]
+ SUM[1]=LLR_sum[0][0][1] SUM[0]=LLR_sum[0][0][0]
Xadd_108 Siso_DW01_add_247 $PINS A[11]=forward_sum[0][5][11]
+ A[10]=forward_sum[0][5][10] A[9]=forward_sum[0][5][9] A[8]=forward_sum[0][5][8]
+ A[7]=forward_sum[0][5][7] A[6]=forward_sum[0][5][6] A[5]=forward_sum[0][5][5]
+ A[4]=forward_sum[0][5][4] A[3]=forward_sum[0][5][3] A[2]=forward_sum[0][5][2]
+ A[1]=forward_sum[0][5][1] A[0]=forward_sum[0][5][0]
+ B[11]=FE_OFN1264_backward_metrics_6__3__11 B[10]=backward_metrics[6][3][10]
+ B[9]=FE_OFN1266_backward_metrics_6__3__9
+ B[8]=FE_OFN1267_backward_metrics_6__3__8 B[7]=backward_metrics[6][3][7]
+ B[6]=FE_OFN1269_backward_metrics_6__3__6 B[5]=backward_metrics[6][3][5]
+ B[4]=backward_metrics[6][3][4] B[3]=FE_OFN1272_backward_metrics_6__3__3
+ B[2]=backward_metrics[6][3][2] B[1]=FE_OFN1274_backward_metrics_6__3__1
+ B[0]=FE_OFN5547_backward_metrics_6__3__0 CI=n1 SUM[11]=LLR_sum[0][3][11]
+ SUM[10]=LLR_sum[0][3][10] SUM[9]=LLR_sum[0][3][9] SUM[8]=LLR_sum[0][3][8]
+ SUM[7]=LLR_sum[0][3][7] SUM[6]=LLR_sum[0][3][6] SUM[5]=LLR_sum[0][3][5]
+ SUM[4]=LLR_sum[0][3][4] SUM[3]=LLR_sum[0][3][3] SUM[2]=LLR_sum[0][3][2]
+ SUM[1]=LLR_sum[0][3][1] SUM[0]=LLR_sum[0][3][0]
+ FE_OFN178_forward_sum_0__5__9=FE_OFN990_forward_sum_0__5__9
+ FE_OFN179_forward_sum_0__5__8=FE_OFN991_forward_sum_0__5__8
+ FE_OFN180_forward_sum_0__5__7=FE_OFN992_forward_sum_0__5__7
+ FE_OFN181_forward_sum_0__5__4=FE_OFN995_forward_sum_0__5__4
+ FE_OFN182_forward_sum_0__5__3=FE_OFN996_forward_sum_0__5__3
Xadd_87_G7 Siso_DW01_add_248 $PINS A[11]=forward_metrics[6][0][11]
+ A[10]=forward_metrics[6][0][10] A[9]=forward_metrics[6][0][9]
+ A[8]=forward_metrics[6][0][8] A[7]=forward_metrics[6][0][7]
+ A[6]=forward_metrics[6][0][6] A[5]=forward_metrics[6][0][5]
+ A[4]=forward_metrics[6][0][4] A[3]=forward_metrics[6][0][3]
+ A[2]=forward_metrics[6][0][2] A[1]=forward_metrics[6][0][1]
+ A[0]=forward_metrics[6][0][0] B[11]=FE_OFN1276_backward_sum_0__0__11
+ B[10]=FE_OFN1277_backward_sum_0__0__10 B[9]=backward_sum[0][4][9]
+ B[8]=backward_sum[0][4][8] B[7]=backward_sum[0][4][7]
+ B[6]=backward_sum[0][4][6] B[5]=backward_sum[0][4][5]
+ B[4]=backward_sum[0][4][4] B[3]=backward_sum[0][4][3]
+ B[2]=backward_sum[0][4][2] B[1]=backward_sum[0][4][1]
+ B[0]=backward_sum[0][4][0] CI=n1 SUM[11]=LLR_sum[6][0][11]
+ SUM[10]=LLR_sum[6][0][10] SUM[9]=LLR_sum[6][0][9] SUM[8]=LLR_sum[6][0][8]
+ SUM[7]=LLR_sum[6][0][7] SUM[6]=LLR_sum[6][0][6] SUM[5]=LLR_sum[6][0][5]
+ SUM[4]=LLR_sum[6][0][4] SUM[3]=LLR_sum[6][0][3] SUM[2]=LLR_sum[6][0][2]
+ SUM[1]=LLR_sum[6][0][1] SUM[0]=LLR_sum[6][0][0]
Xadd_106 Siso_DW01_add_249 $PINS A[11]=forward_sum[0][5][11]
+ A[10]=forward_sum[0][5][10] A[9]=FE_OFN990_forward_sum_0__5__9
+ A[8]=FE_OFN991_forward_sum_0__5__8 A[7]=FE_OFN992_forward_sum_0__5__7
+ A[6]=FE_OFN993_forward_sum_0__5__6 A[5]=FE_OFN994_forward_sum_0__5__5
+ A[4]=FE_OFN995_forward_sum_0__5__4 A[3]=forward_sum[0][5][3]
+ A[2]=FE_OFN997_forward_sum_0__5__2 A[1]=FE_OFN998_forward_sum_0__5__1
+ A[0]=FE_OFN999_forward_sum_0__5__0 B[11]=backward_metrics[6][2][11]
+ B[10]=backward_metrics[6][2][10] B[9]=backward_metrics[6][2][9]
+ B[8]=backward_metrics[6][2][8] B[7]=backward_metrics[6][2][7]
+ B[6]=backward_metrics[6][2][6] B[5]=backward_metrics[6][2][5]
+ B[4]=backward_metrics[6][2][4] B[3]=backward_metrics[6][2][3]
+ B[2]=backward_metrics[6][2][2] B[1]=backward_metrics[6][2][1]
+ B[0]=backward_metrics[6][2][0] CI=n1 SUM[11]=LLR_sum[0][1][11]
+ SUM[10]=LLR_sum[0][1][10] SUM[9]=LLR_sum[0][1][9] SUM[8]=LLR_sum[0][1][8]
+ SUM[7]=LLR_sum[0][1][7] SUM[6]=LLR_sum[0][1][6] SUM[5]=LLR_sum[0][1][5]
+ SUM[4]=LLR_sum[0][1][4] SUM[3]=LLR_sum[0][1][3] SUM[2]=LLR_sum[0][1][2]
+ SUM[1]=LLR_sum[0][1][1] SUM[0]=LLR_sum[0][1][0]
Xadd_107 Siso_DW01_add_250 $PINS A[11]=forward_sum[0][2][11]
+ A[10]=forward_sum[0][2][10] A[9]=FE_OFN980_forward_sum_0__2__9
+ A[8]=FE_OFN981_forward_sum_0__2__8 A[7]=FE_OFN982_forward_sum_0__2__7
+ A[6]=FE_OFN983_forward_sum_0__2__6 A[5]=FE_OFN984_forward_sum_0__2__5
+ A[4]=FE_OFN985_forward_sum_0__2__4 A[3]=FE_OFN5659_forward_sum_0__2__3
+ A[2]=FE_OFN987_forward_sum_0__2__2 A[1]=FE_OFN988_forward_sum_0__2__1
+ A[0]=FE_OFN5651_forward_sum_0__2__0 B[11]=FE_OFN1251_backward_metrics_6__1__11
+ B[10]=FE_OFN1252_backward_metrics_6__1__10
+ B[9]=FE_OFN1253_backward_metrics_6__1__9
+ B[8]=FE_OFN1254_backward_metrics_6__1__8
+ B[7]=FE_OFN1255_backward_metrics_6__1__7
+ B[6]=FE_OFN1256_backward_metrics_6__1__6 B[5]=backward_metrics[6][1][5]
+ B[4]=FE_OFN1258_backward_metrics_6__1__4 B[3]=backward_metrics[6][1][3]
+ B[2]=backward_metrics[6][1][2] B[1]=backward_metrics[6][1][1]
+ B[0]=FE_OFN1262_backward_metrics_6__1__0 CI=n1 SUM[11]=LLR_sum[0][2][11]
+ SUM[10]=LLR_sum[0][2][10] SUM[9]=LLR_sum[0][2][9] SUM[8]=LLR_sum[0][2][8]
+ SUM[7]=LLR_sum[0][2][7] SUM[6]=LLR_sum[0][2][6] SUM[5]=LLR_sum[0][2][5]
+ SUM[4]=LLR_sum[0][2][4] SUM[3]=LLR_sum[0][2][3] SUM[2]=LLR_sum[0][2][2]
+ SUM[1]=LLR_sum[0][2][1] SUM[0]=LLR_sum[0][2][0]
+ FE_OFN221_backward_metrics_6__1__5=backward_metrics[6][1][5]
+ FE_OFN222_backward_metrics_6__1__3=FE_OFN1259_backward_metrics_6__1__3
+ FE_OFN232_backward_metrics_6__1__1=FE_OFN1261_backward_metrics_6__1__1
Xr1494 Siso_DW01_add_251 $PINS A[11]=forward_sum[0][4][11]
+ A[10]=forward_sum[0][4][10] A[9]=FE_OFN1000_forward_sum_0__6__9
+ A[8]=FE_OFN1001_forward_sum_0__6__8 A[7]=FE_OFN1002_forward_sum_0__6__7
+ A[6]=FE_OFN1003_forward_sum_0__6__6 A[5]=FE_OFN1004_forward_sum_0__6__5
+ A[4]=FE_OFN1005_forward_sum_0__6__4 A[3]=FE_OFN1006_forward_sum_0__6__3
+ A[2]=forward_sum[0][6][2] A[1]=forward_sum[0][6][1]
+ A[0]=FE_OFN1009_forward_sum_0__6__0 B[11]=backward_metrics[6][2][11]
+ B[10]=backward_metrics[6][2][10] B[9]=backward_metrics[6][2][9]
+ B[8]=backward_metrics[6][2][8] B[7]=backward_metrics[6][2][7]
+ B[6]=backward_metrics[6][2][6] B[5]=backward_metrics[6][2][5]
+ B[4]=backward_metrics[6][2][4] B[3]=backward_metrics[6][2][3]
+ B[2]=backward_metrics[6][2][2] B[1]=backward_metrics[6][2][1]
+ B[0]=backward_metrics[6][2][0] CI=n1 SUM[11]=LLR_sum[0][4][11]
+ SUM[10]=LLR_sum[0][4][10] SUM[9]=LLR_sum[0][4][9] SUM[8]=LLR_sum[0][4][8]
+ SUM[7]=LLR_sum[0][4][7] SUM[6]=LLR_sum[0][4][6] SUM[5]=LLR_sum[0][4][5]
+ SUM[4]=LLR_sum[0][4][4] SUM[3]=LLR_sum[0][4][3] SUM[2]=LLR_sum[0][4][2]
+ SUM[1]=LLR_sum[0][4][1] SUM[0]=LLR_sum[0][4][0]
+ FE_OFN246_backward_metrics_6__2__0=FE_OFN5663_backward_metrics_6__2__0
Xadd_112 Siso_DW01_add_252 $PINS A[11]=forward_sum[0][1][11]
+ A[10]=forward_sum[0][1][10] A[9]=forward_sum[0][1][9] A[8]=forward_sum[0][1][8]
+ A[7]=forward_sum[0][1][7] A[6]=forward_sum[0][1][6]
+ A[5]=FE_OFN974_forward_sum_0__1__5 A[4]=forward_sum[0][1][4]
+ A[3]=FE_OFN5648_forward_sum_0__1__3 A[2]=forward_sum[0][1][2]
+ A[1]=FE_OFN978_forward_sum_0__1__1 A[0]=FE_OFN979_forward_sum_0__1__0
+ B[11]=FE_OFN1251_backward_metrics_6__1__11 B[10]=backward_metrics[6][1][10]
+ B[9]=FE_OFN1253_backward_metrics_6__1__9
+ B[8]=FE_OFN1254_backward_metrics_6__1__8 B[7]=backward_metrics[6][1][7]
+ B[6]=backward_metrics[6][1][6] B[5]=backward_metrics[6][1][5]
+ B[4]=FE_OFN1258_backward_metrics_6__1__4
+ B[3]=FE_OFN1259_backward_metrics_6__1__3
+ B[2]=FE_OFN1260_backward_metrics_6__1__2
+ B[1]=FE_OFN1261_backward_metrics_6__1__1
+ B[0]=FE_OFN1262_backward_metrics_6__1__0 CI=n1 SUM[11]=LLR_sum[0][7][11]
+ SUM[10]=LLR_sum[0][7][10] SUM[9]=LLR_sum[0][7][9] SUM[8]=LLR_sum[0][7][8]
+ SUM[7]=LLR_sum[0][7][7] SUM[6]=LLR_sum[0][7][6] SUM[5]=LLR_sum[0][7][5]
+ SUM[4]=LLR_sum[0][7][4] SUM[3]=LLR_sum[0][7][3] SUM[2]=LLR_sum[0][7][2]
+ SUM[1]=LLR_sum[0][7][1] SUM[0]=LLR_sum[0][7][0]
+ FE_OFN175_forward_sum_0__1__6=FE_OFN973_forward_sum_0__1__6
+ FE_OFN218_backward_metrics_6__1__10=FE_OFN1252_backward_metrics_6__1__10
+ FE_OFN219_backward_metrics_6__1__7=FE_OFN1255_backward_metrics_6__1__7
+ FE_OFN220_backward_metrics_6__1__6=FE_OFN1256_backward_metrics_6__1__6
Xadd_88_G7 Siso_DW01_add_253 $PINS A[11]=forward_metrics[6][1][11]
+ A[10]=forward_metrics[6][1][10] A[9]=forward_metrics[6][1][9]
+ A[8]=forward_metrics[6][1][8] A[7]=forward_metrics[6][1][7]
+ A[6]=forward_metrics[6][1][6] A[5]=forward_metrics[6][1][5]
+ A[4]=forward_metrics[6][1][4] A[3]=forward_metrics[6][1][3]
+ A[2]=forward_metrics[6][1][2] A[1]=forward_metrics[6][1][1]
+ A[0]=forward_metrics[6][1][0] B[11]=FE_OFN1278_backward_sum_0__2__11
+ B[10]=FE_OFN1279_backward_sum_0__2__10 B[9]=backward_sum[0][6][9]
+ B[8]=backward_sum[0][6][8] B[7]=backward_sum[0][6][7]
+ B[6]=backward_sum[0][6][6] B[5]=backward_sum[0][6][5]
+ B[4]=backward_sum[0][6][4] B[3]=backward_sum[0][6][3]
+ B[2]=backward_sum[0][6][2] B[1]=backward_sum[0][6][1]
+ B[0]=backward_sum[0][6][0] CI=n1 SUM[11]=LLR_sum[6][5][11]
+ SUM[10]=LLR_sum[6][5][10] SUM[9]=LLR_sum[6][5][9] SUM[8]=LLR_sum[6][5][8]
+ SUM[7]=LLR_sum[6][5][7] SUM[6]=LLR_sum[6][5][6] SUM[5]=LLR_sum[6][5][5]
+ SUM[4]=LLR_sum[6][5][4] SUM[3]=LLR_sum[6][5][3] SUM[2]=LLR_sum[6][5][2]
+ SUM[1]=LLR_sum[6][5][1] SUM[0]=LLR_sum[6][5][0]
Xadd_110 Siso_DW01_add_254 $PINS A[11]=forward_sum[0][1][11]
+ A[10]=forward_sum[0][1][10] A[9]=forward_sum[0][1][9]
+ A[8]=FE_OFN971_forward_sum_0__1__8 A[7]=FE_OFN972_forward_sum_0__1__7
+ A[6]=FE_OFN973_forward_sum_0__1__6 A[5]=FE_OFN974_forward_sum_0__1__5
+ A[4]=FE_OFN975_forward_sum_0__1__4 A[3]=FE_OFN5648_forward_sum_0__1__3
+ A[2]=forward_sum[0][1][2] A[1]=FE_OFN978_forward_sum_0__1__1
+ A[0]=FE_OFN979_forward_sum_0__1__0 B[11]=backward_metrics[6][0][11]
+ B[10]=backward_metrics[6][0][10] B[9]=backward_metrics[6][0][9]
+ B[8]=backward_metrics[6][0][8] B[7]=backward_metrics[6][0][7]
+ B[6]=backward_metrics[6][0][6] B[5]=backward_metrics[6][0][5]
+ B[4]=backward_metrics[6][0][4] B[3]=backward_metrics[6][0][3]
+ B[2]=backward_metrics[6][0][2] B[1]=backward_metrics[6][0][1]
+ B[0]=backward_metrics[6][0][0] CI=n1 SUM[11]=LLR_sum[0][5][11]
+ SUM[10]=LLR_sum[0][5][10] SUM[9]=LLR_sum[0][5][9] SUM[8]=LLR_sum[0][5][8]
+ SUM[7]=LLR_sum[0][5][7] SUM[6]=LLR_sum[0][5][6] SUM[5]=LLR_sum[0][5][5]
+ SUM[4]=LLR_sum[0][5][4] SUM[3]=LLR_sum[0][5][3] SUM[2]=LLR_sum[0][5][2]
+ SUM[1]=LLR_sum[0][5][1] SUM[0]=LLR_sum[0][5][0]
+ FE_OFN174_forward_sum_0__1__9=FE_OFN970_forward_sum_0__1__9
Xadd_111 Siso_DW01_add_255 $PINS A[11]=forward_sum[0][6][11]
+ A[10]=forward_sum[0][6][10] A[9]=forward_sum[0][6][9]
+ A[8]=FE_OFN1001_forward_sum_0__6__8 A[7]=forward_sum[0][6][7]
+ A[6]=FE_OFN1003_forward_sum_0__6__6 A[5]=FE_OFN1004_forward_sum_0__6__5
+ A[4]=FE_OFN1005_forward_sum_0__6__4 A[3]=FE_OFN1006_forward_sum_0__6__3
+ A[2]=FE_OFN1007_forward_sum_0__6__2 A[1]=FE_OFN1008_forward_sum_0__6__1
+ A[0]=forward_sum[0][6][0] B[11]=FE_OFN1264_backward_metrics_6__3__11
+ B[10]=backward_metrics[6][3][10] B[9]=backward_metrics[6][3][9]
+ B[8]=backward_metrics[6][3][8] B[7]=backward_metrics[6][3][7]
+ B[6]=FE_OFN1269_backward_metrics_6__3__6 B[5]=backward_metrics[6][3][5]
+ B[4]=backward_metrics[6][3][4] B[3]=FE_OFN1272_backward_metrics_6__3__3
+ B[2]=FE_OFN1273_backward_metrics_6__3__2
+ B[1]=FE_OFN1274_backward_metrics_6__3__1
+ B[0]=FE_OFN5547_backward_metrics_6__3__0 CI=n1 SUM[11]=LLR_sum[0][6][11]
+ SUM[10]=LLR_sum[0][6][10] SUM[9]=LLR_sum[0][6][9] SUM[8]=LLR_sum[0][6][8]
+ SUM[7]=LLR_sum[0][6][7] SUM[6]=LLR_sum[0][6][6] SUM[5]=LLR_sum[0][6][5]
+ SUM[4]=LLR_sum[0][6][4] SUM[3]=LLR_sum[0][6][3] SUM[2]=LLR_sum[0][6][2]
+ SUM[1]=LLR_sum[0][6][1] SUM[0]=LLR_sum[0][6][0]
+ FE_OFN184_forward_sum_0__6__9=FE_OFN1000_forward_sum_0__6__9
+ FE_OFN185_forward_sum_0__6__0=FE_OFN1009_forward_sum_0__6__0
Xadd_88_G2 Siso_DW01_add_256 $PINS A[11]=forward_metrics[1][1][11]
+ A[10]=forward_metrics[1][1][10] A[9]=forward_metrics[1][1][9]
+ A[8]=forward_metrics[1][1][8] A[7]=forward_metrics[1][1][7]
+ A[6]=forward_metrics[1][1][6] A[5]=forward_metrics[1][1][5]
+ A[4]=forward_metrics[1][1][4] A[3]=forward_metrics[1][1][3]
+ A[2]=forward_metrics[1][1][2] A[1]=forward_metrics[1][1][1]
+ A[0]=forward_metrics[1][1][0] B[11]=FE_OFN753_branch_metrics_1__2__11
+ B[10]=FE_OFN754_branch_metrics_1__2__10 B[9]=branch_metrics[1][2][9]
+ B[8]=branch_metrics[1][2][8] B[7]=branch_metrics[1][2][7]
+ B[6]=FE_OFN758_branch_metrics_1__2__6 B[5]=FE_OFN759_branch_metrics_1__2__5
+ B[4]=branch_metrics[1][2][4] B[3]=branch_metrics[1][2][3]
+ B[2]=branch_metrics[1][2][2] B[1]=FE_OFN763_branch_metrics_1__2__1
+ B[0]=branch_metrics[1][2][0] CI=n1 SUM[11]=forward_sum[1][1][11]
+ SUM[10]=forward_sum[1][1][10] SUM[9]=forward_sum[1][1][9]
+ SUM[8]=forward_sum[1][1][8] SUM[7]=forward_sum[1][1][7]
+ SUM[6]=forward_sum[1][1][6] SUM[5]=forward_sum[1][1][5]
+ SUM[4]=forward_sum[1][1][4] SUM[3]=forward_sum[1][1][3]
+ SUM[2]=forward_sum[1][1][2] SUM[1]=forward_sum[1][1][1]
+ SUM[0]=forward_sum[1][1][0]
Xadd_91_G2 Siso_DW01_add_257 $PINS A[11]=forward_metrics[1][0][11]
+ A[10]=forward_metrics[1][0][10] A[9]=forward_metrics[1][0][9]
+ A[8]=forward_metrics[1][0][8] A[7]=forward_metrics[1][0][7]
+ A[6]=forward_metrics[1][0][6] A[5]=forward_metrics[1][0][5]
+ A[4]=forward_metrics[1][0][4] A[3]=forward_metrics[1][0][3]
+ A[2]=forward_metrics[1][0][2] A[1]=forward_metrics[1][0][1]
+ A[0]=forward_metrics[1][0][0] B[11]=FE_OFN741_branch_metrics_1__1__11
+ B[10]=FE_OFN742_branch_metrics_1__1__10 B[9]=FE_OFN743_branch_metrics_1__1__9
+ B[8]=FE_OFN744_branch_metrics_1__1__8 B[7]=FE_OFN745_branch_metrics_1__1__7
+ B[6]=FE_OFN746_branch_metrics_1__1__6 B[5]=branch_metrics[1][1][5]
+ B[4]=branch_metrics[1][1][4] B[3]=branch_metrics[1][1][3]
+ B[2]=FE_OFN750_branch_metrics_1__1__2 B[1]=FE_OFN751_branch_metrics_1__1__1
+ B[0]=branch_metrics[1][1][0] CI=n1 SUM[11]=forward_sum[1][4][11]
+ SUM[10]=forward_sum[1][4][10] SUM[9]=forward_sum[1][4][9]
+ SUM[8]=forward_sum[1][4][8] SUM[7]=forward_sum[1][4][7]
+ SUM[6]=forward_sum[1][4][6] SUM[5]=forward_sum[1][4][5]
+ SUM[4]=forward_sum[1][4][4] SUM[3]=forward_sum[1][4][3]
+ SUM[2]=forward_sum[1][4][2] SUM[1]=forward_sum[1][4][1]
+ SUM[0]=forward_sum[1][4][0]
Xadd_109_G2 Siso_DW01_add_258 $PINS A[11]=forward_sum[1][4][11]
+ A[10]=forward_sum[1][4][10] A[9]=forward_sum[1][4][9] A[8]=forward_sum[1][4][8]
+ A[7]=forward_sum[1][4][7] A[6]=forward_sum[1][4][6] A[5]=forward_sum[1][4][5]
+ A[4]=forward_sum[1][4][4] A[3]=forward_sum[1][4][3] A[2]=forward_sum[1][4][2]
+ A[1]=forward_sum[1][4][1] A[0]=forward_sum[1][4][0]
+ B[11]=backward_metrics[5][2][11] B[10]=backward_metrics[5][2][10]
+ B[9]=backward_metrics[5][2][9] B[8]=FE_OFN1229_backward_metrics_5__2__8
+ B[7]=FE_OFN1230_backward_metrics_5__2__7
+ B[6]=FE_OFN1231_backward_metrics_5__2__6 B[5]=backward_metrics[5][2][5]
+ B[4]=backward_metrics[5][2][4] B[3]=FE_OFN1234_backward_metrics_5__2__3
+ B[2]=FE_OFN1235_backward_metrics_5__2__2 B[1]=backward_metrics[5][2][1]
+ B[0]=FE_OFN1237_backward_metrics_5__2__0 CI=n1 SUM[11]=LLR_sum[1][4][11]
+ SUM[10]=LLR_sum[1][4][10] SUM[9]=LLR_sum[1][4][9] SUM[8]=LLR_sum[1][4][8]
+ SUM[7]=LLR_sum[1][4][7] SUM[6]=LLR_sum[1][4][6] SUM[5]=LLR_sum[1][4][5]
+ SUM[4]=LLR_sum[1][4][4] SUM[3]=LLR_sum[1][4][3] SUM[2]=LLR_sum[1][4][2]
+ SUM[1]=LLR_sum[1][4][1] SUM[0]=LLR_sum[1][4][0]
+ FE_OFN209_backward_metrics_5__2__10=FE_OFN1227_backward_metrics_5__2__10
+ FE_OFN210_backward_metrics_5__2__9=FE_OFN1228_backward_metrics_5__2__9
Xadd_110_G2 Siso_DW01_add_259 $PINS A[11]=forward_sum[1][1][11]
+ A[10]=forward_sum[1][1][10] A[9]=forward_sum[1][1][9] A[8]=forward_sum[1][1][8]
+ A[7]=forward_sum[1][1][7] A[6]=forward_sum[1][1][6] A[5]=forward_sum[1][1][5]
+ A[4]=forward_sum[1][1][4] A[3]=forward_sum[1][1][3] A[2]=forward_sum[1][1][2]
+ A[1]=forward_sum[1][1][1] A[0]=forward_sum[1][1][0]
+ B[11]=FE_OFN1202_backward_metrics_5__0__11
+ B[10]=FE_OFN1203_backward_metrics_5__0__10 B[9]=backward_metrics[5][0][9]
+ B[8]=FE_OFN1205_backward_metrics_5__0__8
+ B[7]=FE_OFN1206_backward_metrics_5__0__7
+ B[6]=FE_OFN1207_backward_metrics_5__0__6 B[5]=backward_metrics[5][0][5]
+ B[4]=backward_metrics[5][0][4] B[3]=FE_OFN1210_backward_metrics_5__0__3
+ B[2]=FE_OFN1211_backward_metrics_5__0__2 B[1]=backward_metrics[5][0][1]
+ B[0]=backward_metrics[5][0][0] CI=n1 SUM[11]=LLR_sum[1][5][11]
+ SUM[10]=LLR_sum[1][5][10] SUM[9]=LLR_sum[1][5][9] SUM[8]=LLR_sum[1][5][8]
+ SUM[7]=LLR_sum[1][5][7] SUM[6]=LLR_sum[1][5][6] SUM[5]=LLR_sum[1][5][5]
+ SUM[4]=LLR_sum[1][5][4] SUM[3]=LLR_sum[1][5][3] SUM[2]=LLR_sum[1][5][2]
+ SUM[1]=LLR_sum[1][5][1] SUM[0]=LLR_sum[1][5][0]
Xadd_88_G3 Siso_DW01_add_260 $PINS A[11]=forward_metrics[2][1][11]
+ A[10]=forward_metrics[2][1][10] A[9]=forward_metrics[2][1][9]
+ A[8]=forward_metrics[2][1][8] A[7]=forward_metrics[2][1][7]
+ A[6]=forward_metrics[2][1][6] A[5]=forward_metrics[2][1][5]
+ A[4]=forward_metrics[2][1][4] A[3]=forward_metrics[2][1][3]
+ A[2]=forward_metrics[2][1][2] A[1]=forward_metrics[2][1][1]
+ A[0]=forward_metrics[2][1][0] B[11]=branch_metrics[2][2][11]
+ B[10]=FE_OFN802_branch_metrics_2__2__10 B[9]=branch_metrics[2][2][9]
+ B[8]=FE_OFN804_branch_metrics_2__2__8 B[7]=branch_metrics[2][2][7]
+ B[6]=branch_metrics[2][2][6] B[5]=FE_OFN807_branch_metrics_2__2__5
+ B[4]=branch_metrics[2][2][4] B[3]=branch_metrics[2][2][3]
+ B[2]=FE_OFN810_branch_metrics_2__2__2 B[1]=branch_metrics[2][2][1]
+ B[0]=branch_metrics[2][2][0] CI=n1 SUM[11]=forward_sum[2][1][11]
+ SUM[10]=forward_sum[2][1][10] SUM[9]=forward_sum[2][1][9]
+ SUM[8]=forward_sum[2][1][8] SUM[7]=forward_sum[2][1][7]
+ SUM[6]=forward_sum[2][1][6] SUM[5]=forward_sum[2][1][5]
+ SUM[4]=forward_sum[2][1][4] SUM[3]=forward_sum[2][1][3]
+ SUM[2]=forward_sum[2][1][2] SUM[1]=forward_sum[2][1][1]
+ SUM[0]=forward_sum[2][1][0]
+ FE_OFN160_branch_metrics_2__2__9=FE_OFN803_branch_metrics_2__2__9
Xadd_91_G3 Siso_DW01_add_261 $PINS A[11]=forward_metrics[2][0][11]
+ A[10]=forward_metrics[2][0][10] A[9]=forward_metrics[2][0][9]
+ A[8]=forward_metrics[2][0][8] A[7]=forward_metrics[2][0][7]
+ A[6]=forward_metrics[2][0][6] A[5]=forward_metrics[2][0][5]
+ A[4]=forward_metrics[2][0][4] A[3]=forward_metrics[2][0][3]
+ A[2]=forward_metrics[2][0][2] A[1]=forward_metrics[2][0][1]
+ A[0]=forward_metrics[2][0][0] B[11]=branch_metrics[2][1][11]
+ B[10]=branch_metrics[2][1][10] B[9]=FE_OFN791_branch_metrics_2__1__9
+ B[8]=FE_OFN792_branch_metrics_2__1__8 B[7]=FE_OFN793_branch_metrics_2__1__7
+ B[6]=FE_OFN794_branch_metrics_2__1__6 B[5]=branch_metrics[2][1][5]
+ B[4]=branch_metrics[2][1][4] B[3]=branch_metrics[2][1][3]
+ B[2]=FE_OFN798_branch_metrics_2__1__2 B[1]=FE_OFN799_branch_metrics_2__1__1
+ B[0]=branch_metrics[2][1][0] CI=n1 SUM[11]=forward_sum[2][4][11]
+ SUM[10]=forward_sum[2][4][10] SUM[9]=forward_sum[2][4][9]
+ SUM[8]=forward_sum[2][4][8] SUM[7]=forward_sum[2][4][7]
+ SUM[6]=forward_sum[2][4][6] SUM[5]=forward_sum[2][4][5]
+ SUM[4]=forward_sum[2][4][4] SUM[3]=forward_sum[2][4][3]
+ SUM[2]=forward_sum[2][4][2] SUM[1]=forward_sum[2][4][1]
+ SUM[0]=forward_sum[2][4][0]
Xadd_109_G3 Siso_DW01_add_262 $PINS A[11]=forward_sum[2][4][11]
+ A[10]=forward_sum[2][4][10] A[9]=forward_sum[2][4][9] A[8]=forward_sum[2][4][8]
+ A[7]=forward_sum[2][4][7] A[6]=forward_sum[2][4][6] A[5]=forward_sum[2][4][5]
+ A[4]=forward_sum[2][4][4] A[3]=forward_sum[2][4][3] A[2]=forward_sum[2][4][2]
+ A[1]=forward_sum[2][4][1] A[0]=forward_sum[2][4][0]
+ B[11]=FE_OFN1178_backward_metrics_4__2__11
+ B[10]=FE_OFN1179_backward_metrics_4__2__10
+ B[9]=FE_OFN1180_backward_metrics_4__2__9
+ B[8]=FE_OFN1181_backward_metrics_4__2__8
+ B[7]=FE_OFN1182_backward_metrics_4__2__7
+ B[6]=FE_OFN1183_backward_metrics_4__2__6 B[5]=backward_metrics[4][2][5]
+ B[4]=FE_OFN1185_backward_metrics_4__2__4 B[3]=backward_metrics[4][2][3]
+ B[2]=FE_OFN1187_backward_metrics_4__2__2
+ B[1]=FE_OFN1188_backward_metrics_4__2__1
+ B[0]=FE_OFN1189_backward_metrics_4__2__0 CI=n1 SUM[11]=LLR_sum[2][4][11]
+ SUM[10]=LLR_sum[2][4][10] SUM[9]=LLR_sum[2][4][9] SUM[8]=LLR_sum[2][4][8]
+ SUM[7]=LLR_sum[2][4][7] SUM[6]=LLR_sum[2][4][6] SUM[5]=LLR_sum[2][4][5]
+ SUM[4]=LLR_sum[2][4][4] SUM[3]=LLR_sum[2][4][3] SUM[2]=LLR_sum[2][4][2]
+ SUM[1]=LLR_sum[2][4][1] SUM[0]=LLR_sum[2][4][0]
Xadd_110_G3 Siso_DW01_add_263 $PINS A[11]=forward_sum[2][1][11]
+ A[10]=forward_sum[2][1][10] A[9]=forward_sum[2][1][9] A[8]=forward_sum[2][1][8]
+ A[7]=forward_sum[2][1][7] A[6]=forward_sum[2][1][6] A[5]=forward_sum[2][1][5]
+ A[4]=forward_sum[2][1][4] A[3]=forward_sum[2][1][3] A[2]=forward_sum[2][1][2]
+ A[1]=forward_sum[2][1][1] A[0]=forward_sum[2][1][0]
+ B[11]=FE_OFN1154_backward_metrics_4__0__11
+ B[10]=FE_OFN1155_backward_metrics_4__0__10
+ B[9]=FE_OFN1156_backward_metrics_4__0__9 B[8]=backward_metrics[4][0][8]
+ B[7]=FE_OFN1158_backward_metrics_4__0__7
+ B[6]=FE_OFN1159_backward_metrics_4__0__6 B[5]=backward_metrics[4][0][5]
+ B[4]=backward_metrics[4][0][4] B[3]=backward_metrics[4][0][3]
+ B[2]=backward_metrics[4][0][2] B[1]=backward_metrics[4][0][1]
+ B[0]=FE_OFN5548_backward_metrics_4__0__0 CI=n1 SUM[11]=LLR_sum[2][5][11]
+ SUM[10]=LLR_sum[2][5][10] SUM[9]=LLR_sum[2][5][9] SUM[8]=LLR_sum[2][5][8]
+ SUM[7]=LLR_sum[2][5][7] SUM[6]=LLR_sum[2][5][6] SUM[5]=LLR_sum[2][5][5]
+ SUM[4]=LLR_sum[2][5][4] SUM[3]=LLR_sum[2][5][3] SUM[2]=LLR_sum[2][5][2]
+ SUM[1]=LLR_sum[2][5][1] SUM[0]=LLR_sum[2][5][0]
+ FE_OFN199_backward_metrics_4__0__8=FE_OFN1157_backward_metrics_4__0__8
+ FE_OFN200_backward_metrics_4__0__3=FE_OFN1162_backward_metrics_4__0__3
Xadd_88_G4 Siso_DW01_add_264 $PINS A[11]=forward_metrics[3][1][11]
+ A[10]=forward_metrics[3][1][10] A[9]=forward_metrics[3][1][9]
+ A[8]=forward_metrics[3][1][8] A[7]=forward_metrics[3][1][7]
+ A[6]=forward_metrics[3][1][6] A[5]=forward_metrics[3][1][5]
+ A[4]=forward_metrics[3][1][4] A[3]=forward_metrics[3][1][3]
+ A[2]=forward_metrics[3][1][2] A[1]=forward_metrics[3][1][1]
+ A[0]=forward_metrics[3][1][0] B[11]=FE_OFN849_branch_metrics_3__2__11
+ B[10]=FE_OFN850_branch_metrics_3__2__10 B[9]=FE_OFN851_branch_metrics_3__2__9
+ B[8]=FE_OFN852_branch_metrics_3__2__8 B[7]=branch_metrics[3][2][7]
+ B[6]=branch_metrics[3][2][6] B[5]=branch_metrics[3][2][5]
+ B[4]=branch_metrics[3][2][4] B[3]=branch_metrics[3][2][3]
+ B[2]=branch_metrics[3][2][2] B[1]=branch_metrics[3][2][1]
+ B[0]=branch_metrics[3][2][0] CI=n1 SUM[11]=forward_sum[3][1][11]
+ SUM[10]=forward_sum[3][1][10] SUM[9]=forward_sum[3][1][9]
+ SUM[8]=forward_sum[3][1][8] SUM[7]=forward_sum[3][1][7]
+ SUM[6]=forward_sum[3][1][6] SUM[5]=forward_sum[3][1][5]
+ SUM[4]=forward_sum[3][1][4] SUM[3]=forward_sum[3][1][3]
+ SUM[2]=forward_sum[3][1][2] SUM[1]=forward_sum[3][1][1]
+ SUM[0]=forward_sum[3][1][0]
+ FE_OFN163_branch_metrics_3__2__7=FE_OFN853_branch_metrics_3__2__7
Xadd_91_G4 Siso_DW01_add_265 $PINS A[11]=forward_metrics[3][0][11]
+ A[10]=forward_metrics[3][0][10] A[9]=forward_metrics[3][0][9]
+ A[8]=forward_metrics[3][0][8] A[7]=forward_metrics[3][0][7]
+ A[6]=forward_metrics[3][0][6] A[5]=forward_metrics[3][0][5]
+ A[4]=forward_metrics[3][0][4] A[3]=forward_metrics[3][0][3]
+ A[2]=forward_metrics[3][0][2] A[1]=forward_metrics[3][0][1]
+ A[0]=forward_metrics[3][0][0] B[11]=FE_OFN837_branch_metrics_3__1__11
+ B[10]=FE_OFN838_branch_metrics_3__1__10 B[9]=branch_metrics[3][1][9]
+ B[8]=FE_OFN840_branch_metrics_3__1__8 B[7]=branch_metrics[3][1][7]
+ B[6]=branch_metrics[3][1][6] B[5]=branch_metrics[3][1][5]
+ B[4]=branch_metrics[3][1][4] B[3]=branch_metrics[3][1][3]
+ B[2]=FE_OFN846_branch_metrics_3__1__2 B[1]=FE_OFN847_branch_metrics_3__1__1
+ B[0]=FE_OFN848_branch_metrics_3__1__0 CI=n1 SUM[11]=forward_sum[3][4][11]
+ SUM[10]=forward_sum[3][4][10] SUM[9]=forward_sum[3][4][9]
+ SUM[8]=forward_sum[3][4][8] SUM[7]=forward_sum[3][4][7]
+ SUM[6]=forward_sum[3][4][6] SUM[5]=forward_sum[3][4][5]
+ SUM[4]=forward_sum[3][4][4] SUM[3]=forward_sum[3][4][3]
+ SUM[2]=forward_sum[3][4][2] SUM[1]=forward_sum[3][4][1]
+ SUM[0]=forward_sum[3][4][0]
Xadd_109_G4 Siso_DW01_add_266 $PINS A[11]=forward_sum[3][4][11]
+ A[10]=forward_sum[3][4][10] A[9]=forward_sum[3][4][9] A[8]=forward_sum[3][4][8]
+ A[7]=forward_sum[3][4][7] A[6]=forward_sum[3][4][6] A[5]=forward_sum[3][4][5]
+ A[4]=forward_sum[3][4][4] A[3]=forward_sum[3][4][3] A[2]=forward_sum[3][4][2]
+ A[1]=forward_sum[3][4][1] A[0]=forward_sum[3][4][0]
+ B[11]=FE_OFN1130_backward_metrics_3__2__11
+ B[10]=FE_OFN1131_backward_metrics_3__2__10
+ B[9]=FE_OFN1132_backward_metrics_3__2__9
+ B[8]=FE_OFN1133_backward_metrics_3__2__8 B[7]=backward_metrics[3][2][7]
+ B[6]=FE_OFN1135_backward_metrics_3__2__6
+ B[5]=FE_OFN1136_backward_metrics_3__2__5 B[4]=backward_metrics[3][2][4]
+ B[3]=backward_metrics[3][2][3] B[2]=backward_metrics[3][2][2]
+ B[1]=FE_OFN1140_backward_metrics_3__2__1
+ B[0]=FE_OFN1141_backward_metrics_3__2__0 CI=n1 SUM[11]=LLR_sum[3][4][11]
+ SUM[10]=LLR_sum[3][4][10] SUM[9]=LLR_sum[3][4][9] SUM[8]=LLR_sum[3][4][8]
+ SUM[7]=LLR_sum[3][4][7] SUM[6]=LLR_sum[3][4][6] SUM[5]=LLR_sum[3][4][5]
+ SUM[4]=LLR_sum[3][4][4] SUM[3]=LLR_sum[3][4][3] SUM[2]=LLR_sum[3][4][2]
+ SUM[1]=LLR_sum[3][4][1] SUM[0]=LLR_sum[3][4][0]
Xadd_110_G4 Siso_DW01_add_267 $PINS A[11]=forward_sum[3][1][11]
+ A[10]=forward_sum[3][1][10] A[9]=forward_sum[3][1][9] A[8]=forward_sum[3][1][8]
+ A[7]=forward_sum[3][1][7] A[6]=forward_sum[3][1][6] A[5]=forward_sum[3][1][5]
+ A[4]=forward_sum[3][1][4] A[3]=forward_sum[3][1][3] A[2]=forward_sum[3][1][2]
+ A[1]=forward_sum[3][1][1] A[0]=forward_sum[3][1][0]
+ B[11]=FE_OFN1106_backward_metrics_3__0__11
+ B[10]=FE_OFN1107_backward_metrics_3__0__10
+ B[9]=FE_OFN1108_backward_metrics_3__0__9 B[8]=backward_metrics[3][0][8]
+ B[7]=FE_OFN1110_backward_metrics_3__0__7
+ B[6]=FE_OFN1111_backward_metrics_3__0__6 B[5]=backward_metrics[3][0][5]
+ B[4]=backward_metrics[3][0][4] B[3]=backward_metrics[3][0][3]
+ B[2]=FE_OFN1115_backward_metrics_3__0__2 B[1]=backward_metrics[3][0][1]
+ B[0]=FE_OFN1117_backward_metrics_3__0__0 CI=n1 SUM[11]=LLR_sum[3][5][11]
+ SUM[10]=LLR_sum[3][5][10] SUM[9]=LLR_sum[3][5][9] SUM[8]=LLR_sum[3][5][8]
+ SUM[7]=LLR_sum[3][5][7] SUM[6]=LLR_sum[3][5][6] SUM[5]=LLR_sum[3][5][5]
+ SUM[4]=LLR_sum[3][5][4] SUM[3]=LLR_sum[3][5][3] SUM[2]=LLR_sum[3][5][2]
+ SUM[1]=LLR_sum[3][5][1] SUM[0]=LLR_sum[3][5][0]
Xadd_88_G5 Siso_DW01_add_268 $PINS A[11]=forward_metrics[4][1][11]
+ A[10]=forward_metrics[4][1][10] A[9]=forward_metrics[4][1][9]
+ A[8]=forward_metrics[4][1][8] A[7]=forward_metrics[4][1][7]
+ A[6]=forward_metrics[4][1][6] A[5]=forward_metrics[4][1][5]
+ A[4]=forward_metrics[4][1][4] A[3]=forward_metrics[4][1][3]
+ A[2]=forward_metrics[4][1][2] A[1]=forward_metrics[4][1][1]
+ A[0]=forward_metrics[4][1][0] B[11]=FE_OFN897_branch_metrics_4__2__11
+ B[10]=FE_OFN898_branch_metrics_4__2__10 B[9]=branch_metrics[4][2][9]
+ B[8]=branch_metrics[4][2][8] B[7]=FE_OFN901_branch_metrics_4__2__7
+ B[6]=branch_metrics[4][2][6] B[5]=FE_OFN903_branch_metrics_4__2__5
+ B[4]=branch_metrics[4][2][4] B[3]=branch_metrics[4][2][3]
+ B[2]=FE_OFN906_branch_metrics_4__2__2 B[1]=branch_metrics[4][2][1]
+ B[0]=FE_OFN3100_branch_metrics_4_2_0 CI=n1 SUM[11]=forward_sum[4][1][11]
+ SUM[10]=forward_sum[4][1][10] SUM[9]=forward_sum[4][1][9]
+ SUM[8]=forward_sum[4][1][8] SUM[7]=forward_sum[4][1][7]
+ SUM[6]=forward_sum[4][1][6] SUM[5]=forward_sum[4][1][5]
+ SUM[4]=forward_sum[4][1][4] SUM[3]=forward_sum[4][1][3]
+ SUM[2]=forward_sum[4][1][2] SUM[1]=forward_sum[4][1][1]
+ SUM[0]=forward_sum[4][1][0]
Xadd_91_G5 Siso_DW01_add_269 $PINS A[11]=forward_metrics[4][0][11]
+ A[10]=forward_metrics[4][0][10] A[9]=forward_metrics[4][0][9]
+ A[8]=forward_metrics[4][0][8] A[7]=forward_metrics[4][0][7]
+ A[6]=forward_metrics[4][0][6] A[5]=forward_metrics[4][0][5]
+ A[4]=forward_metrics[4][0][4] A[3]=forward_metrics[4][0][3]
+ A[2]=forward_metrics[4][0][2] A[1]=forward_metrics[4][0][1]
+ A[0]=forward_metrics[4][0][0] B[11]=branch_metrics[4][1][11]
+ B[10]=branch_metrics[4][1][10] B[9]=branch_metrics[4][1][9]
+ B[8]=branch_metrics[4][1][8] B[7]=FE_OFN889_branch_metrics_4__1__7
+ B[6]=branch_metrics[4][1][6] B[5]=branch_metrics[4][1][5]
+ B[4]=branch_metrics[4][1][4] B[3]=branch_metrics[4][1][3]
+ B[2]=branch_metrics[4][1][2] B[1]=branch_metrics[4][1][1]
+ B[0]=branch_metrics[4][1][0] CI=n1 SUM[11]=forward_sum[4][4][11]
+ SUM[10]=forward_sum[4][4][10] SUM[9]=forward_sum[4][4][9]
+ SUM[8]=forward_sum[4][4][8] SUM[7]=forward_sum[4][4][7]
+ SUM[6]=forward_sum[4][4][6] SUM[5]=forward_sum[4][4][5]
+ SUM[4]=forward_sum[4][4][4] SUM[3]=forward_sum[4][4][3]
+ SUM[2]=forward_sum[4][4][2] SUM[1]=forward_sum[4][4][1]
+ SUM[0]=forward_sum[4][4][0]
Xadd_109_G5 Siso_DW01_add_270 $PINS A[11]=forward_sum[4][4][11]
+ A[10]=forward_sum[4][4][10] A[9]=forward_sum[4][4][9] A[8]=forward_sum[4][4][8]
+ A[7]=forward_sum[4][4][7] A[6]=forward_sum[4][4][6] A[5]=forward_sum[4][4][5]
+ A[4]=forward_sum[4][4][4] A[3]=forward_sum[4][4][3] A[2]=forward_sum[4][4][2]
+ A[1]=forward_sum[4][4][1] A[0]=forward_sum[4][4][0]
+ B[11]=FE_OFN1082_backward_metrics_2__2__11
+ B[10]=FE_OFN1083_backward_metrics_2__2__10
+ B[9]=FE_OFN1084_backward_metrics_2__2__9
+ B[8]=FE_OFN1085_backward_metrics_2__2__8 B[7]=backward_metrics[2][2][7]
+ B[6]=FE_OFN1087_backward_metrics_2__2__6 B[5]=backward_metrics[2][2][5]
+ B[4]=backward_metrics[2][2][4] B[3]=FE_OFN1090_backward_metrics_2__2__3
+ B[2]=FE_OFN1091_backward_metrics_2__2__2 B[1]=backward_metrics[2][2][1]
+ B[0]=backward_metrics[2][2][0] CI=n1 SUM[11]=LLR_sum[4][4][11]
+ SUM[10]=LLR_sum[4][4][10] SUM[9]=LLR_sum[4][4][9] SUM[8]=LLR_sum[4][4][8]
+ SUM[7]=LLR_sum[4][4][7] SUM[6]=LLR_sum[4][4][6] SUM[5]=LLR_sum[4][4][5]
+ SUM[4]=LLR_sum[4][4][4] SUM[3]=LLR_sum[4][4][3] SUM[2]=LLR_sum[4][4][2]
+ SUM[1]=LLR_sum[4][4][1] SUM[0]=LLR_sum[4][4][0]
Xadd_110_G5 Siso_DW01_add_271 $PINS A[11]=forward_sum[4][1][11]
+ A[10]=forward_sum[4][1][10] A[9]=forward_sum[4][1][9] A[8]=forward_sum[4][1][8]
+ A[7]=forward_sum[4][1][7] A[6]=forward_sum[4][1][6] A[5]=forward_sum[4][1][5]
+ A[4]=forward_sum[4][1][4] A[3]=forward_sum[4][1][3] A[2]=forward_sum[4][1][2]
+ A[1]=forward_sum[4][1][1] A[0]=forward_sum[4][1][0]
+ B[11]=FE_OFN1058_backward_metrics_2__0__11
+ B[10]=FE_OFN1059_backward_metrics_2__0__10
+ B[9]=FE_OFN1060_backward_metrics_2__0__9
+ B[8]=FE_OFN1061_backward_metrics_2__0__8
+ B[7]=FE_OFN1062_backward_metrics_2__0__7
+ B[6]=FE_OFN1063_backward_metrics_2__0__6 B[5]=backward_metrics[2][0][5]
+ B[4]=backward_metrics[2][0][4] B[3]=FE_OFN1066_backward_metrics_2__0__3
+ B[2]=FE_OFN1067_backward_metrics_2__0__2 B[1]=backward_metrics[2][0][1]
+ B[0]=backward_metrics[2][0][0] CI=n1 SUM[11]=LLR_sum[4][5][11]
+ SUM[10]=LLR_sum[4][5][10] SUM[9]=LLR_sum[4][5][9] SUM[8]=LLR_sum[4][5][8]
+ SUM[7]=LLR_sum[4][5][7] SUM[6]=LLR_sum[4][5][6] SUM[5]=LLR_sum[4][5][5]
+ SUM[4]=LLR_sum[4][5][4] SUM[3]=LLR_sum[4][5][3] SUM[2]=LLR_sum[4][5][2]
+ SUM[1]=LLR_sum[4][5][1] SUM[0]=LLR_sum[4][5][0]
Xadd_88_G6 Siso_DW01_add_272 $PINS A[11]=forward_metrics[5][1][11]
+ A[10]=forward_metrics[5][1][10] A[9]=forward_metrics[5][1][9]
+ A[8]=forward_metrics[5][1][8] A[7]=forward_metrics[5][1][7]
+ A[6]=forward_metrics[5][1][6] A[5]=forward_metrics[5][1][5]
+ A[4]=forward_metrics[5][1][4] A[3]=forward_metrics[5][1][3]
+ A[2]=forward_metrics[5][1][2] A[1]=forward_metrics[5][1][1]
+ A[0]=forward_metrics[5][1][0] B[11]=branch_metrics[5][2][11]
+ B[10]=FE_OFN945_branch_metrics_5__2__10 B[9]=FE_OFN946_branch_metrics_5__2__9
+ B[8]=FE_OFN947_branch_metrics_5__2__8 B[7]=branch_metrics[5][2][7]
+ B[6]=FE_OFN949_branch_metrics_5__2__6 B[5]=branch_metrics[5][2][5]
+ B[4]=branch_metrics[5][2][4] B[3]=branch_metrics[5][2][3]
+ B[2]=branch_metrics[5][2][2] B[1]=branch_metrics[5][2][1]
+ B[0]=branch_metrics[5][2][0] CI=n1 SUM[11]=forward_sum[5][1][11]
+ SUM[10]=forward_sum[5][1][10] SUM[9]=forward_sum[5][1][9]
+ SUM[8]=forward_sum[5][1][8] SUM[7]=forward_sum[5][1][7]
+ SUM[6]=forward_sum[5][1][6] SUM[5]=forward_sum[5][1][5]
+ SUM[4]=forward_sum[5][1][4] SUM[3]=forward_sum[5][1][3]
+ SUM[2]=forward_sum[5][1][2] SUM[1]=forward_sum[5][1][1]
+ SUM[0]=forward_sum[5][1][0]
Xadd_91_G6 Siso_DW01_add_273 $PINS A[11]=forward_metrics[5][0][11]
+ A[10]=forward_metrics[5][0][10] A[9]=forward_metrics[5][0][9]
+ A[8]=forward_metrics[5][0][8] A[7]=forward_metrics[5][0][7]
+ A[6]=forward_metrics[5][0][6] A[5]=forward_metrics[5][0][5]
+ A[4]=forward_metrics[5][0][4] A[3]=forward_metrics[5][0][3]
+ A[2]=forward_metrics[5][0][2] A[1]=forward_metrics[5][0][1]
+ A[0]=forward_metrics[5][0][0] B[11]=FE_OFN933_branch_metrics_5__1__11
+ B[10]=branch_metrics[5][1][10] B[9]=branch_metrics[5][1][9]
+ B[8]=branch_metrics[5][1][8] B[7]=FE_OFN937_branch_metrics_5__1__7
+ B[6]=branch_metrics[5][1][6] B[5]=branch_metrics[5][1][5]
+ B[4]=branch_metrics[5][1][4] B[3]=branch_metrics[5][1][3]
+ B[2]=FE_OFN942_branch_metrics_5__1__2 B[1]=FE_OFN943_branch_metrics_5__1__1
+ B[0]=FE_OFN1359_n1434 CI=n1 SUM[11]=forward_sum[5][4][11]
+ SUM[10]=forward_sum[5][4][10] SUM[9]=forward_sum[5][4][9]
+ SUM[8]=forward_sum[5][4][8] SUM[7]=forward_sum[5][4][7]
+ SUM[6]=forward_sum[5][4][6] SUM[5]=forward_sum[5][4][5]
+ SUM[4]=forward_sum[5][4][4] SUM[3]=forward_sum[5][4][3]
+ SUM[2]=forward_sum[5][4][2] SUM[1]=forward_sum[5][4][1]
+ SUM[0]=forward_sum[5][4][0]
Xadd_109_G6 Siso_DW01_add_274 $PINS A[11]=forward_sum[5][4][11]
+ A[10]=forward_sum[5][4][10] A[9]=forward_sum[5][4][9] A[8]=forward_sum[5][4][8]
+ A[7]=forward_sum[5][4][7] A[6]=forward_sum[5][4][6] A[5]=forward_sum[5][4][5]
+ A[4]=forward_sum[5][4][4] A[3]=forward_sum[5][4][3] A[2]=forward_sum[5][4][2]
+ A[1]=forward_sum[5][4][1] A[0]=forward_sum[5][4][0]
+ B[11]=FE_OFN1034_backward_metrics_1__2__11
+ B[10]=FE_OFN1035_backward_metrics_1__2__10
+ B[9]=FE_OFN1036_backward_metrics_1__2__9
+ B[8]=FE_OFN1037_backward_metrics_1__2__8 B[7]=backward_metrics[1][2][7]
+ B[6]=FE_OFN1039_backward_metrics_1__2__6 B[5]=backward_metrics[1][2][5]
+ B[4]=backward_metrics[1][2][4] B[3]=backward_metrics[1][2][3]
+ B[2]=FE_OFN1043_backward_metrics_1__2__2
+ B[1]=FE_OFN1044_backward_metrics_1__2__1 B[0]=backward_metrics[1][2][0] CI=n1
+ SUM[11]=LLR_sum[5][4][11] SUM[10]=LLR_sum[5][4][10] SUM[9]=LLR_sum[5][4][9]
+ SUM[8]=LLR_sum[5][4][8] SUM[7]=LLR_sum[5][4][7] SUM[6]=LLR_sum[5][4][6]
+ SUM[5]=LLR_sum[5][4][5] SUM[4]=LLR_sum[5][4][4] SUM[3]=LLR_sum[5][4][3]
+ SUM[2]=LLR_sum[5][4][2] SUM[1]=LLR_sum[5][4][1] SUM[0]=LLR_sum[5][4][0]
Xadd_110_G6 Siso_DW01_add_275 $PINS A[11]=forward_sum[5][1][11]
+ A[10]=forward_sum[5][1][10] A[9]=forward_sum[5][1][9] A[8]=forward_sum[5][1][8]
+ A[7]=forward_sum[5][1][7] A[6]=forward_sum[5][1][6] A[5]=forward_sum[5][1][5]
+ A[4]=forward_sum[5][1][4] A[3]=forward_sum[5][1][3] A[2]=forward_sum[5][1][2]
+ A[1]=forward_sum[5][1][1] A[0]=forward_sum[5][1][0]
+ B[11]=FE_OFN1010_backward_metrics_1__0__11
+ B[10]=FE_OFN1011_backward_metrics_1__0__10
+ B[9]=FE_OFN1012_backward_metrics_1__0__9
+ B[8]=FE_OFN1013_backward_metrics_1__0__8
+ B[7]=FE_OFN1014_backward_metrics_1__0__7
+ B[6]=FE_OFN1015_backward_metrics_1__0__6
+ B[5]=FE_OFN1016_backward_metrics_1__0__5 B[4]=backward_metrics[1][0][4]
+ B[3]=FE_OFN1018_backward_metrics_1__0__3 B[2]=backward_metrics[1][0][2]
+ B[1]=backward_metrics[1][0][1] B[0]=backward_metrics[1][0][0] CI=n1
+ SUM[11]=LLR_sum[5][5][11] SUM[10]=LLR_sum[5][5][10] SUM[9]=LLR_sum[5][5][9]
+ SUM[8]=LLR_sum[5][5][8] SUM[7]=LLR_sum[5][5][7] SUM[6]=LLR_sum[5][5][6]
+ SUM[5]=LLR_sum[5][5][5] SUM[4]=LLR_sum[5][5][4] SUM[3]=LLR_sum[5][5][3]
+ SUM[2]=LLR_sum[5][5][2] SUM[1]=LLR_sum[5][5][1] SUM[0]=LLR_sum[5][5][0]
+ FE_OFN186_backward_metrics_1__0__1=backward_metrics[1][0][1]
Xadd_90_G2 Siso_DW01_add_276 $PINS A[11]=forward_metrics[1][3][11]
+ A[10]=forward_metrics[1][3][10] A[9]=forward_metrics[1][3][9]
+ A[8]=forward_metrics[1][3][8] A[7]=forward_metrics[1][3][7]
+ A[6]=forward_metrics[1][3][6] A[5]=forward_metrics[1][3][5]
+ A[4]=forward_metrics[1][3][4] A[3]=forward_metrics[1][3][3]
+ A[2]=forward_metrics[1][3][2] A[1]=forward_metrics[1][3][1]
+ A[0]=forward_metrics[1][3][0] B[11]=branch_metrics[1][2][11]
+ B[10]=FE_OFN754_branch_metrics_1__2__10 B[9]=branch_metrics[1][2][9]
+ B[8]=branch_metrics[1][2][8] B[7]=FE_OFN757_branch_metrics_1__2__7
+ B[6]=branch_metrics[1][2][6] B[5]=FE_OFN759_branch_metrics_1__2__5
+ B[4]=branch_metrics[1][2][4] B[3]=branch_metrics[1][2][3]
+ B[2]=branch_metrics[1][2][2] B[1]=branch_metrics[1][2][1]
+ B[0]=branch_metrics[1][2][0] CI=n1 SUM[11]=forward_sum[1][3][11]
+ SUM[10]=forward_sum[1][3][10] SUM[9]=forward_sum[1][3][9]
+ SUM[8]=forward_sum[1][3][8] SUM[7]=forward_sum[1][3][7]
+ SUM[6]=forward_sum[1][3][6] SUM[5]=forward_sum[1][3][5]
+ SUM[4]=forward_sum[1][3][4] SUM[3]=forward_sum[1][3][3]
+ SUM[2]=forward_sum[1][3][2] SUM[1]=forward_sum[1][3][1]
+ SUM[0]=forward_sum[1][3][0]
+ FE_OFN153_branch_metrics_1__2__11=FE_OFN753_branch_metrics_1__2__11
+ FE_OFN154_branch_metrics_1__2__6=FE_OFN758_branch_metrics_1__2__6
Xadd_93_G2 Siso_DW01_add_277 $PINS A[11]=forward_metrics[1][2][11]
+ A[10]=forward_metrics[1][2][10] A[9]=forward_metrics[1][2][9]
+ A[8]=forward_metrics[1][2][8] A[7]=forward_metrics[1][2][7]
+ A[6]=forward_metrics[1][2][6] A[5]=forward_metrics[1][2][5]
+ A[4]=forward_metrics[1][2][4] A[3]=forward_metrics[1][2][3]
+ A[2]=forward_metrics[1][2][2] A[1]=forward_metrics[1][2][1]
+ A[0]=forward_metrics[1][2][0] B[11]=FE_OFN741_branch_metrics_1__1__11
+ B[10]=FE_OFN742_branch_metrics_1__1__10 B[9]=FE_OFN743_branch_metrics_1__1__9
+ B[8]=branch_metrics[1][1][8] B[7]=FE_OFN745_branch_metrics_1__1__7
+ B[6]=FE_OFN746_branch_metrics_1__1__6 B[5]=branch_metrics[1][1][5]
+ B[4]=branch_metrics[1][1][4] B[3]=branch_metrics[1][1][3]
+ B[2]=FE_OFN750_branch_metrics_1__1__2 B[1]=FE_OFN751_branch_metrics_1__1__1
+ B[0]=branch_metrics[1][1][0] CI=n1 SUM[11]=forward_sum[1][6][11]
+ SUM[10]=forward_sum[1][6][10] SUM[9]=forward_sum[1][6][9]
+ SUM[8]=forward_sum[1][6][8] SUM[7]=forward_sum[1][6][7]
+ SUM[6]=forward_sum[1][6][6] SUM[5]=forward_sum[1][6][5]
+ SUM[4]=forward_sum[1][6][4] SUM[3]=forward_sum[1][6][3]
+ SUM[2]=forward_sum[1][6][2] SUM[1]=forward_sum[1][6][1]
+ SUM[0]=forward_sum[1][6][0]
+ FE_OFN233_branch_metrics_1__1__3=FE_OFN749_branch_metrics_1__1__3
Xadd_111_G2 Siso_DW01_add_278 $PINS A[11]=forward_sum[1][6][11]
+ A[10]=forward_sum[1][6][10] A[9]=forward_sum[1][6][9] A[8]=forward_sum[1][6][8]
+ A[7]=forward_sum[1][6][7] A[6]=forward_sum[1][6][6] A[5]=forward_sum[1][6][5]
+ A[4]=forward_sum[1][6][4] A[3]=forward_sum[1][6][3] A[2]=forward_sum[1][6][2]
+ A[1]=forward_sum[1][6][1] A[0]=forward_sum[1][6][0]
+ B[11]=backward_metrics[5][3][11] B[10]=backward_metrics[5][3][10]
+ B[9]=FE_OFN1240_backward_metrics_5__3__9
+ B[8]=FE_OFN1241_backward_metrics_5__3__8 B[7]=backward_metrics[5][3][7]
+ B[6]=backward_metrics[5][3][6] B[5]=backward_metrics[5][3][5]
+ B[4]=backward_metrics[5][3][4] B[3]=backward_metrics[5][3][3]
+ B[2]=backward_metrics[5][3][2] B[1]=FE_OFN1248_backward_metrics_5__3__1
+ B[0]=FE_OFN1249_backward_metrics_5__3__0 CI=n1 SUM[11]=LLR_sum[1][6][11]
+ SUM[10]=LLR_sum[1][6][10] SUM[9]=LLR_sum[1][6][9] SUM[8]=LLR_sum[1][6][8]
+ SUM[7]=LLR_sum[1][6][7] SUM[6]=LLR_sum[1][6][6] SUM[5]=LLR_sum[1][6][5]
+ SUM[4]=LLR_sum[1][6][4] SUM[3]=LLR_sum[1][6][3] SUM[2]=LLR_sum[1][6][2]
+ SUM[1]=LLR_sum[1][6][1] SUM[0]=LLR_sum[1][6][0]
+ FE_OFN212_backward_metrics_5__3__10=FE_OFN1239_backward_metrics_5__3__10
+ FE_OFN213_backward_metrics_5__3__5=FE_OFN1244_backward_metrics_5__3__5
+ FE_OFN214_backward_metrics_5__3__4=FE_OFN1245_backward_metrics_5__3__4
+ FE_OFN216_backward_metrics_5__3__2=FE_OFN1247_backward_metrics_5__3__2
Xadd_112_G2 Siso_DW01_add_279 $PINS A[11]=forward_sum[1][3][11]
+ A[10]=forward_sum[1][3][10] A[9]=forward_sum[1][3][9] A[8]=forward_sum[1][3][8]
+ A[7]=forward_sum[1][3][7] A[6]=forward_sum[1][3][6] A[5]=forward_sum[1][3][5]
+ A[4]=forward_sum[1][3][4] A[3]=forward_sum[1][3][3] A[2]=forward_sum[1][3][2]
+ A[1]=forward_sum[1][3][1] A[0]=forward_sum[1][3][0]
+ B[11]=FE_OFN1214_backward_metrics_5__1__11
+ B[10]=FE_OFN1215_backward_metrics_5__1__10
+ B[9]=FE_OFN1216_backward_metrics_5__1__9
+ B[8]=FE_OFN1217_backward_metrics_5__1__8
+ B[7]=FE_OFN1218_backward_metrics_5__1__7
+ B[6]=FE_OFN1219_backward_metrics_5__1__6 B[5]=backward_metrics[5][1][5]
+ B[4]=backward_metrics[5][1][4] B[3]=FE_OFN1222_backward_metrics_5__1__3
+ B[2]=backward_metrics[5][1][2] B[1]=backward_metrics[5][1][1]
+ B[0]=backward_metrics[5][1][0] CI=n1 SUM[11]=LLR_sum[1][7][11]
+ SUM[10]=LLR_sum[1][7][10] SUM[9]=LLR_sum[1][7][9] SUM[8]=LLR_sum[1][7][8]
+ SUM[7]=LLR_sum[1][7][7] SUM[6]=LLR_sum[1][7][6] SUM[5]=LLR_sum[1][7][5]
+ SUM[4]=LLR_sum[1][7][4] SUM[3]=LLR_sum[1][7][3] SUM[2]=LLR_sum[1][7][2]
+ SUM[1]=LLR_sum[1][7][1] SUM[0]=LLR_sum[1][7][0]
+ FE_OFN234_backward_metrics_5__1__1=FE_OFN1224_backward_metrics_5__1__1
Xadd_90_G3 Siso_DW01_add_280 $PINS A[11]=forward_metrics[2][3][11]
+ A[10]=forward_metrics[2][3][10] A[9]=forward_metrics[2][3][9]
+ A[8]=forward_metrics[2][3][8] A[7]=forward_metrics[2][3][7]
+ A[6]=forward_metrics[2][3][6] A[5]=forward_metrics[2][3][5]
+ A[4]=forward_metrics[2][3][4] A[3]=forward_metrics[2][3][3]
+ A[2]=forward_metrics[2][3][2] A[1]=forward_metrics[2][3][1]
+ A[0]=forward_metrics[2][3][0] B[11]=branch_metrics[2][2][11]
+ B[10]=FE_OFN802_branch_metrics_2__2__10 B[9]=FE_OFN803_branch_metrics_2__2__9
+ B[8]=branch_metrics[2][2][8] B[7]=branch_metrics[2][2][7]
+ B[6]=branch_metrics[2][2][6] B[5]=FE_OFN807_branch_metrics_2__2__5
+ B[4]=branch_metrics[2][2][4] B[3]=branch_metrics[2][2][3]
+ B[2]=FE_OFN810_branch_metrics_2__2__2 B[1]=branch_metrics[2][2][1]
+ B[0]=branch_metrics[2][2][0] CI=n1 SUM[11]=forward_sum[2][3][11]
+ SUM[10]=forward_sum[2][3][10] SUM[9]=forward_sum[2][3][9]
+ SUM[8]=forward_sum[2][3][8] SUM[7]=forward_sum[2][3][7]
+ SUM[6]=forward_sum[2][3][6] SUM[5]=forward_sum[2][3][5]
+ SUM[4]=forward_sum[2][3][4] SUM[3]=forward_sum[2][3][3]
+ SUM[2]=forward_sum[2][3][2] SUM[1]=forward_sum[2][3][1]
+ SUM[0]=forward_sum[2][3][0]
Xadd_93_G3 Siso_DW01_add_281 $PINS A[11]=forward_metrics[2][2][11]
+ A[10]=forward_metrics[2][2][10] A[9]=forward_metrics[2][2][9]
+ A[8]=forward_metrics[2][2][8] A[7]=forward_metrics[2][2][7]
+ A[6]=forward_metrics[2][2][6] A[5]=forward_metrics[2][2][5]
+ A[4]=forward_metrics[2][2][4] A[3]=forward_metrics[2][2][3]
+ A[2]=forward_metrics[2][2][2] A[1]=forward_metrics[2][2][1]
+ A[0]=forward_metrics[2][2][0] B[11]=branch_metrics[2][1][11]
+ B[10]=FE_OFN790_branch_metrics_2__1__10 B[9]=branch_metrics[2][1][9]
+ B[8]=FE_OFN792_branch_metrics_2__1__8 B[7]=FE_OFN793_branch_metrics_2__1__7
+ B[6]=FE_OFN794_branch_metrics_2__1__6 B[5]=branch_metrics[2][1][5]
+ B[4]=branch_metrics[2][1][4] B[3]=branch_metrics[2][1][3]
+ B[2]=FE_OFN798_branch_metrics_2__1__2 B[1]=FE_OFN799_branch_metrics_2__1__1
+ B[0]=branch_metrics[2][1][0] CI=n1 SUM[11]=forward_sum[2][6][11]
+ SUM[10]=forward_sum[2][6][10] SUM[9]=forward_sum[2][6][9]
+ SUM[8]=forward_sum[2][6][8] SUM[7]=forward_sum[2][6][7]
+ SUM[6]=forward_sum[2][6][6] SUM[5]=forward_sum[2][6][5]
+ SUM[4]=forward_sum[2][6][4] SUM[3]=forward_sum[2][6][3]
+ SUM[2]=forward_sum[2][6][2] SUM[1]=forward_sum[2][6][1]
+ SUM[0]=forward_sum[2][6][0]
Xadd_111_G3 Siso_DW01_add_282 $PINS A[11]=forward_sum[2][6][11]
+ A[10]=forward_sum[2][6][10] A[9]=forward_sum[2][6][9] A[8]=forward_sum[2][6][8]
+ A[7]=forward_sum[2][6][7] A[6]=forward_sum[2][6][6] A[5]=forward_sum[2][6][5]
+ A[4]=forward_sum[2][6][4] A[3]=forward_sum[2][6][3] A[2]=forward_sum[2][6][2]
+ A[1]=forward_sum[2][6][1] A[0]=forward_sum[2][6][0]
+ B[11]=FE_OFN1190_backward_metrics_4__3__11
+ B[10]=FE_OFN1191_backward_metrics_4__3__10 B[9]=backward_metrics[4][3][9]
+ B[8]=FE_OFN1193_backward_metrics_4__3__8
+ B[7]=FE_OFN1194_backward_metrics_4__3__7
+ B[6]=FE_OFN1195_backward_metrics_4__3__6 B[5]=backward_metrics[4][3][5]
+ B[4]=backward_metrics[4][3][4] B[3]=FE_OFN1198_backward_metrics_4__3__3
+ B[2]=backward_metrics[4][3][2] B[1]=backward_metrics[4][3][1]
+ B[0]=FE_OFN1201_backward_metrics_4__3__0 CI=n1 SUM[11]=LLR_sum[2][6][11]
+ SUM[10]=LLR_sum[2][6][10] SUM[9]=LLR_sum[2][6][9] SUM[8]=LLR_sum[2][6][8]
+ SUM[7]=LLR_sum[2][6][7] SUM[6]=LLR_sum[2][6][6] SUM[5]=LLR_sum[2][6][5]
+ SUM[4]=LLR_sum[2][6][4] SUM[3]=LLR_sum[2][6][3] SUM[2]=LLR_sum[2][6][2]
+ SUM[1]=LLR_sum[2][6][1] SUM[0]=LLR_sum[2][6][0]
+ FE_OFN206_backward_metrics_4__3__9=FE_OFN1192_backward_metrics_4__3__9
+ FE_OFN207_backward_metrics_4__3__4=FE_OFN1197_backward_metrics_4__3__4
Xadd_112_G3 Siso_DW01_add_283 $PINS A[11]=forward_sum[2][3][11]
+ A[10]=forward_sum[2][3][10] A[9]=forward_sum[2][3][9] A[8]=forward_sum[2][3][8]
+ A[7]=forward_sum[2][3][7] A[6]=forward_sum[2][3][6] A[5]=forward_sum[2][3][5]
+ A[4]=forward_sum[2][3][4] A[3]=forward_sum[2][3][3] A[2]=forward_sum[2][3][2]
+ A[1]=forward_sum[2][3][1] A[0]=forward_sum[2][3][0]
+ B[11]=FE_OFN1166_backward_metrics_4__1__11
+ B[10]=FE_OFN1167_backward_metrics_4__1__10
+ B[9]=FE_OFN1168_backward_metrics_4__1__9
+ B[8]=FE_OFN1169_backward_metrics_4__1__8
+ B[7]=FE_OFN1170_backward_metrics_4__1__7
+ B[6]=FE_OFN1171_backward_metrics_4__1__6 B[5]=backward_metrics[4][1][5]
+ B[4]=backward_metrics[4][1][4] B[3]=backward_metrics[4][1][3]
+ B[2]=backward_metrics[4][1][2] B[1]=backward_metrics[4][1][1]
+ B[0]=FE_OFN1177_backward_metrics_4__1__0 CI=n1 SUM[11]=LLR_sum[2][7][11]
+ SUM[10]=LLR_sum[2][7][10] SUM[9]=LLR_sum[2][7][9] SUM[8]=LLR_sum[2][7][8]
+ SUM[7]=LLR_sum[2][7][7] SUM[6]=LLR_sum[2][7][6] SUM[5]=LLR_sum[2][7][5]
+ SUM[4]=LLR_sum[2][7][4] SUM[3]=LLR_sum[2][7][3] SUM[2]=LLR_sum[2][7][2]
+ SUM[1]=LLR_sum[2][7][1] SUM[0]=LLR_sum[2][7][0]
Xadd_90_G4 Siso_DW01_add_284 $PINS A[11]=forward_metrics[3][3][11]
+ A[10]=forward_metrics[3][3][10] A[9]=forward_metrics[3][3][9]
+ A[8]=forward_metrics[3][3][8] A[7]=forward_metrics[3][3][7]
+ A[6]=forward_metrics[3][3][6] A[5]=forward_metrics[3][3][5]
+ A[4]=forward_metrics[3][3][4] A[3]=forward_metrics[3][3][3]
+ A[2]=forward_metrics[3][3][2] A[1]=forward_metrics[3][3][1]
+ A[0]=forward_metrics[3][3][0] B[11]=FE_OFN849_branch_metrics_3__2__11
+ B[10]=FE_OFN850_branch_metrics_3__2__10 B[9]=branch_metrics[3][2][9]
+ B[8]=FE_OFN852_branch_metrics_3__2__8 B[7]=branch_metrics[3][2][7]
+ B[6]=branch_metrics[3][2][6] B[5]=branch_metrics[3][2][5]
+ B[4]=branch_metrics[3][2][4] B[3]=branch_metrics[3][2][3]
+ B[2]=branch_metrics[3][2][2] B[1]=branch_metrics[3][2][1]
+ B[0]=branch_metrics[3][2][0] CI=n1 SUM[11]=forward_sum[3][3][11]
+ SUM[10]=forward_sum[3][3][10] SUM[9]=forward_sum[3][3][9]
+ SUM[8]=forward_sum[3][3][8] SUM[7]=forward_sum[3][3][7]
+ SUM[6]=forward_sum[3][3][6] SUM[5]=forward_sum[3][3][5]
+ SUM[4]=forward_sum[3][3][4] SUM[3]=forward_sum[3][3][3]
+ SUM[2]=forward_sum[3][3][2] SUM[1]=forward_sum[3][3][1]
+ SUM[0]=forward_sum[3][3][0]
Xadd_93_G4 Siso_DW01_add_285 $PINS A[11]=forward_metrics[3][2][11]
+ A[10]=forward_metrics[3][2][10] A[9]=forward_metrics[3][2][9]
+ A[8]=forward_metrics[3][2][8] A[7]=forward_metrics[3][2][7]
+ A[6]=forward_metrics[3][2][6] A[5]=forward_metrics[3][2][5]
+ A[4]=forward_metrics[3][2][4] A[3]=forward_metrics[3][2][3]
+ A[2]=forward_metrics[3][2][2] A[1]=forward_metrics[3][2][1]
+ A[0]=forward_metrics[3][2][0] B[11]=FE_OFN837_branch_metrics_3__1__11
+ B[10]=FE_OFN838_branch_metrics_3__1__10 B[9]=branch_metrics[3][1][9]
+ B[8]=FE_OFN840_branch_metrics_3__1__8 B[7]=branch_metrics[3][1][7]
+ B[6]=branch_metrics[3][1][6] B[5]=branch_metrics[3][1][5]
+ B[4]=branch_metrics[3][1][4] B[3]=branch_metrics[3][1][3]
+ B[2]=FE_OFN846_branch_metrics_3__1__2 B[1]=FE_OFN847_branch_metrics_3__1__1
+ B[0]=FE_OFN848_branch_metrics_3__1__0 CI=n1 SUM[11]=forward_sum[3][6][11]
+ SUM[10]=forward_sum[3][6][10] SUM[9]=forward_sum[3][6][9]
+ SUM[8]=forward_sum[3][6][8] SUM[7]=forward_sum[3][6][7]
+ SUM[6]=forward_sum[3][6][6] SUM[5]=forward_sum[3][6][5]
+ SUM[4]=forward_sum[3][6][4] SUM[3]=forward_sum[3][6][3]
+ SUM[2]=forward_sum[3][6][2] SUM[1]=forward_sum[3][6][1]
+ SUM[0]=forward_sum[3][6][0]
Xadd_111_G4 Siso_DW01_add_286 $PINS A[11]=forward_sum[3][6][11]
+ A[10]=forward_sum[3][6][10] A[9]=forward_sum[3][6][9] A[8]=forward_sum[3][6][8]
+ A[7]=forward_sum[3][6][7] A[6]=forward_sum[3][6][6] A[5]=forward_sum[3][6][5]
+ A[4]=forward_sum[3][6][4] A[3]=forward_sum[3][6][3] A[2]=forward_sum[3][6][2]
+ A[1]=forward_sum[3][6][1] A[0]=forward_sum[3][6][0]
+ B[11]=FE_OFN1142_backward_metrics_3__3__11
+ B[10]=FE_OFN1143_backward_metrics_3__3__10
+ B[9]=FE_OFN1144_backward_metrics_3__3__9
+ B[8]=FE_OFN1145_backward_metrics_3__3__8
+ B[7]=FE_OFN1146_backward_metrics_3__3__7
+ B[6]=FE_OFN1147_backward_metrics_3__3__6 B[5]=backward_metrics[3][3][5]
+ B[4]=backward_metrics[3][3][4] B[3]=backward_metrics[3][3][3]
+ B[2]=backward_metrics[3][3][2] B[1]=backward_metrics[3][3][1]
+ B[0]=backward_metrics[3][3][0] CI=n1 SUM[11]=LLR_sum[3][6][11]
+ SUM[10]=LLR_sum[3][6][10] SUM[9]=LLR_sum[3][6][9] SUM[8]=LLR_sum[3][6][8]
+ SUM[7]=LLR_sum[3][6][7] SUM[6]=LLR_sum[3][6][6] SUM[5]=LLR_sum[3][6][5]
+ SUM[4]=LLR_sum[3][6][4] SUM[3]=LLR_sum[3][6][3] SUM[2]=LLR_sum[3][6][2]
+ SUM[1]=LLR_sum[3][6][1] SUM[0]=LLR_sum[3][6][0]
Xadd_112_G4 Siso_DW01_add_287 $PINS A[11]=forward_sum[3][3][11]
+ A[10]=forward_sum[3][3][10] A[9]=forward_sum[3][3][9] A[8]=forward_sum[3][3][8]
+ A[7]=forward_sum[3][3][7] A[6]=forward_sum[3][3][6] A[5]=forward_sum[3][3][5]
+ A[4]=forward_sum[3][3][4] A[3]=forward_sum[3][3][3] A[2]=forward_sum[3][3][2]
+ A[1]=forward_sum[3][3][1] A[0]=forward_sum[3][3][0]
+ B[11]=FE_OFN1118_backward_metrics_3__1__11
+ B[10]=FE_OFN1119_backward_metrics_3__1__10
+ B[9]=FE_OFN1120_backward_metrics_3__1__9 B[8]=backward_metrics[3][1][8]
+ B[7]=backward_metrics[3][1][7] B[6]=backward_metrics[3][1][6]
+ B[5]=FE_OFN1124_backward_metrics_3__1__5 B[4]=backward_metrics[3][1][4]
+ B[3]=backward_metrics[3][1][3] B[2]=backward_metrics[3][1][2]
+ B[1]=backward_metrics[3][1][1] B[0]=FE_OFN1129_backward_metrics_3__1__0 CI=n1
+ SUM[11]=LLR_sum[3][7][11] SUM[10]=LLR_sum[3][7][10] SUM[9]=LLR_sum[3][7][9]
+ SUM[8]=LLR_sum[3][7][8] SUM[7]=LLR_sum[3][7][7] SUM[6]=LLR_sum[3][7][6]
+ SUM[5]=LLR_sum[3][7][5] SUM[4]=LLR_sum[3][7][4] SUM[3]=LLR_sum[3][7][3]
+ SUM[2]=LLR_sum[3][7][2] SUM[1]=LLR_sum[3][7][1] SUM[0]=LLR_sum[3][7][0]
Xadd_90_G5 Siso_DW01_add_288 $PINS A[11]=forward_metrics[4][3][11]
+ A[10]=forward_metrics[4][3][10] A[9]=forward_metrics[4][3][9]
+ A[8]=forward_metrics[4][3][8] A[7]=forward_metrics[4][3][7]
+ A[6]=forward_metrics[4][3][6] A[5]=forward_metrics[4][3][5]
+ A[4]=forward_metrics[4][3][4] A[3]=forward_metrics[4][3][3]
+ A[2]=forward_metrics[4][3][2] A[1]=forward_metrics[4][3][1]
+ A[0]=forward_metrics[4][3][0] B[11]=FE_OFN897_branch_metrics_4__2__11
+ B[10]=FE_OFN898_branch_metrics_4__2__10 B[9]=branch_metrics[4][2][9]
+ B[8]=branch_metrics[4][2][8] B[7]=branch_metrics[4][2][7]
+ B[6]=branch_metrics[4][2][6] B[5]=FE_OFN903_branch_metrics_4__2__5
+ B[4]=branch_metrics[4][2][4] B[3]=branch_metrics[4][2][3]
+ B[2]=FE_OFN906_branch_metrics_4__2__2 B[1]=FE_OFN907_branch_metrics_4__2__1
+ B[0]=branch_metrics[4][2][0] CI=n1 SUM[11]=forward_sum[4][3][11]
+ SUM[10]=forward_sum[4][3][10] SUM[9]=forward_sum[4][3][9]
+ SUM[8]=forward_sum[4][3][8] SUM[7]=forward_sum[4][3][7]
+ SUM[6]=forward_sum[4][3][6] SUM[5]=forward_sum[4][3][5]
+ SUM[4]=forward_sum[4][3][4] SUM[3]=forward_sum[4][3][3]
+ SUM[2]=forward_sum[4][3][2] SUM[1]=forward_sum[4][3][1]
+ SUM[0]=forward_sum[4][3][0]
+ FE_OFN168_branch_metrics_4__2__9=FE_OFN899_branch_metrics_4__2__9
+ FE_OFN169_branch_metrics_4__2__7=FE_OFN901_branch_metrics_4__2__7
Xadd_93_G5 Siso_DW01_add_289 $PINS A[11]=forward_metrics[4][2][11]
+ A[10]=forward_metrics[4][2][10] A[9]=forward_metrics[4][2][9]
+ A[8]=forward_metrics[4][2][8] A[7]=forward_metrics[4][2][7]
+ A[6]=forward_metrics[4][2][6] A[5]=forward_metrics[4][2][5]
+ A[4]=forward_metrics[4][2][4] A[3]=forward_metrics[4][2][3]
+ A[2]=forward_metrics[4][2][2] A[1]=forward_metrics[4][2][1]
+ A[0]=forward_metrics[4][2][0] B[11]=branch_metrics[4][1][11]
+ B[10]=FE_OFN886_branch_metrics_4__1__10 B[9]=branch_metrics[4][1][9]
+ B[8]=branch_metrics[4][1][8] B[7]=branch_metrics[4][1][7]
+ B[6]=branch_metrics[4][1][6] B[5]=branch_metrics[4][1][5]
+ B[4]=branch_metrics[4][1][4] B[3]=branch_metrics[4][1][3]
+ B[2]=branch_metrics[4][1][2] B[1]=branch_metrics[4][1][1]
+ B[0]=branch_metrics[4][1][0] CI=n1 SUM[11]=forward_sum[4][6][11]
+ SUM[10]=forward_sum[4][6][10] SUM[9]=forward_sum[4][6][9]
+ SUM[8]=forward_sum[4][6][8] SUM[7]=forward_sum[4][6][7]
+ SUM[6]=forward_sum[4][6][6] SUM[5]=forward_sum[4][6][5]
+ SUM[4]=forward_sum[4][6][4] SUM[3]=forward_sum[4][6][3]
+ SUM[2]=forward_sum[4][6][2] SUM[1]=forward_sum[4][6][1]
+ SUM[0]=forward_sum[4][6][0]
+ FE_OFN167_branch_metrics_4__1__7=FE_OFN889_branch_metrics_4__1__7
Xadd_111_G5 Siso_DW01_add_290 $PINS A[11]=forward_sum[4][6][11]
+ A[10]=forward_sum[4][6][10] A[9]=forward_sum[4][6][9] A[8]=forward_sum[4][6][8]
+ A[7]=forward_sum[4][6][7] A[6]=forward_sum[4][6][6] A[5]=forward_sum[4][6][5]
+ A[4]=forward_sum[4][6][4] A[3]=forward_sum[4][6][3] A[2]=forward_sum[4][6][2]
+ A[1]=forward_sum[4][6][1] A[0]=forward_sum[4][6][0]
+ B[11]=FE_OFN1094_backward_metrics_2__3__11
+ B[10]=FE_OFN1095_backward_metrics_2__3__10 B[9]=backward_metrics[2][3][9]
+ B[8]=FE_OFN1097_backward_metrics_2__3__8 B[7]=backward_metrics[2][3][7]
+ B[6]=backward_metrics[2][3][6] B[5]=backward_metrics[2][3][5]
+ B[4]=backward_metrics[2][3][4] B[3]=backward_metrics[2][3][3]
+ B[2]=backward_metrics[2][3][2] B[1]=backward_metrics[2][3][1]
+ B[0]=backward_metrics[2][3][0] CI=n1 SUM[11]=LLR_sum[4][6][11]
+ SUM[10]=LLR_sum[4][6][10] SUM[9]=LLR_sum[4][6][9] SUM[8]=LLR_sum[4][6][8]
+ SUM[7]=LLR_sum[4][6][7] SUM[6]=LLR_sum[4][6][6] SUM[5]=LLR_sum[4][6][5]
+ SUM[4]=LLR_sum[4][6][4] SUM[3]=LLR_sum[4][6][3] SUM[2]=LLR_sum[4][6][2]
+ SUM[1]=LLR_sum[4][6][1] SUM[0]=LLR_sum[4][6][0]
Xadd_112_G5 Siso_DW01_add_291 $PINS A[11]=forward_sum[4][3][11]
+ A[10]=forward_sum[4][3][10] A[9]=forward_sum[4][3][9] A[8]=forward_sum[4][3][8]
+ A[7]=forward_sum[4][3][7] A[6]=forward_sum[4][3][6] A[5]=forward_sum[4][3][5]
+ A[4]=forward_sum[4][3][4] A[3]=forward_sum[4][3][3] A[2]=forward_sum[4][3][2]
+ A[1]=forward_sum[4][3][1] A[0]=forward_sum[4][3][0]
+ B[11]=FE_OFN1070_backward_metrics_2__1__11 B[10]=backward_metrics[2][1][10]
+ B[9]=FE_OFN1072_backward_metrics_2__1__9
+ B[8]=FE_OFN1073_backward_metrics_2__1__8
+ B[7]=FE_OFN1074_backward_metrics_2__1__7
+ B[6]=FE_OFN1075_backward_metrics_2__1__6 B[5]=backward_metrics[2][1][5]
+ B[4]=backward_metrics[2][1][4] B[3]=backward_metrics[2][1][3]
+ B[2]=FE_OFN1079_backward_metrics_2__1__2 B[1]=backward_metrics[2][1][1]
+ B[0]=backward_metrics[2][1][0] CI=n1 SUM[11]=LLR_sum[4][7][11]
+ SUM[10]=LLR_sum[4][7][10] SUM[9]=LLR_sum[4][7][9] SUM[8]=LLR_sum[4][7][8]
+ SUM[7]=LLR_sum[4][7][7] SUM[6]=LLR_sum[4][7][6] SUM[5]=LLR_sum[4][7][5]
+ SUM[4]=LLR_sum[4][7][4] SUM[3]=LLR_sum[4][7][3] SUM[2]=LLR_sum[4][7][2]
+ SUM[1]=LLR_sum[4][7][1] SUM[0]=LLR_sum[4][7][0]
+ FE_OFN237_backward_metrics_2__1__0=FE_OFN1081_backward_metrics_2__1__0
Xadd_90_G6 Siso_DW01_add_292 $PINS A[11]=forward_metrics[5][3][11]
+ A[10]=forward_metrics[5][3][10] A[9]=forward_metrics[5][3][9]
+ A[8]=forward_metrics[5][3][8] A[7]=forward_metrics[5][3][7]
+ A[6]=forward_metrics[5][3][6] A[5]=forward_metrics[5][3][5]
+ A[4]=forward_metrics[5][3][4] A[3]=forward_metrics[5][3][3]
+ A[2]=forward_metrics[5][3][2] A[1]=forward_metrics[5][3][1]
+ A[0]=forward_metrics[5][3][0] B[11]=branch_metrics[5][2][11]
+ B[10]=FE_OFN945_branch_metrics_5__2__10 B[9]=FE_OFN946_branch_metrics_5__2__9
+ B[8]=branch_metrics[5][2][8] B[7]=branch_metrics[5][2][7]
+ B[6]=FE_OFN949_branch_metrics_5__2__6 B[5]=branch_metrics[5][2][5]
+ B[4]=branch_metrics[5][2][4] B[3]=branch_metrics[5][2][3]
+ B[2]=branch_metrics[5][2][2] B[1]=branch_metrics[5][2][1]
+ B[0]=branch_metrics[5][2][0] CI=n1 SUM[11]=forward_sum[5][3][11]
+ SUM[10]=forward_sum[5][3][10] SUM[9]=forward_sum[5][3][9]
+ SUM[8]=forward_sum[5][3][8] SUM[7]=forward_sum[5][3][7]
+ SUM[6]=forward_sum[5][3][6] SUM[5]=forward_sum[5][3][5]
+ SUM[4]=forward_sum[5][3][4] SUM[3]=forward_sum[5][3][3]
+ SUM[2]=forward_sum[5][3][2] SUM[1]=forward_sum[5][3][1]
+ SUM[0]=forward_sum[5][3][0]
+ FE_OFN173_branch_metrics_5__2__8=FE_OFN947_branch_metrics_5__2__8
Xadd_93_G6 Siso_DW01_add_293 $PINS A[11]=forward_metrics[5][2][11]
+ A[10]=forward_metrics[5][2][10] A[9]=forward_metrics[5][2][9]
+ A[8]=forward_metrics[5][2][8] A[7]=forward_metrics[5][2][7]
+ A[6]=forward_metrics[5][2][6] A[5]=forward_metrics[5][2][5]
+ A[4]=forward_metrics[5][2][4] A[3]=forward_metrics[5][2][3]
+ A[2]=forward_metrics[5][2][2] A[1]=forward_metrics[5][2][1]
+ A[0]=forward_metrics[5][2][0] B[11]=FE_OFN933_branch_metrics_5__1__11
+ B[10]=branch_metrics[5][1][10] B[9]=branch_metrics[5][1][9]
+ B[8]=branch_metrics[5][1][8] B[7]=FE_OFN937_branch_metrics_5__1__7
+ B[6]=branch_metrics[5][1][6] B[5]=branch_metrics[5][1][5]
+ B[4]=branch_metrics[5][1][4] B[3]=branch_metrics[5][1][3]
+ B[2]=FE_OFN942_branch_metrics_5__1__2 B[1]=FE_OFN943_branch_metrics_5__1__1
+ B[0]=FE_OFN1359_n1434 CI=n1 SUM[11]=forward_sum[5][6][11]
+ SUM[10]=forward_sum[5][6][10] SUM[9]=forward_sum[5][6][9]
+ SUM[8]=forward_sum[5][6][8] SUM[7]=forward_sum[5][6][7]
+ SUM[6]=forward_sum[5][6][6] SUM[5]=forward_sum[5][6][5]
+ SUM[4]=forward_sum[5][6][4] SUM[3]=forward_sum[5][6][3]
+ SUM[2]=forward_sum[5][6][2] SUM[1]=forward_sum[5][6][1]
+ SUM[0]=forward_sum[5][6][0]
Xadd_111_G6 Siso_DW01_add_294 $PINS A[11]=forward_sum[5][6][11]
+ A[10]=forward_sum[5][6][10] A[9]=forward_sum[5][6][9] A[8]=forward_sum[5][6][8]
+ A[7]=forward_sum[5][6][7] A[6]=forward_sum[5][6][6] A[5]=forward_sum[5][6][5]
+ A[4]=forward_sum[5][6][4] A[3]=forward_sum[5][6][3] A[2]=forward_sum[5][6][2]
+ A[1]=forward_sum[5][6][1] A[0]=forward_sum[5][6][0]
+ B[11]=FE_OFN1046_backward_metrics_1__3__11
+ B[10]=FE_OFN1047_backward_metrics_1__3__10 B[9]=backward_metrics[1][3][9]
+ B[8]=FE_OFN1049_backward_metrics_1__3__8 B[7]=backward_metrics[1][3][7]
+ B[6]=backward_metrics[1][3][6] B[5]=backward_metrics[1][3][5]
+ B[4]=backward_metrics[1][3][4] B[3]=backward_metrics[1][3][3]
+ B[2]=FE_OFN1055_backward_metrics_1__3__2 B[1]=backward_metrics[1][3][1]
+ B[0]=FE_OFN1057_backward_metrics_1__3__0 CI=n1 SUM[11]=LLR_sum[5][6][11]
+ SUM[10]=LLR_sum[5][6][10] SUM[9]=LLR_sum[5][6][9] SUM[8]=LLR_sum[5][6][8]
+ SUM[7]=LLR_sum[5][6][7] SUM[6]=LLR_sum[5][6][6] SUM[5]=LLR_sum[5][6][5]
+ SUM[4]=LLR_sum[5][6][4] SUM[3]=LLR_sum[5][6][3] SUM[2]=LLR_sum[5][6][2]
+ SUM[1]=LLR_sum[5][6][1] SUM[0]=LLR_sum[5][6][0]
+ FE_OFN190_backward_metrics_1__3__9=FE_OFN1048_backward_metrics_1__3__9
Xadd_112_G6 Siso_DW01_add_295 $PINS A[11]=forward_sum[5][3][11]
+ A[10]=forward_sum[5][3][10] A[9]=forward_sum[5][3][9] A[8]=forward_sum[5][3][8]
+ A[7]=forward_sum[5][3][7] A[6]=forward_sum[5][3][6] A[5]=forward_sum[5][3][5]
+ A[4]=forward_sum[5][3][4] A[3]=forward_sum[5][3][3] A[2]=forward_sum[5][3][2]
+ A[1]=forward_sum[5][3][1] A[0]=forward_sum[5][3][0]
+ B[11]=FE_OFN1022_backward_metrics_1__1__11 B[10]=backward_metrics[1][1][10]
+ B[9]=FE_OFN1024_backward_metrics_1__1__9
+ B[8]=FE_OFN1025_backward_metrics_1__1__8 B[7]=backward_metrics[1][1][7]
+ B[6]=FE_OFN1027_backward_metrics_1__1__6 B[5]=backward_metrics[1][1][5]
+ B[4]=backward_metrics[1][1][4] B[3]=backward_metrics[1][1][3]
+ B[2]=FE_OFN1031_backward_metrics_1__1__2
+ B[1]=FE_OFN1032_backward_metrics_1__1__1
+ B[0]=FE_OFN5642_backward_metrics_1__1__0 CI=n1 SUM[11]=LLR_sum[5][7][11]
+ SUM[10]=LLR_sum[5][7][10] SUM[9]=LLR_sum[5][7][9] SUM[8]=LLR_sum[5][7][8]
+ SUM[7]=LLR_sum[5][7][7] SUM[6]=LLR_sum[5][7][6] SUM[5]=LLR_sum[5][7][5]
+ SUM[4]=LLR_sum[5][7][4] SUM[3]=LLR_sum[5][7][3] SUM[2]=LLR_sum[5][7][2]
+ SUM[1]=LLR_sum[5][7][1] SUM[0]=LLR_sum[5][7][0]
Xadd_87_G2 Siso_DW01_add_296 $PINS A[11]=forward_metrics[1][0][11]
+ A[10]=forward_metrics[1][0][10] A[9]=forward_metrics[1][0][9]
+ A[8]=forward_metrics[1][0][8] A[7]=forward_metrics[1][0][7]
+ A[6]=forward_metrics[1][0][6] A[5]=forward_metrics[1][0][5]
+ A[4]=forward_metrics[1][0][4] A[3]=forward_metrics[1][0][3]
+ A[2]=forward_metrics[1][0][2] A[1]=forward_metrics[1][0][1]
+ A[0]=forward_metrics[1][0][0] B[11]=branch_metrics[1][0][11]
+ B[10]=FE_OFN730_branch_metrics_1__0__10 B[9]=branch_metrics[1][0][9]
+ B[8]=FE_OFN732_branch_metrics_1__0__8 B[7]=branch_metrics[1][0][7]
+ B[6]=branch_metrics[1][0][6] B[5]=FE_OFN735_branch_metrics_1__0__5
+ B[4]=branch_metrics[1][0][4] B[3]=branch_metrics[1][0][3]
+ B[2]=FE_OFN738_branch_metrics_1__0__2 B[1]=FE_OFN739_branch_metrics_1__0__1
+ B[0]=branch_metrics[1][0][0] CI=n1 SUM[11]=forward_sum[1][0][11]
+ SUM[10]=forward_sum[1][0][10] SUM[9]=forward_sum[1][0][9]
+ SUM[8]=forward_sum[1][0][8] SUM[7]=forward_sum[1][0][7]
+ SUM[6]=forward_sum[1][0][6] SUM[5]=forward_sum[1][0][5]
+ SUM[4]=forward_sum[1][0][4] SUM[3]=forward_sum[1][0][3]
+ SUM[2]=forward_sum[1][0][2] SUM[1]=forward_sum[1][0][1]
+ SUM[0]=forward_sum[1][0][0]
+ FE_OFN151_branch_metrics_1__0__0=FE_OFN740_branch_metrics_1__0__0
Xadd_92_G2 Siso_DW01_add_297 $PINS A[11]=forward_metrics[1][1][11]
+ A[10]=forward_metrics[1][1][10] A[9]=forward_metrics[1][1][9]
+ A[8]=forward_metrics[1][1][8] A[7]=forward_metrics[1][1][7]
+ A[6]=forward_metrics[1][1][6] A[5]=forward_metrics[1][1][5]
+ A[4]=forward_metrics[1][1][4] A[3]=forward_metrics[1][1][3]
+ A[2]=forward_metrics[1][1][2] A[1]=forward_metrics[1][1][1]
+ A[0]=forward_metrics[1][1][0] B[11]=FE_OFN765_branch_metrics_1__3__11
+ B[10]=branch_metrics[1][3][10] B[9]=FE_OFN767_branch_metrics_1__3__9
+ B[8]=FE_OFN768_branch_metrics_1__3__8 B[7]=FE_OFN769_branch_metrics_1__3__7
+ B[6]=branch_metrics[1][3][6] B[5]=branch_metrics[1][3][5]
+ B[4]=branch_metrics[1][3][4] B[3]=FE_OFN773_branch_metrics_1__3__3
+ B[2]=branch_metrics[1][3][2] B[1]=FE_OFN775_branch_metrics_1__3__1
+ B[0]=FE_OFN776_branch_metrics_1__3__0 CI=n1 SUM[11]=forward_sum[1][5][11]
+ SUM[10]=forward_sum[1][5][10] SUM[9]=forward_sum[1][5][9]
+ SUM[8]=forward_sum[1][5][8] SUM[7]=forward_sum[1][5][7]
+ SUM[6]=forward_sum[1][5][6] SUM[5]=forward_sum[1][5][5]
+ SUM[4]=forward_sum[1][5][4] SUM[3]=forward_sum[1][5][3]
+ SUM[2]=forward_sum[1][5][2] SUM[1]=forward_sum[1][5][1]
+ SUM[0]=forward_sum[1][5][0]
+ FE_OFN157_branch_metrics_1__3__5=branch_metrics[1][3][5]
Xadd_105_G2 Siso_DW01_add_298 $PINS A[11]=forward_sum[1][0][11]
+ A[10]=forward_sum[1][0][10] A[9]=forward_sum[1][0][9] A[8]=forward_sum[1][0][8]
+ A[7]=forward_sum[1][0][7] A[6]=forward_sum[1][0][6] A[5]=forward_sum[1][0][5]
+ A[4]=forward_sum[1][0][4] A[3]=forward_sum[1][0][3] A[2]=forward_sum[1][0][2]
+ A[1]=forward_sum[1][0][1] A[0]=forward_sum[1][0][0]
+ B[11]=FE_OFN1202_backward_metrics_5__0__11
+ B[10]=FE_OFN1203_backward_metrics_5__0__10
+ B[9]=FE_OFN1204_backward_metrics_5__0__9
+ B[8]=FE_OFN1205_backward_metrics_5__0__8
+ B[7]=FE_OFN1206_backward_metrics_5__0__7 B[6]=backward_metrics[5][0][6]
+ B[5]=backward_metrics[5][0][5] B[4]=backward_metrics[5][0][4]
+ B[3]=FE_OFN1210_backward_metrics_5__0__3
+ B[2]=FE_OFN1211_backward_metrics_5__0__2 B[1]=backward_metrics[5][0][1]
+ B[0]=backward_metrics[5][0][0] CI=n1 SUM[11]=LLR_sum[1][0][11]
+ SUM[10]=LLR_sum[1][0][10] SUM[9]=LLR_sum[1][0][9] SUM[8]=LLR_sum[1][0][8]
+ SUM[7]=LLR_sum[1][0][7] SUM[6]=LLR_sum[1][0][6] SUM[5]=LLR_sum[1][0][5]
+ SUM[4]=LLR_sum[1][0][4] SUM[3]=LLR_sum[1][0][3] SUM[2]=LLR_sum[1][0][2]
+ SUM[1]=LLR_sum[1][0][1] SUM[0]=LLR_sum[1][0][0]
Xadd_106_G2 Siso_DW01_add_299 $PINS A[11]=forward_sum[1][5][11]
+ A[10]=forward_sum[1][5][10] A[9]=forward_sum[1][5][9] A[8]=forward_sum[1][5][8]
+ A[7]=forward_sum[1][5][7] A[6]=forward_sum[1][5][6] A[5]=forward_sum[1][5][5]
+ A[4]=forward_sum[1][5][4] A[3]=forward_sum[1][5][3] A[2]=forward_sum[1][5][2]
+ A[1]=forward_sum[1][5][1] A[0]=forward_sum[1][5][0]
+ B[11]=FE_OFN1226_backward_metrics_5__2__11
+ B[10]=FE_OFN1227_backward_metrics_5__2__10
+ B[9]=FE_OFN1228_backward_metrics_5__2__9
+ B[8]=FE_OFN1229_backward_metrics_5__2__8 B[7]=backward_metrics[5][2][7]
+ B[6]=FE_OFN1231_backward_metrics_5__2__6 B[5]=backward_metrics[5][2][5]
+ B[4]=backward_metrics[5][2][4] B[3]=FE_OFN1234_backward_metrics_5__2__3
+ B[2]=FE_OFN1235_backward_metrics_5__2__2 B[1]=backward_metrics[5][2][1]
+ B[0]=FE_OFN1237_backward_metrics_5__2__0 CI=n1 SUM[11]=LLR_sum[1][1][11]
+ SUM[10]=LLR_sum[1][1][10] SUM[9]=LLR_sum[1][1][9] SUM[8]=LLR_sum[1][1][8]
+ SUM[7]=LLR_sum[1][1][7] SUM[6]=LLR_sum[1][1][6] SUM[5]=LLR_sum[1][1][5]
+ SUM[4]=LLR_sum[1][1][4] SUM[3]=LLR_sum[1][1][3] SUM[2]=LLR_sum[1][1][2]
+ SUM[1]=LLR_sum[1][1][1] SUM[0]=LLR_sum[1][1][0]
Xadd_87_G3 Siso_DW01_add_300 $PINS A[11]=forward_metrics[2][0][11]
+ A[10]=forward_metrics[2][0][10] A[9]=forward_metrics[2][0][9]
+ A[8]=forward_metrics[2][0][8] A[7]=forward_metrics[2][0][7]
+ A[6]=forward_metrics[2][0][6] A[5]=forward_metrics[2][0][5]
+ A[4]=forward_metrics[2][0][4] A[3]=forward_metrics[2][0][3]
+ A[2]=forward_metrics[2][0][2] A[1]=forward_metrics[2][0][1]
+ A[0]=forward_metrics[2][0][0] B[11]=FE_OFN777_branch_metrics_2__0__11
+ B[10]=FE_OFN778_branch_metrics_2__0__10 B[9]=FE_OFN779_branch_metrics_2__0__9
+ B[8]=FE_OFN780_branch_metrics_2__0__8 B[7]=branch_metrics[2][0][7]
+ B[6]=FE_OFN782_branch_metrics_2__0__6 B[5]=FE_OFN783_branch_metrics_2__0__5
+ B[4]=branch_metrics[2][0][4] B[3]=FE_OFN785_branch_metrics_2__0__3
+ B[2]=FE_OFN786_branch_metrics_2__0__2 B[1]=branch_metrics[2][0][1]
+ B[0]=FE_OFN788_branch_metrics_2__0__0 CI=n1 SUM[11]=forward_sum[2][0][11]
+ SUM[10]=forward_sum[2][0][10] SUM[9]=forward_sum[2][0][9]
+ SUM[8]=forward_sum[2][0][8] SUM[7]=forward_sum[2][0][7]
+ SUM[6]=forward_sum[2][0][6] SUM[5]=forward_sum[2][0][5]
+ SUM[4]=forward_sum[2][0][4] SUM[3]=forward_sum[2][0][3]
+ SUM[2]=forward_sum[2][0][2] SUM[1]=forward_sum[2][0][1]
+ SUM[0]=forward_sum[2][0][0]
+ FE_OFN241_branch_metrics_2__0__1=branch_metrics[2][0][1]
Xadd_92_G3 Siso_DW01_add_301 $PINS A[11]=forward_metrics[2][1][11]
+ A[10]=forward_metrics[2][1][10] A[9]=forward_metrics[2][1][9]
+ A[8]=forward_metrics[2][1][8] A[7]=forward_metrics[2][1][7]
+ A[6]=forward_metrics[2][1][6] A[5]=forward_metrics[2][1][5]
+ A[4]=forward_metrics[2][1][4] A[3]=forward_metrics[2][1][3]
+ A[2]=forward_metrics[2][1][2] A[1]=forward_metrics[2][1][1]
+ A[0]=forward_metrics[2][1][0] B[11]=branch_metrics[2][3][11]
+ B[10]=FE_OFN814_branch_metrics_2__3__10 B[9]=FE_OFN815_branch_metrics_2__3__9
+ B[8]=FE_OFN816_branch_metrics_2__3__8 B[7]=branch_metrics[2][3][7]
+ B[6]=FE_OFN818_branch_metrics_2__3__6 B[5]=branch_metrics[2][3][5]
+ B[4]=branch_metrics[2][3][4] B[3]=branch_metrics[2][3][3]
+ B[2]=branch_metrics[2][3][2] B[1]=FE_OFN823_branch_metrics_2__3__1
+ B[0]=FE_OFN824_branch_metrics_2__3__0 CI=n1 SUM[11]=forward_sum[2][5][11]
+ SUM[10]=forward_sum[2][5][10] SUM[9]=forward_sum[2][5][9]
+ SUM[8]=forward_sum[2][5][8] SUM[7]=forward_sum[2][5][7]
+ SUM[6]=forward_sum[2][5][6] SUM[5]=forward_sum[2][5][5]
+ SUM[4]=forward_sum[2][5][4] SUM[3]=forward_sum[2][5][3]
+ SUM[2]=forward_sum[2][5][2] SUM[1]=forward_sum[2][5][1]
+ SUM[0]=forward_sum[2][5][0]
+ FE_OFN161_branch_metrics_2__3__7=FE_OFN817_branch_metrics_2__3__7
Xadd_105_G3 Siso_DW01_add_302 $PINS A[11]=forward_sum[2][0][11]
+ A[10]=forward_sum[2][0][10] A[9]=forward_sum[2][0][9] A[8]=forward_sum[2][0][8]
+ A[7]=forward_sum[2][0][7] A[6]=forward_sum[2][0][6] A[5]=forward_sum[2][0][5]
+ A[4]=forward_sum[2][0][4] A[3]=forward_sum[2][0][3] A[2]=forward_sum[2][0][2]
+ A[1]=forward_sum[2][0][1] A[0]=forward_sum[2][0][0]
+ B[11]=FE_OFN1154_backward_metrics_4__0__11
+ B[10]=FE_OFN1155_backward_metrics_4__0__10
+ B[9]=FE_OFN1156_backward_metrics_4__0__9
+ B[8]=FE_OFN1157_backward_metrics_4__0__8
+ B[7]=FE_OFN1158_backward_metrics_4__0__7
+ B[6]=FE_OFN1159_backward_metrics_4__0__6 B[5]=backward_metrics[4][0][5]
+ B[4]=backward_metrics[4][0][4] B[3]=FE_OFN1162_backward_metrics_4__0__3
+ B[2]=FE_OFN1163_backward_metrics_4__0__2 B[1]=backward_metrics[4][0][1]
+ B[0]=FE_OFN5548_backward_metrics_4__0__0 CI=n1 SUM[11]=LLR_sum[2][0][11]
+ SUM[10]=LLR_sum[2][0][10] SUM[9]=LLR_sum[2][0][9] SUM[8]=LLR_sum[2][0][8]
+ SUM[7]=LLR_sum[2][0][7] SUM[6]=LLR_sum[2][0][6] SUM[5]=LLR_sum[2][0][5]
+ SUM[4]=LLR_sum[2][0][4] SUM[3]=LLR_sum[2][0][3] SUM[2]=LLR_sum[2][0][2]
+ SUM[1]=LLR_sum[2][0][1] SUM[0]=LLR_sum[2][0][0]
Xadd_106_G3 Siso_DW01_add_303 $PINS A[11]=forward_sum[2][5][11]
+ A[10]=forward_sum[2][5][10] A[9]=forward_sum[2][5][9] A[8]=forward_sum[2][5][8]
+ A[7]=forward_sum[2][5][7] A[6]=forward_sum[2][5][6] A[5]=forward_sum[2][5][5]
+ A[4]=forward_sum[2][5][4] A[3]=forward_sum[2][5][3] A[2]=forward_sum[2][5][2]
+ A[1]=forward_sum[2][5][1] A[0]=forward_sum[2][5][0]
+ B[11]=FE_OFN1178_backward_metrics_4__2__11
+ B[10]=FE_OFN1179_backward_metrics_4__2__10
+ B[9]=FE_OFN1180_backward_metrics_4__2__9
+ B[8]=FE_OFN1181_backward_metrics_4__2__8
+ B[7]=FE_OFN1182_backward_metrics_4__2__7
+ B[6]=FE_OFN1183_backward_metrics_4__2__6 B[5]=backward_metrics[4][2][5]
+ B[4]=FE_OFN1185_backward_metrics_4__2__4 B[3]=backward_metrics[4][2][3]
+ B[2]=FE_OFN1187_backward_metrics_4__2__2 B[1]=backward_metrics[4][2][1]
+ B[0]=backward_metrics[4][2][0] CI=n1 SUM[11]=LLR_sum[2][1][11]
+ SUM[10]=LLR_sum[2][1][10] SUM[9]=LLR_sum[2][1][9] SUM[8]=LLR_sum[2][1][8]
+ SUM[7]=LLR_sum[2][1][7] SUM[6]=LLR_sum[2][1][6] SUM[5]=LLR_sum[2][1][5]
+ SUM[4]=LLR_sum[2][1][4] SUM[3]=LLR_sum[2][1][3] SUM[2]=LLR_sum[2][1][2]
+ SUM[1]=LLR_sum[2][1][1] SUM[0]=LLR_sum[2][1][0]
+ FE_OFN203_backward_metrics_4__2__0=FE_OFN1189_backward_metrics_4__2__0
Xadd_87_G4 Siso_DW01_add_304 $PINS A[11]=forward_metrics[3][0][11]
+ A[10]=forward_metrics[3][0][10] A[9]=forward_metrics[3][0][9]
+ A[8]=forward_metrics[3][0][8] A[7]=forward_metrics[3][0][7]
+ A[6]=forward_metrics[3][0][6] A[5]=forward_metrics[3][0][5]
+ A[4]=forward_metrics[3][0][4] A[3]=forward_metrics[3][0][3]
+ A[2]=forward_metrics[3][0][2] A[1]=forward_metrics[3][0][1]
+ A[0]=forward_metrics[3][0][0] B[11]=branch_metrics[3][0][11]
+ B[10]=branch_metrics[3][0][10] B[9]=FE_OFN827_branch_metrics_3__0__9
+ B[8]=branch_metrics[3][0][8] B[7]=branch_metrics[3][0][7]
+ B[6]=branch_metrics[3][0][6] B[5]=branch_metrics[3][0][5]
+ B[4]=branch_metrics[3][0][4] B[3]=branch_metrics[3][0][3]
+ B[2]=branch_metrics[3][0][2] B[1]=branch_metrics[3][0][1]
+ B[0]=branch_metrics[3][0][0] CI=n1 SUM[11]=forward_sum[3][0][11]
+ SUM[10]=forward_sum[3][0][10] SUM[9]=forward_sum[3][0][9]
+ SUM[8]=forward_sum[3][0][8] SUM[7]=forward_sum[3][0][7]
+ SUM[6]=forward_sum[3][0][6] SUM[5]=forward_sum[3][0][5]
+ SUM[4]=forward_sum[3][0][4] SUM[3]=forward_sum[3][0][3]
+ SUM[2]=forward_sum[3][0][2] SUM[1]=forward_sum[3][0][1]
+ SUM[0]=forward_sum[3][0][0]
Xadd_92_G4 Siso_DW01_add_305 $PINS A[11]=forward_metrics[3][1][11]
+ A[10]=forward_metrics[3][1][10] A[9]=forward_metrics[3][1][9]
+ A[8]=forward_metrics[3][1][8] A[7]=forward_metrics[3][1][7]
+ A[6]=forward_metrics[3][1][6] A[5]=forward_metrics[3][1][5]
+ A[4]=forward_metrics[3][1][4] A[3]=forward_metrics[3][1][3]
+ A[2]=forward_metrics[3][1][2] A[1]=forward_metrics[3][1][1]
+ A[0]=forward_metrics[3][1][0] B[11]=FE_OFN861_branch_metrics_3__3__11
+ B[10]=FE_OFN862_branch_metrics_3__3__10 B[9]=FE_OFN863_branch_metrics_3__3__9
+ B[8]=FE_OFN864_branch_metrics_3__3__8 B[7]=FE_OFN865_branch_metrics_3__3__7
+ B[6]=branch_metrics[3][3][6] B[5]=branch_metrics[3][3][5]
+ B[4]=FE_OFN868_branch_metrics_3__3__4 B[3]=FE_OFN869_branch_metrics_3__3__3
+ B[2]=branch_metrics[3][3][2] B[1]=FE_OFN871_branch_metrics_3__3__1
+ B[0]=FE_OFN872_branch_metrics_3__3__0 CI=n1 SUM[11]=forward_sum[3][5][11]
+ SUM[10]=forward_sum[3][5][10] SUM[9]=forward_sum[3][5][9]
+ SUM[8]=forward_sum[3][5][8] SUM[7]=forward_sum[3][5][7]
+ SUM[6]=forward_sum[3][5][6] SUM[5]=forward_sum[3][5][5]
+ SUM[4]=forward_sum[3][5][4] SUM[3]=forward_sum[3][5][3]
+ SUM[2]=forward_sum[3][5][2] SUM[1]=forward_sum[3][5][1]
+ SUM[0]=forward_sum[3][5][0]
Xadd_105_G4 Siso_DW01_add_306 $PINS A[11]=forward_sum[3][0][11]
+ A[10]=forward_sum[3][0][10] A[9]=forward_sum[3][0][9] A[8]=forward_sum[3][0][8]
+ A[7]=forward_sum[3][0][7] A[6]=forward_sum[3][0][6] A[5]=forward_sum[3][0][5]
+ A[4]=forward_sum[3][0][4] A[3]=forward_sum[3][0][3] A[2]=forward_sum[3][0][2]
+ A[1]=forward_sum[3][0][1] A[0]=forward_sum[3][0][0]
+ B[11]=FE_OFN1106_backward_metrics_3__0__11
+ B[10]=FE_OFN1107_backward_metrics_3__0__10
+ B[9]=FE_OFN1108_backward_metrics_3__0__9 B[8]=backward_metrics[3][0][8]
+ B[7]=FE_OFN1110_backward_metrics_3__0__7
+ B[6]=FE_OFN1111_backward_metrics_3__0__6 B[5]=backward_metrics[3][0][5]
+ B[4]=backward_metrics[3][0][4] B[3]=backward_metrics[3][0][3]
+ B[2]=FE_OFN1115_backward_metrics_3__0__2 B[1]=backward_metrics[3][0][1]
+ B[0]=FE_OFN1117_backward_metrics_3__0__0 CI=n1 SUM[11]=LLR_sum[3][0][11]
+ SUM[10]=LLR_sum[3][0][10] SUM[9]=LLR_sum[3][0][9] SUM[8]=LLR_sum[3][0][8]
+ SUM[7]=LLR_sum[3][0][7] SUM[6]=LLR_sum[3][0][6] SUM[5]=LLR_sum[3][0][5]
+ SUM[4]=LLR_sum[3][0][4] SUM[3]=LLR_sum[3][0][3] SUM[2]=LLR_sum[3][0][2]
+ SUM[1]=LLR_sum[3][0][1] SUM[0]=LLR_sum[3][0][0]
Xadd_106_G4 Siso_DW01_add_307 $PINS A[11]=forward_sum[3][5][11]
+ A[10]=forward_sum[3][5][10] A[9]=forward_sum[3][5][9] A[8]=forward_sum[3][5][8]
+ A[7]=forward_sum[3][5][7] A[6]=forward_sum[3][5][6] A[5]=forward_sum[3][5][5]
+ A[4]=forward_sum[3][5][4] A[3]=forward_sum[3][5][3] A[2]=forward_sum[3][5][2]
+ A[1]=forward_sum[3][5][1] A[0]=forward_sum[3][5][0]
+ B[11]=FE_OFN1130_backward_metrics_3__2__11
+ B[10]=FE_OFN1131_backward_metrics_3__2__10
+ B[9]=FE_OFN1132_backward_metrics_3__2__9
+ B[8]=FE_OFN1133_backward_metrics_3__2__8
+ B[7]=FE_OFN1134_backward_metrics_3__2__7
+ B[6]=FE_OFN1135_backward_metrics_3__2__6
+ B[5]=FE_OFN1136_backward_metrics_3__2__5 B[4]=backward_metrics[3][2][4]
+ B[3]=backward_metrics[3][2][3] B[2]=backward_metrics[3][2][2]
+ B[1]=FE_OFN1140_backward_metrics_3__2__1
+ B[0]=FE_OFN1141_backward_metrics_3__2__0 CI=n1 SUM[11]=LLR_sum[3][1][11]
+ SUM[10]=LLR_sum[3][1][10] SUM[9]=LLR_sum[3][1][9] SUM[8]=LLR_sum[3][1][8]
+ SUM[7]=LLR_sum[3][1][7] SUM[6]=LLR_sum[3][1][6] SUM[5]=LLR_sum[3][1][5]
+ SUM[4]=LLR_sum[3][1][4] SUM[3]=LLR_sum[3][1][3] SUM[2]=LLR_sum[3][1][2]
+ SUM[1]=LLR_sum[3][1][1] SUM[0]=LLR_sum[3][1][0]
Xadd_87_G5 Siso_DW01_add_308 $PINS A[11]=forward_metrics[4][0][11]
+ A[10]=forward_metrics[4][0][10] A[9]=forward_metrics[4][0][9]
+ A[8]=forward_metrics[4][0][8] A[7]=forward_metrics[4][0][7]
+ A[6]=forward_metrics[4][0][6] A[5]=forward_metrics[4][0][5]
+ A[4]=forward_metrics[4][0][4] A[3]=forward_metrics[4][0][3]
+ A[2]=forward_metrics[4][0][2] A[1]=forward_metrics[4][0][1]
+ A[0]=forward_metrics[4][0][0] B[11]=FE_OFN873_branch_metrics_4__0__11
+ B[10]=FE_OFN874_branch_metrics_4__0__10 B[9]=FE_OFN875_branch_metrics_4__0__9
+ B[8]=FE_OFN876_branch_metrics_4__0__8 B[7]=branch_metrics[4][0][7]
+ B[6]=branch_metrics[4][0][6] B[5]=branch_metrics[4][0][5]
+ B[4]=branch_metrics[4][0][4] B[3]=branch_metrics[4][0][3]
+ B[2]=FE_OFN882_branch_metrics_4__0__2 B[1]=branch_metrics[4][0][1]
+ B[0]=branch_metrics[4][0][0] CI=n1 SUM[11]=forward_sum[4][0][11]
+ SUM[10]=forward_sum[4][0][10] SUM[9]=forward_sum[4][0][9]
+ SUM[8]=forward_sum[4][0][8] SUM[7]=forward_sum[4][0][7]
+ SUM[6]=forward_sum[4][0][6] SUM[5]=forward_sum[4][0][5]
+ SUM[4]=forward_sum[4][0][4] SUM[3]=forward_sum[4][0][3]
+ SUM[2]=forward_sum[4][0][2] SUM[1]=forward_sum[4][0][1]
+ SUM[0]=forward_sum[4][0][0]
+ FE_OFN164_branch_metrics_4__0__1=branch_metrics[4][0][1]
+ FE_OFN165_branch_metrics_4__0__0=branch_metrics[4][0][0]
Xadd_92_G5 Siso_DW01_add_309 $PINS A[11]=forward_metrics[4][1][11]
+ A[10]=forward_metrics[4][1][10] A[9]=forward_metrics[4][1][9]
+ A[8]=forward_metrics[4][1][8] A[7]=forward_metrics[4][1][7]
+ A[6]=forward_metrics[4][1][6] A[5]=forward_metrics[4][1][5]
+ A[4]=forward_metrics[4][1][4] A[3]=forward_metrics[4][1][3]
+ A[2]=forward_metrics[4][1][2] A[1]=forward_metrics[4][1][1]
+ A[0]=forward_metrics[4][1][0] B[11]=branch_metrics[4][3][11]
+ B[10]=FE_OFN910_branch_metrics_4__3__10 B[9]=branch_metrics[4][3][9]
+ B[8]=branch_metrics[4][3][8] B[7]=FE_OFN913_branch_metrics_4__3__7
+ B[6]=branch_metrics[4][3][6] B[5]=branch_metrics[4][3][5]
+ B[4]=branch_metrics[4][3][4] B[3]=branch_metrics[4][3][3]
+ B[2]=branch_metrics[4][3][2] B[1]=branch_metrics[4][3][1]
+ B[0]=branch_metrics[4][3][0] CI=n1 SUM[11]=forward_sum[4][5][11]
+ SUM[10]=forward_sum[4][5][10] SUM[9]=forward_sum[4][5][9]
+ SUM[8]=forward_sum[4][5][8] SUM[7]=forward_sum[4][5][7]
+ SUM[6]=forward_sum[4][5][6] SUM[5]=forward_sum[4][5][5]
+ SUM[4]=forward_sum[4][5][4] SUM[3]=forward_sum[4][5][3]
+ SUM[2]=forward_sum[4][5][2] SUM[1]=forward_sum[4][5][1]
+ SUM[0]=forward_sum[4][5][0]
+ FE_OFN170_branch_metrics_4__3__9=FE_OFN911_branch_metrics_4__3__9
+ FE_OFN171_branch_metrics_4__3__5=branch_metrics[4][3][5]
Xadd_105_G5 Siso_DW01_add_310 $PINS A[11]=forward_sum[4][0][11]
+ A[10]=forward_sum[4][0][10] A[9]=forward_sum[4][0][9] A[8]=forward_sum[4][0][8]
+ A[7]=forward_sum[4][0][7] A[6]=forward_sum[4][0][6] A[5]=forward_sum[4][0][5]
+ A[4]=forward_sum[4][0][4] A[3]=forward_sum[4][0][3] A[2]=forward_sum[4][0][2]
+ A[1]=forward_sum[4][0][1] A[0]=forward_sum[4][0][0]
+ B[11]=FE_OFN1058_backward_metrics_2__0__11
+ B[10]=FE_OFN1059_backward_metrics_2__0__10
+ B[9]=FE_OFN1060_backward_metrics_2__0__9
+ B[8]=FE_OFN1061_backward_metrics_2__0__8
+ B[7]=FE_OFN1062_backward_metrics_2__0__7 B[6]=backward_metrics[2][0][6]
+ B[5]=FE_OFN1064_backward_metrics_2__0__5 B[4]=backward_metrics[2][0][4]
+ B[3]=FE_OFN1066_backward_metrics_2__0__3
+ B[2]=FE_OFN1067_backward_metrics_2__0__2 B[1]=backward_metrics[2][0][1]
+ B[0]=backward_metrics[2][0][0] CI=n1 SUM[11]=LLR_sum[4][0][11]
+ SUM[10]=LLR_sum[4][0][10] SUM[9]=LLR_sum[4][0][9] SUM[8]=LLR_sum[4][0][8]
+ SUM[7]=LLR_sum[4][0][7] SUM[6]=LLR_sum[4][0][6] SUM[5]=LLR_sum[4][0][5]
+ SUM[4]=LLR_sum[4][0][4] SUM[3]=LLR_sum[4][0][3] SUM[2]=LLR_sum[4][0][2]
+ SUM[1]=LLR_sum[4][0][1] SUM[0]=LLR_sum[4][0][0]
Xadd_106_G5 Siso_DW01_add_311 $PINS A[11]=forward_sum[4][5][11]
+ A[10]=forward_sum[4][5][10] A[9]=forward_sum[4][5][9] A[8]=forward_sum[4][5][8]
+ A[7]=forward_sum[4][5][7] A[6]=forward_sum[4][5][6] A[5]=forward_sum[4][5][5]
+ A[4]=forward_sum[4][5][4] A[3]=forward_sum[4][5][3] A[2]=forward_sum[4][5][2]
+ A[1]=forward_sum[4][5][1] A[0]=forward_sum[4][5][0]
+ B[11]=backward_metrics[2][2][11] B[10]=backward_metrics[2][2][10]
+ B[9]=backward_metrics[2][2][9] B[8]=FE_OFN1085_backward_metrics_2__2__8
+ B[7]=FE_OFN1086_backward_metrics_2__2__7
+ B[6]=FE_OFN1087_backward_metrics_2__2__6 B[5]=backward_metrics[2][2][5]
+ B[4]=backward_metrics[2][2][4] B[3]=FE_OFN1090_backward_metrics_2__2__3
+ B[2]=backward_metrics[2][2][2] B[1]=backward_metrics[2][2][1]
+ B[0]=backward_metrics[2][2][0] CI=n1 SUM[11]=LLR_sum[4][1][11]
+ SUM[10]=LLR_sum[4][1][10] SUM[9]=LLR_sum[4][1][9] SUM[8]=LLR_sum[4][1][8]
+ SUM[7]=LLR_sum[4][1][7] SUM[6]=LLR_sum[4][1][6] SUM[5]=LLR_sum[4][1][5]
+ SUM[4]=LLR_sum[4][1][4] SUM[3]=LLR_sum[4][1][3] SUM[2]=LLR_sum[4][1][2]
+ SUM[1]=LLR_sum[4][1][1] SUM[0]=LLR_sum[4][1][0]
Xadd_87_G6 Siso_DW01_add_312 $PINS A[11]=forward_metrics[5][0][11]
+ A[10]=forward_metrics[5][0][10] A[9]=forward_metrics[5][0][9]
+ A[8]=forward_metrics[5][0][8] A[7]=forward_metrics[5][0][7]
+ A[6]=forward_metrics[5][0][6] A[5]=forward_metrics[5][0][5]
+ A[4]=forward_metrics[5][0][4] A[3]=forward_metrics[5][0][3]
+ A[2]=forward_metrics[5][0][2] A[1]=forward_metrics[5][0][1]
+ A[0]=forward_metrics[5][0][0] B[11]=FE_OFN921_branch_metrics_5__0__11
+ B[10]=FE_OFN922_branch_metrics_5__0__10 B[9]=FE_OFN923_branch_metrics_5__0__9
+ B[8]=FE_OFN924_branch_metrics_5__0__8 B[7]=branch_metrics[5][0][7]
+ B[6]=FE_OFN926_branch_metrics_5__0__6 B[5]=FE_OFN927_branch_metrics_5__0__5
+ B[4]=branch_metrics[5][0][4] B[3]=branch_metrics[5][0][3]
+ B[2]=FE_OFN930_branch_metrics_5__0__2 B[1]=branch_metrics[5][0][1]
+ B[0]=branch_metrics[5][0][0] CI=n1 SUM[11]=forward_sum[5][0][11]
+ SUM[10]=forward_sum[5][0][10] SUM[9]=forward_sum[5][0][9]
+ SUM[8]=forward_sum[5][0][8] SUM[7]=forward_sum[5][0][7]
+ SUM[6]=forward_sum[5][0][6] SUM[5]=forward_sum[5][0][5]
+ SUM[4]=forward_sum[5][0][4] SUM[3]=forward_sum[5][0][3]
+ SUM[2]=forward_sum[5][0][2] SUM[1]=forward_sum[5][0][1]
+ SUM[0]=forward_sum[5][0][0]
Xadd_92_G6 Siso_DW01_add_313 $PINS A[11]=forward_metrics[5][1][11]
+ A[10]=forward_metrics[5][1][10] A[9]=forward_metrics[5][1][9]
+ A[8]=forward_metrics[5][1][8] A[7]=forward_metrics[5][1][7]
+ A[6]=forward_metrics[5][1][6] A[5]=forward_metrics[5][1][5]
+ A[4]=forward_metrics[5][1][4] A[3]=forward_metrics[5][1][3]
+ A[2]=forward_metrics[5][1][2] A[1]=forward_metrics[5][1][1]
+ A[0]=forward_metrics[5][1][0] B[11]=FE_OFN956_branch_metrics_5__3__11
+ B[10]=branch_metrics[5][3][10] B[9]=branch_metrics[5][3][9]
+ B[8]=branch_metrics[5][3][8] B[7]=FE_OFN960_branch_metrics_5__3__7
+ B[6]=branch_metrics[5][3][6] B[5]=branch_metrics[5][3][5]
+ B[4]=branch_metrics[5][3][4] B[3]=FE_OFN964_branch_metrics_5__3__3
+ B[2]=FE_OFN965_branch_metrics_5__3__2 B[1]=FE_OFN966_branch_metrics_5__3__1
+ B[0]=FE_OFN967_branch_metrics_5__3__0 CI=n1 SUM[11]=forward_sum[5][5][11]
+ SUM[10]=forward_sum[5][5][10] SUM[9]=forward_sum[5][5][9]
+ SUM[8]=forward_sum[5][5][8] SUM[7]=forward_sum[5][5][7]
+ SUM[6]=forward_sum[5][5][6] SUM[5]=forward_sum[5][5][5]
+ SUM[4]=forward_sum[5][5][4] SUM[3]=forward_sum[5][5][3]
+ SUM[2]=forward_sum[5][5][2] SUM[1]=forward_sum[5][5][1]
+ SUM[0]=forward_sum[5][5][0]
Xadd_105_G6 Siso_DW01_add_314 $PINS A[11]=forward_sum[5][0][11]
+ A[10]=forward_sum[5][0][10] A[9]=forward_sum[5][0][9] A[8]=forward_sum[5][0][8]
+ A[7]=forward_sum[5][0][7] A[6]=forward_sum[5][0][6] A[5]=forward_sum[5][0][5]
+ A[4]=forward_sum[5][0][4] A[3]=forward_sum[5][0][3] A[2]=forward_sum[5][0][2]
+ A[1]=forward_sum[5][0][1] A[0]=forward_sum[5][0][0]
+ B[11]=FE_OFN1010_backward_metrics_1__0__11
+ B[10]=FE_OFN1011_backward_metrics_1__0__10
+ B[9]=FE_OFN1012_backward_metrics_1__0__9
+ B[8]=FE_OFN1013_backward_metrics_1__0__8
+ B[7]=FE_OFN1014_backward_metrics_1__0__7
+ B[6]=FE_OFN1015_backward_metrics_1__0__6
+ B[5]=FE_OFN1016_backward_metrics_1__0__5
+ B[4]=FE_OFN1017_backward_metrics_1__0__4
+ B[3]=FE_OFN1018_backward_metrics_1__0__3 B[2]=backward_metrics[1][0][2]
+ B[1]=backward_metrics[1][0][1] B[0]=backward_metrics[1][0][0] CI=n1
+ SUM[11]=LLR_sum[5][0][11] SUM[10]=LLR_sum[5][0][10] SUM[9]=LLR_sum[5][0][9]
+ SUM[8]=LLR_sum[5][0][8] SUM[7]=LLR_sum[5][0][7] SUM[6]=LLR_sum[5][0][6]
+ SUM[5]=LLR_sum[5][0][5] SUM[4]=LLR_sum[5][0][4] SUM[3]=LLR_sum[5][0][3]
+ SUM[2]=LLR_sum[5][0][2] SUM[1]=LLR_sum[5][0][1] SUM[0]=LLR_sum[5][0][0]
+ FE_OFN188_backward_metrics_1__0__0=FE_OFN1021_backward_metrics_1__0__0
Xadd_106_G6 Siso_DW01_add_315 $PINS A[11]=forward_sum[5][5][11]
+ A[10]=forward_sum[5][5][10] A[9]=forward_sum[5][5][9] A[8]=forward_sum[5][5][8]
+ A[7]=forward_sum[5][5][7] A[6]=forward_sum[5][5][6] A[5]=forward_sum[5][5][5]
+ A[4]=forward_sum[5][5][4] A[3]=forward_sum[5][5][3] A[2]=forward_sum[5][5][2]
+ A[1]=forward_sum[5][5][1] A[0]=forward_sum[5][5][0]
+ B[11]=FE_OFN1034_backward_metrics_1__2__11
+ B[10]=FE_OFN1035_backward_metrics_1__2__10
+ B[9]=FE_OFN1036_backward_metrics_1__2__9
+ B[8]=FE_OFN1037_backward_metrics_1__2__8
+ B[7]=FE_OFN1038_backward_metrics_1__2__7
+ B[6]=FE_OFN1039_backward_metrics_1__2__6
+ B[5]=FE_OFN1040_backward_metrics_1__2__5 B[4]=backward_metrics[1][2][4]
+ B[3]=backward_metrics[1][2][3] B[2]=FE_OFN1043_backward_metrics_1__2__2
+ B[1]=FE_OFN1044_backward_metrics_1__2__1
+ B[0]=FE_OFN1045_backward_metrics_1__2__0 CI=n1 SUM[11]=LLR_sum[5][1][11]
+ SUM[10]=LLR_sum[5][1][10] SUM[9]=LLR_sum[5][1][9] SUM[8]=LLR_sum[5][1][8]
+ SUM[7]=LLR_sum[5][1][7] SUM[6]=LLR_sum[5][1][6] SUM[5]=LLR_sum[5][1][5]
+ SUM[4]=LLR_sum[5][1][4] SUM[3]=LLR_sum[5][1][3] SUM[2]=LLR_sum[5][1][2]
+ SUM[1]=LLR_sum[5][1][1] SUM[0]=LLR_sum[5][1][0]
Xadd_89_G2 Siso_DW01_add_316 $PINS A[11]=forward_metrics[1][2][11]
+ A[10]=forward_metrics[1][2][10] A[9]=forward_metrics[1][2][9]
+ A[8]=forward_metrics[1][2][8] A[7]=forward_metrics[1][2][7]
+ A[6]=forward_metrics[1][2][6] A[5]=forward_metrics[1][2][5]
+ A[4]=forward_metrics[1][2][4] A[3]=forward_metrics[1][2][3]
+ A[2]=forward_metrics[1][2][2] A[1]=forward_metrics[1][2][1]
+ A[0]=forward_metrics[1][2][0] B[11]=branch_metrics[1][0][11]
+ B[10]=FE_OFN730_branch_metrics_1__0__10 B[9]=branch_metrics[1][0][9]
+ B[8]=FE_OFN732_branch_metrics_1__0__8 B[7]=branch_metrics[1][0][7]
+ B[6]=FE_OFN734_branch_metrics_1__0__6 B[5]=FE_OFN735_branch_metrics_1__0__5
+ B[4]=branch_metrics[1][0][4] B[3]=branch_metrics[1][0][3]
+ B[2]=branch_metrics[1][0][2] B[1]=FE_OFN739_branch_metrics_1__0__1
+ B[0]=branch_metrics[1][0][0] CI=n1 SUM[11]=forward_sum[1][2][11]
+ SUM[10]=forward_sum[1][2][10] SUM[9]=forward_sum[1][2][9]
+ SUM[8]=forward_sum[1][2][8] SUM[7]=forward_sum[1][2][7]
+ SUM[6]=forward_sum[1][2][6] SUM[5]=forward_sum[1][2][5]
+ SUM[4]=forward_sum[1][2][4] SUM[3]=forward_sum[1][2][3]
+ SUM[2]=forward_sum[1][2][2] SUM[1]=forward_sum[1][2][1]
+ SUM[0]=forward_sum[1][2][0]
+ FE_OFN152_branch_metrics_1__0__0=FE_OFN740_branch_metrics_1__0__0
Xadd_94_G2 Siso_DW01_add_317 $PINS A[11]=forward_metrics[1][3][11]
+ A[10]=forward_metrics[1][3][10] A[9]=forward_metrics[1][3][9]
+ A[8]=forward_metrics[1][3][8] A[7]=forward_metrics[1][3][7]
+ A[6]=forward_metrics[1][3][6] A[5]=forward_metrics[1][3][5]
+ A[4]=forward_metrics[1][3][4] A[3]=forward_metrics[1][3][3]
+ A[2]=forward_metrics[1][3][2] A[1]=forward_metrics[1][3][1]
+ A[0]=forward_metrics[1][3][0] B[11]=branch_metrics[1][3][11]
+ B[10]=FE_OFN766_branch_metrics_1__3__10 B[9]=FE_OFN767_branch_metrics_1__3__9
+ B[8]=FE_OFN768_branch_metrics_1__3__8 B[7]=branch_metrics[1][3][7]
+ B[6]=FE_OFN770_branch_metrics_1__3__6 B[5]=branch_metrics[1][3][5]
+ B[4]=FE_OFN772_branch_metrics_1__3__4 B[3]=FE_OFN773_branch_metrics_1__3__3
+ B[2]=FE_OFN774_branch_metrics_1__3__2 B[1]=FE_OFN775_branch_metrics_1__3__1
+ B[0]=FE_OFN776_branch_metrics_1__3__0 CI=n1 SUM[11]=forward_sum[1][7][11]
+ SUM[10]=forward_sum[1][7][10] SUM[9]=forward_sum[1][7][9]
+ SUM[8]=forward_sum[1][7][8] SUM[7]=forward_sum[1][7][7]
+ SUM[6]=forward_sum[1][7][6] SUM[5]=forward_sum[1][7][5]
+ SUM[4]=forward_sum[1][7][4] SUM[3]=forward_sum[1][7][3]
+ SUM[2]=forward_sum[1][7][2] SUM[1]=forward_sum[1][7][1]
+ SUM[0]=forward_sum[1][7][0]
+ FE_OFN156_branch_metrics_1__3__11=FE_OFN765_branch_metrics_1__3__11
+ FE_OFN229_branch_metrics_1__3__5=FE_OFN771_branch_metrics_1__3__5
Xadd_107_G2 Siso_DW01_add_318 $PINS A[11]=forward_sum[1][2][11]
+ A[10]=forward_sum[1][2][10] A[9]=forward_sum[1][2][9] A[8]=forward_sum[1][2][8]
+ A[7]=forward_sum[1][2][7] A[6]=forward_sum[1][2][6] A[5]=forward_sum[1][2][5]
+ A[4]=forward_sum[1][2][4] A[3]=forward_sum[1][2][3] A[2]=forward_sum[1][2][2]
+ A[1]=forward_sum[1][2][1] A[0]=forward_sum[1][2][0]
+ B[11]=FE_OFN1214_backward_metrics_5__1__11
+ B[10]=FE_OFN1215_backward_metrics_5__1__10
+ B[9]=FE_OFN1216_backward_metrics_5__1__9
+ B[8]=FE_OFN1217_backward_metrics_5__1__8
+ B[7]=FE_OFN1218_backward_metrics_5__1__7
+ B[6]=FE_OFN1219_backward_metrics_5__1__6 B[5]=backward_metrics[5][1][5]
+ B[4]=backward_metrics[5][1][4] B[3]=FE_OFN1222_backward_metrics_5__1__3
+ B[2]=FE_OFN1223_backward_metrics_5__1__2 B[1]=backward_metrics[5][1][1]
+ B[0]=backward_metrics[5][1][0] CI=n1 SUM[11]=LLR_sum[1][2][11]
+ SUM[10]=LLR_sum[1][2][10] SUM[9]=LLR_sum[1][2][9] SUM[8]=LLR_sum[1][2][8]
+ SUM[7]=LLR_sum[1][2][7] SUM[6]=LLR_sum[1][2][6] SUM[5]=LLR_sum[1][2][5]
+ SUM[4]=LLR_sum[1][2][4] SUM[3]=LLR_sum[1][2][3] SUM[2]=LLR_sum[1][2][2]
+ SUM[1]=LLR_sum[1][2][1] SUM[0]=LLR_sum[1][2][0]
+ FE_OFN208_backward_metrics_5__1__0=FE_OFN1225_backward_metrics_5__1__0
Xadd_108_G2 Siso_DW01_add_319 $PINS A[11]=forward_sum[1][7][11]
+ A[10]=forward_sum[1][7][10] A[9]=forward_sum[1][7][9] A[8]=forward_sum[1][7][8]
+ A[7]=forward_sum[1][7][7] A[6]=forward_sum[1][7][6] A[5]=forward_sum[1][7][5]
+ A[4]=forward_sum[1][7][4] A[3]=forward_sum[1][7][3] A[2]=forward_sum[1][7][2]
+ A[1]=forward_sum[1][7][1] A[0]=forward_sum[1][7][0]
+ B[11]=FE_OFN1238_backward_metrics_5__3__11
+ B[10]=FE_OFN1239_backward_metrics_5__3__10
+ B[9]=FE_OFN1240_backward_metrics_5__3__9
+ B[8]=FE_OFN1241_backward_metrics_5__3__8
+ B[7]=FE_OFN1242_backward_metrics_5__3__7 B[6]=backward_metrics[5][3][6]
+ B[5]=FE_OFN1244_backward_metrics_5__3__5
+ B[4]=FE_OFN1245_backward_metrics_5__3__4 B[3]=backward_metrics[5][3][3]
+ B[2]=backward_metrics[5][3][2] B[1]=FE_OFN1248_backward_metrics_5__3__1
+ B[0]=backward_metrics[5][3][0] CI=n1 SUM[11]=LLR_sum[1][3][11]
+ SUM[10]=LLR_sum[1][3][10] SUM[9]=LLR_sum[1][3][9] SUM[8]=LLR_sum[1][3][8]
+ SUM[7]=LLR_sum[1][3][7] SUM[6]=LLR_sum[1][3][6] SUM[5]=LLR_sum[1][3][5]
+ SUM[4]=LLR_sum[1][3][4] SUM[3]=LLR_sum[1][3][3] SUM[2]=LLR_sum[1][3][2]
+ SUM[1]=LLR_sum[1][3][1] SUM[0]=LLR_sum[1][3][0]
+ FE_OFN215_backward_metrics_5__3__3=FE_OFN1246_backward_metrics_5__3__3
+ FE_OFN235_backward_metrics_5__3__0=FE_OFN1249_backward_metrics_5__3__0
Xadd_89_G3 Siso_DW01_add_320 $PINS A[11]=forward_metrics[2][2][11]
+ A[10]=forward_metrics[2][2][10] A[9]=forward_metrics[2][2][9]
+ A[8]=forward_metrics[2][2][8] A[7]=forward_metrics[2][2][7]
+ A[6]=forward_metrics[2][2][6] A[5]=forward_metrics[2][2][5]
+ A[4]=forward_metrics[2][2][4] A[3]=forward_metrics[2][2][3]
+ A[2]=forward_metrics[2][2][2] A[1]=forward_metrics[2][2][1]
+ A[0]=forward_metrics[2][2][0] B[11]=branch_metrics[2][0][11]
+ B[10]=FE_OFN778_branch_metrics_2__0__10 B[9]=branch_metrics[2][0][9]
+ B[8]=FE_OFN780_branch_metrics_2__0__8 B[7]=branch_metrics[2][0][7]
+ B[6]=branch_metrics[2][0][6] B[5]=FE_OFN783_branch_metrics_2__0__5
+ B[4]=branch_metrics[2][0][4] B[3]=branch_metrics[2][0][3]
+ B[2]=branch_metrics[2][0][2] B[1]=branch_metrics[2][0][1]
+ B[0]=branch_metrics[2][0][0] CI=n1 SUM[11]=forward_sum[2][2][11]
+ SUM[10]=forward_sum[2][2][10] SUM[9]=forward_sum[2][2][9]
+ SUM[8]=forward_sum[2][2][8] SUM[7]=forward_sum[2][2][7]
+ SUM[6]=forward_sum[2][2][6] SUM[5]=forward_sum[2][2][5]
+ SUM[4]=forward_sum[2][2][4] SUM[3]=forward_sum[2][2][3]
+ SUM[2]=forward_sum[2][2][2] SUM[1]=forward_sum[2][2][1]
+ SUM[0]=forward_sum[2][2][0]
+ FE_OFN158_branch_metrics_2__0__11=FE_OFN777_branch_metrics_2__0__11
+ FE_OFN159_branch_metrics_2__0__2=FE_OFN786_branch_metrics_2__0__2
+ FE_OFN238_branch_metrics_2__0__2=FE_OFN786_branch_metrics_2__0__2
Xadd_94_G3 Siso_DW01_add_321 $PINS A[11]=forward_metrics[2][3][11]
+ A[10]=forward_metrics[2][3][10] A[9]=forward_metrics[2][3][9]
+ A[8]=forward_metrics[2][3][8] A[7]=forward_metrics[2][3][7]
+ A[6]=forward_metrics[2][3][6] A[5]=forward_metrics[2][3][5]
+ A[4]=forward_metrics[2][3][4] A[3]=forward_metrics[2][3][3]
+ A[2]=forward_metrics[2][3][2] A[1]=forward_metrics[2][3][1]
+ A[0]=forward_metrics[2][3][0] B[11]=branch_metrics[2][3][11]
+ B[10]=FE_OFN814_branch_metrics_2__3__10 B[9]=FE_OFN815_branch_metrics_2__3__9
+ B[8]=FE_OFN816_branch_metrics_2__3__8 B[7]=FE_OFN817_branch_metrics_2__3__7
+ B[6]=FE_OFN818_branch_metrics_2__3__6 B[5]=FE_OFN819_branch_metrics_2__3__5
+ B[4]=FE_OFN820_branch_metrics_2__3__4 B[3]=FE_OFN5555_branch_metrics_2__3__3
+ B[2]=FE_OFN5553_branch_metrics_2__3__2 B[1]=FE_OFN823_branch_metrics_2__3__1
+ B[0]=FE_OFN824_branch_metrics_2__3__0 CI=n1 SUM[11]=forward_sum[2][7][11]
+ SUM[10]=forward_sum[2][7][10] SUM[9]=forward_sum[2][7][9]
+ SUM[8]=forward_sum[2][7][8] SUM[7]=forward_sum[2][7][7]
+ SUM[6]=forward_sum[2][7][6] SUM[5]=forward_sum[2][7][5]
+ SUM[4]=forward_sum[2][7][4] SUM[3]=forward_sum[2][7][3]
+ SUM[2]=forward_sum[2][7][2] SUM[1]=forward_sum[2][7][1]
+ SUM[0]=forward_sum[2][7][0]
Xadd_107_G3 Siso_DW01_add_322 $PINS A[11]=forward_sum[2][2][11]
+ A[10]=forward_sum[2][2][10] A[9]=forward_sum[2][2][9] A[8]=forward_sum[2][2][8]
+ A[7]=forward_sum[2][2][7] A[6]=forward_sum[2][2][6] A[5]=forward_sum[2][2][5]
+ A[4]=forward_sum[2][2][4] A[3]=forward_sum[2][2][3] A[2]=forward_sum[2][2][2]
+ A[1]=forward_sum[2][2][1] A[0]=forward_sum[2][2][0]
+ B[11]=FE_OFN1166_backward_metrics_4__1__11
+ B[10]=FE_OFN1167_backward_metrics_4__1__10 B[9]=backward_metrics[4][1][9]
+ B[8]=FE_OFN1169_backward_metrics_4__1__8
+ B[7]=FE_OFN1170_backward_metrics_4__1__7
+ B[6]=FE_OFN1171_backward_metrics_4__1__6 B[5]=backward_metrics[4][1][5]
+ B[4]=backward_metrics[4][1][4] B[3]=backward_metrics[4][1][3]
+ B[2]=backward_metrics[4][1][2] B[1]=backward_metrics[4][1][1]
+ B[0]=backward_metrics[4][1][0] CI=n1 SUM[11]=LLR_sum[2][2][11]
+ SUM[10]=LLR_sum[2][2][10] SUM[9]=LLR_sum[2][2][9] SUM[8]=LLR_sum[2][2][8]
+ SUM[7]=LLR_sum[2][2][7] SUM[6]=LLR_sum[2][2][6] SUM[5]=LLR_sum[2][2][5]
+ SUM[4]=LLR_sum[2][2][4] SUM[3]=LLR_sum[2][2][3] SUM[2]=LLR_sum[2][2][2]
+ SUM[1]=LLR_sum[2][2][1] SUM[0]=LLR_sum[2][2][0]
+ FE_OFN201_backward_metrics_4__1__9=FE_OFN1168_backward_metrics_4__1__9
+ FE_OFN202_backward_metrics_4__1__3=backward_metrics[4][1][3]
Xadd_108_G3 Siso_DW01_add_323 $PINS A[11]=forward_sum[2][7][11]
+ A[10]=forward_sum[2][7][10] A[9]=forward_sum[2][7][9] A[8]=forward_sum[2][7][8]
+ A[7]=forward_sum[2][7][7] A[6]=forward_sum[2][7][6] A[5]=forward_sum[2][7][5]
+ A[4]=forward_sum[2][7][4] A[3]=forward_sum[2][7][3] A[2]=forward_sum[2][7][2]
+ A[1]=forward_sum[2][7][1] A[0]=forward_sum[2][7][0]
+ B[11]=FE_OFN1190_backward_metrics_4__3__11
+ B[10]=FE_OFN1191_backward_metrics_4__3__10
+ B[9]=FE_OFN1192_backward_metrics_4__3__9
+ B[8]=FE_OFN1193_backward_metrics_4__3__8
+ B[7]=FE_OFN1194_backward_metrics_4__3__7
+ B[6]=FE_OFN1195_backward_metrics_4__3__6 B[5]=backward_metrics[4][3][5]
+ B[4]=FE_OFN1197_backward_metrics_4__3__4 B[3]=backward_metrics[4][3][3]
+ B[2]=backward_metrics[4][3][2] B[1]=backward_metrics[4][3][1]
+ B[0]=FE_OFN1201_backward_metrics_4__3__0 CI=n1 SUM[11]=LLR_sum[2][3][11]
+ SUM[10]=LLR_sum[2][3][10] SUM[9]=LLR_sum[2][3][9] SUM[8]=LLR_sum[2][3][8]
+ SUM[7]=LLR_sum[2][3][7] SUM[6]=LLR_sum[2][3][6] SUM[5]=LLR_sum[2][3][5]
+ SUM[4]=LLR_sum[2][3][4] SUM[3]=LLR_sum[2][3][3] SUM[2]=LLR_sum[2][3][2]
+ SUM[1]=LLR_sum[2][3][1] SUM[0]=LLR_sum[2][3][0]
Xadd_89_G4 Siso_DW01_add_324 $PINS A[11]=forward_metrics[3][2][11]
+ A[10]=forward_metrics[3][2][10] A[9]=forward_metrics[3][2][9]
+ A[8]=forward_metrics[3][2][8] A[7]=forward_metrics[3][2][7]
+ A[6]=forward_metrics[3][2][6] A[5]=forward_metrics[3][2][5]
+ A[4]=forward_metrics[3][2][4] A[3]=forward_metrics[3][2][3]
+ A[2]=forward_metrics[3][2][2] A[1]=forward_metrics[3][2][1]
+ A[0]=forward_metrics[3][2][0] B[11]=branch_metrics[3][0][11]
+ B[10]=FE_OFN826_branch_metrics_3__0__10 B[9]=branch_metrics[3][0][9]
+ B[8]=branch_metrics[3][0][8] B[7]=branch_metrics[3][0][7]
+ B[6]=branch_metrics[3][0][6] B[5]=branch_metrics[3][0][5]
+ B[4]=branch_metrics[3][0][4] B[3]=branch_metrics[3][0][3]
+ B[2]=branch_metrics[3][0][2] B[1]=branch_metrics[3][0][1]
+ B[0]=branch_metrics[3][0][0] CI=n1 SUM[11]=forward_sum[3][2][11]
+ SUM[10]=forward_sum[3][2][10] SUM[9]=forward_sum[3][2][9]
+ SUM[8]=forward_sum[3][2][8] SUM[7]=forward_sum[3][2][7]
+ SUM[6]=forward_sum[3][2][6] SUM[5]=forward_sum[3][2][5]
+ SUM[4]=forward_sum[3][2][4] SUM[3]=forward_sum[3][2][3]
+ SUM[2]=forward_sum[3][2][2] SUM[1]=forward_sum[3][2][1]
+ SUM[0]=forward_sum[3][2][0]
+ FE_OFN162_branch_metrics_3__0__11=FE_OFN825_branch_metrics_3__0__11
Xadd_94_G4 Siso_DW01_add_325 $PINS A[11]=forward_metrics[3][3][11]
+ A[10]=forward_metrics[3][3][10] A[9]=forward_metrics[3][3][9]
+ A[8]=forward_metrics[3][3][8] A[7]=forward_metrics[3][3][7]
+ A[6]=forward_metrics[3][3][6] A[5]=forward_metrics[3][3][5]
+ A[4]=forward_metrics[3][3][4] A[3]=forward_metrics[3][3][3]
+ A[2]=forward_metrics[3][3][2] A[1]=forward_metrics[3][3][1]
+ A[0]=forward_metrics[3][3][0] B[11]=FE_OFN861_branch_metrics_3__3__11
+ B[10]=FE_OFN862_branch_metrics_3__3__10 B[9]=FE_OFN863_branch_metrics_3__3__9
+ B[8]=FE_OFN864_branch_metrics_3__3__8 B[7]=FE_OFN865_branch_metrics_3__3__7
+ B[6]=branch_metrics[3][3][6] B[5]=FE_OFN867_branch_metrics_3__3__5
+ B[4]=FE_OFN868_branch_metrics_3__3__4 B[3]=branch_metrics[3][3][3]
+ B[2]=branch_metrics[3][3][2] B[1]=FE_OFN871_branch_metrics_3__3__1
+ B[0]=FE_OFN872_branch_metrics_3__3__0 CI=n1 SUM[11]=forward_sum[3][7][11]
+ SUM[10]=forward_sum[3][7][10] SUM[9]=forward_sum[3][7][9]
+ SUM[8]=forward_sum[3][7][8] SUM[7]=forward_sum[3][7][7]
+ SUM[6]=forward_sum[3][7][6] SUM[5]=forward_sum[3][7][5]
+ SUM[4]=forward_sum[3][7][4] SUM[3]=forward_sum[3][7][3]
+ SUM[2]=forward_sum[3][7][2] SUM[1]=forward_sum[3][7][1]
+ SUM[0]=forward_sum[3][7][0]
Xadd_107_G4 Siso_DW01_add_326 $PINS A[11]=forward_sum[3][2][11]
+ A[10]=forward_sum[3][2][10] A[9]=forward_sum[3][2][9] A[8]=forward_sum[3][2][8]
+ A[7]=forward_sum[3][2][7] A[6]=forward_sum[3][2][6] A[5]=forward_sum[3][2][5]
+ A[4]=forward_sum[3][2][4] A[3]=forward_sum[3][2][3] A[2]=forward_sum[3][2][2]
+ A[1]=forward_sum[3][2][1] A[0]=forward_sum[3][2][0]
+ B[11]=FE_OFN1118_backward_metrics_3__1__11
+ B[10]=FE_OFN1119_backward_metrics_3__1__10
+ B[9]=FE_OFN1120_backward_metrics_3__1__9 B[8]=backward_metrics[3][1][8]
+ B[7]=backward_metrics[3][1][7] B[6]=backward_metrics[3][1][6]
+ B[5]=FE_OFN1124_backward_metrics_3__1__5 B[4]=backward_metrics[3][1][4]
+ B[3]=backward_metrics[3][1][3] B[2]=backward_metrics[3][1][2]
+ B[1]=backward_metrics[3][1][1] B[0]=FE_OFN1129_backward_metrics_3__1__0 CI=n1
+ SUM[11]=LLR_sum[3][2][11] SUM[10]=LLR_sum[3][2][10] SUM[9]=LLR_sum[3][2][9]
+ SUM[8]=LLR_sum[3][2][8] SUM[7]=LLR_sum[3][2][7] SUM[6]=LLR_sum[3][2][6]
+ SUM[5]=LLR_sum[3][2][5] SUM[4]=LLR_sum[3][2][4] SUM[3]=LLR_sum[3][2][3]
+ SUM[2]=LLR_sum[3][2][2] SUM[1]=LLR_sum[3][2][1] SUM[0]=LLR_sum[3][2][0]
Xadd_108_G4 Siso_DW01_add_327 $PINS A[11]=forward_sum[3][7][11]
+ A[10]=forward_sum[3][7][10] A[9]=forward_sum[3][7][9] A[8]=forward_sum[3][7][8]
+ A[7]=forward_sum[3][7][7] A[6]=forward_sum[3][7][6] A[5]=forward_sum[3][7][5]
+ A[4]=forward_sum[3][7][4] A[3]=forward_sum[3][7][3] A[2]=forward_sum[3][7][2]
+ A[1]=forward_sum[3][7][1] A[0]=forward_sum[3][7][0]
+ B[11]=FE_OFN1142_backward_metrics_3__3__11
+ B[10]=FE_OFN1143_backward_metrics_3__3__10
+ B[9]=FE_OFN1144_backward_metrics_3__3__9
+ B[8]=FE_OFN1145_backward_metrics_3__3__8 B[7]=backward_metrics[3][3][7]
+ B[6]=FE_OFN1147_backward_metrics_3__3__6 B[5]=backward_metrics[3][3][5]
+ B[4]=FE_OFN1149_backward_metrics_3__3__4
+ B[3]=FE_OFN1150_backward_metrics_3__3__3 B[2]=backward_metrics[3][3][2]
+ B[1]=backward_metrics[3][3][1] B[0]=backward_metrics[3][3][0] CI=n1
+ SUM[11]=LLR_sum[3][3][11] SUM[10]=LLR_sum[3][3][10] SUM[9]=LLR_sum[3][3][9]
+ SUM[8]=LLR_sum[3][3][8] SUM[7]=LLR_sum[3][3][7] SUM[6]=LLR_sum[3][3][6]
+ SUM[5]=LLR_sum[3][3][5] SUM[4]=LLR_sum[3][3][4] SUM[3]=LLR_sum[3][3][3]
+ SUM[2]=LLR_sum[3][3][2] SUM[1]=LLR_sum[3][3][1] SUM[0]=LLR_sum[3][3][0]
+ FE_OFN231_backward_metrics_3__3__0=FE_OFN1153_backward_metrics_3__3__0
Xadd_89_G5 Siso_DW01_add_328 $PINS A[11]=forward_metrics[4][2][11]
+ A[10]=forward_metrics[4][2][10] A[9]=forward_metrics[4][2][9]
+ A[8]=forward_metrics[4][2][8] A[7]=forward_metrics[4][2][7]
+ A[6]=forward_metrics[4][2][6] A[5]=forward_metrics[4][2][5]
+ A[4]=forward_metrics[4][2][4] A[3]=forward_metrics[4][2][3]
+ A[2]=forward_metrics[4][2][2] A[1]=forward_metrics[4][2][1]
+ A[0]=forward_metrics[4][2][0] B[11]=FE_OFN873_branch_metrics_4__0__11
+ B[10]=FE_OFN874_branch_metrics_4__0__10 B[9]=branch_metrics[4][0][9]
+ B[8]=FE_OFN876_branch_metrics_4__0__8 B[7]=branch_metrics[4][0][7]
+ B[6]=branch_metrics[4][0][6] B[5]=branch_metrics[4][0][5]
+ B[4]=branch_metrics[4][0][4] B[3]=branch_metrics[4][0][3]
+ B[2]=branch_metrics[4][0][2] B[1]=branch_metrics[4][0][1]
+ B[0]=branch_metrics[4][0][0] CI=n1 SUM[11]=forward_sum[4][2][11]
+ SUM[10]=forward_sum[4][2][10] SUM[9]=forward_sum[4][2][9]
+ SUM[8]=forward_sum[4][2][8] SUM[7]=forward_sum[4][2][7]
+ SUM[6]=forward_sum[4][2][6] SUM[5]=forward_sum[4][2][5]
+ SUM[4]=forward_sum[4][2][4] SUM[3]=forward_sum[4][2][3]
+ SUM[2]=forward_sum[4][2][2] SUM[1]=forward_sum[4][2][1]
+ SUM[0]=forward_sum[4][2][0]
+ FE_OFN166_branch_metrics_4__0__0=branch_metrics[4][0][0]
Xadd_94_G5 Siso_DW01_add_329 $PINS A[11]=forward_metrics[4][3][11]
+ A[10]=forward_metrics[4][3][10] A[9]=forward_metrics[4][3][9]
+ A[8]=forward_metrics[4][3][8] A[7]=forward_metrics[4][3][7]
+ A[6]=forward_metrics[4][3][6] A[5]=forward_metrics[4][3][5]
+ A[4]=forward_metrics[4][3][4] A[3]=forward_metrics[4][3][3]
+ A[2]=forward_metrics[4][3][2] A[1]=forward_metrics[4][3][1]
+ A[0]=forward_metrics[4][3][0] B[11]=branch_metrics[4][3][11]
+ B[10]=FE_OFN910_branch_metrics_4__3__10 B[9]=FE_OFN911_branch_metrics_4__3__9
+ B[8]=FE_OFN912_branch_metrics_4__3__8 B[7]=branch_metrics[4][3][7]
+ B[6]=FE_OFN914_branch_metrics_4__3__6 B[5]=branch_metrics[4][3][5]
+ B[4]=branch_metrics[4][3][4] B[3]=branch_metrics[4][3][3]
+ B[2]=branch_metrics[4][3][2] B[1]=branch_metrics[4][3][1]
+ B[0]=branch_metrics[4][3][0] CI=n1 SUM[11]=forward_sum[4][7][11]
+ SUM[10]=forward_sum[4][7][10] SUM[9]=forward_sum[4][7][9]
+ SUM[8]=forward_sum[4][7][8] SUM[7]=forward_sum[4][7][7]
+ SUM[6]=forward_sum[4][7][6] SUM[5]=forward_sum[4][7][5]
+ SUM[4]=forward_sum[4][7][4] SUM[3]=forward_sum[4][7][3]
+ SUM[2]=forward_sum[4][7][2] SUM[1]=forward_sum[4][7][1]
+ SUM[0]=forward_sum[4][7][0]
Xadd_107_G5 Siso_DW01_add_330 $PINS A[11]=forward_sum[4][2][11]
+ A[10]=forward_sum[4][2][10] A[9]=forward_sum[4][2][9] A[8]=forward_sum[4][2][8]
+ A[7]=forward_sum[4][2][7] A[6]=forward_sum[4][2][6] A[5]=forward_sum[4][2][5]
+ A[4]=forward_sum[4][2][4] A[3]=forward_sum[4][2][3] A[2]=forward_sum[4][2][2]
+ A[1]=forward_sum[4][2][1] A[0]=forward_sum[4][2][0]
+ B[11]=FE_OFN1070_backward_metrics_2__1__11
+ B[10]=FE_OFN1071_backward_metrics_2__1__10
+ B[9]=FE_OFN1072_backward_metrics_2__1__9
+ B[8]=FE_OFN1073_backward_metrics_2__1__8
+ B[7]=FE_OFN1074_backward_metrics_2__1__7
+ B[6]=FE_OFN1075_backward_metrics_2__1__6 B[5]=backward_metrics[2][1][5]
+ B[4]=backward_metrics[2][1][4] B[3]=backward_metrics[2][1][3]
+ B[2]=FE_OFN1079_backward_metrics_2__1__2 B[1]=backward_metrics[2][1][1]
+ B[0]=backward_metrics[2][1][0] CI=n1 SUM[11]=LLR_sum[4][2][11]
+ SUM[10]=LLR_sum[4][2][10] SUM[9]=LLR_sum[4][2][9] SUM[8]=LLR_sum[4][2][8]
+ SUM[7]=LLR_sum[4][2][7] SUM[6]=LLR_sum[4][2][6] SUM[5]=LLR_sum[4][2][5]
+ SUM[4]=LLR_sum[4][2][4] SUM[3]=LLR_sum[4][2][3] SUM[2]=LLR_sum[4][2][2]
+ SUM[1]=LLR_sum[4][2][1] SUM[0]=LLR_sum[4][2][0]
+ FE_OFN228_backward_metrics_2__1__1=backward_metrics[2][1][1]
Xadd_108_G5 Siso_DW01_add_331 $PINS A[11]=forward_sum[4][7][11]
+ A[10]=forward_sum[4][7][10] A[9]=forward_sum[4][7][9] A[8]=forward_sum[4][7][8]
+ A[7]=forward_sum[4][7][7] A[6]=forward_sum[4][7][6] A[5]=forward_sum[4][7][5]
+ A[4]=forward_sum[4][7][4] A[3]=forward_sum[4][7][3] A[2]=forward_sum[4][7][2]
+ A[1]=forward_sum[4][7][1] A[0]=forward_sum[4][7][0]
+ B[11]=FE_OFN1094_backward_metrics_2__3__11
+ B[10]=FE_OFN1095_backward_metrics_2__3__10 B[9]=backward_metrics[2][3][9]
+ B[8]=FE_OFN1097_backward_metrics_2__3__8 B[7]=backward_metrics[2][3][7]
+ B[6]=backward_metrics[2][3][6] B[5]=backward_metrics[2][3][5]
+ B[4]=backward_metrics[2][3][4] B[3]=backward_metrics[2][3][3]
+ B[2]=backward_metrics[2][3][2] B[1]=backward_metrics[2][3][1]
+ B[0]=backward_metrics[2][3][0] CI=n1 SUM[11]=LLR_sum[4][3][11]
+ SUM[10]=LLR_sum[4][3][10] SUM[9]=LLR_sum[4][3][9] SUM[8]=LLR_sum[4][3][8]
+ SUM[7]=LLR_sum[4][3][7] SUM[6]=LLR_sum[4][3][6] SUM[5]=LLR_sum[4][3][5]
+ SUM[4]=LLR_sum[4][3][4] SUM[3]=LLR_sum[4][3][3] SUM[2]=LLR_sum[4][3][2]
+ SUM[1]=LLR_sum[4][3][1] SUM[0]=LLR_sum[4][3][0]
Xadd_89_G6 Siso_DW01_add_332 $PINS A[11]=forward_metrics[5][2][11]
+ A[10]=forward_metrics[5][2][10] A[9]=forward_metrics[5][2][9]
+ A[8]=forward_metrics[5][2][8] A[7]=forward_metrics[5][2][7]
+ A[6]=forward_metrics[5][2][6] A[5]=forward_metrics[5][2][5]
+ A[4]=forward_metrics[5][2][4] A[3]=forward_metrics[5][2][3]
+ A[2]=forward_metrics[5][2][2] A[1]=forward_metrics[5][2][1]
+ A[0]=forward_metrics[5][2][0] B[11]=FE_OFN921_branch_metrics_5__0__11
+ B[10]=FE_OFN922_branch_metrics_5__0__10 B[9]=branch_metrics[5][0][9]
+ B[8]=FE_OFN924_branch_metrics_5__0__8 B[7]=branch_metrics[5][0][7]
+ B[6]=FE_OFN926_branch_metrics_5__0__6 B[5]=FE_OFN927_branch_metrics_5__0__5
+ B[4]=branch_metrics[5][0][4] B[3]=branch_metrics[5][0][3]
+ B[2]=branch_metrics[5][0][2] B[1]=branch_metrics[5][0][1]
+ B[0]=branch_metrics[5][0][0] CI=n1 SUM[11]=forward_sum[5][2][11]
+ SUM[10]=forward_sum[5][2][10] SUM[9]=forward_sum[5][2][9]
+ SUM[8]=forward_sum[5][2][8] SUM[7]=forward_sum[5][2][7]
+ SUM[6]=forward_sum[5][2][6] SUM[5]=forward_sum[5][2][5]
+ SUM[4]=forward_sum[5][2][4] SUM[3]=forward_sum[5][2][3]
+ SUM[2]=forward_sum[5][2][2] SUM[1]=forward_sum[5][2][1]
+ SUM[0]=forward_sum[5][2][0]
+ FE_OFN172_branch_metrics_5__0__9=FE_OFN923_branch_metrics_5__0__9
Xadd_94_G6 Siso_DW01_add_333 $PINS A[11]=forward_metrics[5][3][11]
+ A[10]=forward_metrics[5][3][10] A[9]=forward_metrics[5][3][9]
+ A[8]=forward_metrics[5][3][8] A[7]=forward_metrics[5][3][7]
+ A[6]=forward_metrics[5][3][6] A[5]=forward_metrics[5][3][5]
+ A[4]=forward_metrics[5][3][4] A[3]=forward_metrics[5][3][3]
+ A[2]=forward_metrics[5][3][2] A[1]=forward_metrics[5][3][1]
+ A[0]=forward_metrics[5][3][0] B[11]=FE_OFN956_branch_metrics_5__3__11
+ B[10]=branch_metrics[5][3][10] B[9]=branch_metrics[5][3][9]
+ B[8]=branch_metrics[5][3][8] B[7]=branch_metrics[5][3][7]
+ B[6]=branch_metrics[5][3][6] B[5]=FE_OFN962_branch_metrics_5__3__5
+ B[4]=branch_metrics[5][3][4] B[3]=FE_OFN964_branch_metrics_5__3__3
+ B[2]=FE_OFN965_branch_metrics_5__3__2 B[1]=FE_OFN966_branch_metrics_5__3__1
+ B[0]=FE_OFN967_branch_metrics_5__3__0 CI=n1 SUM[11]=forward_sum[5][7][11]
+ SUM[10]=forward_sum[5][7][10] SUM[9]=forward_sum[5][7][9]
+ SUM[8]=forward_sum[5][7][8] SUM[7]=forward_sum[5][7][7]
+ SUM[6]=forward_sum[5][7][6] SUM[5]=forward_sum[5][7][5]
+ SUM[4]=forward_sum[5][7][4] SUM[3]=forward_sum[5][7][3]
+ SUM[2]=forward_sum[5][7][2] SUM[1]=forward_sum[5][7][1]
+ SUM[0]=forward_sum[5][7][0]
Xadd_107_G6 Siso_DW01_add_334 $PINS A[11]=forward_sum[5][2][11]
+ A[10]=forward_sum[5][2][10] A[9]=forward_sum[5][2][9] A[8]=forward_sum[5][2][8]
+ A[7]=forward_sum[5][2][7] A[6]=forward_sum[5][2][6] A[5]=forward_sum[5][2][5]
+ A[4]=forward_sum[5][2][4] A[3]=forward_sum[5][2][3] A[2]=forward_sum[5][2][2]
+ A[1]=forward_sum[5][2][1] A[0]=forward_sum[5][2][0]
+ B[11]=FE_OFN1022_backward_metrics_1__1__11 B[10]=backward_metrics[1][1][10]
+ B[9]=FE_OFN1024_backward_metrics_1__1__9
+ B[8]=FE_OFN1025_backward_metrics_1__1__8 B[7]=backward_metrics[1][1][7]
+ B[6]=FE_OFN1027_backward_metrics_1__1__6 B[5]=backward_metrics[1][1][5]
+ B[4]=backward_metrics[1][1][4] B[3]=FE_OFN1030_backward_metrics_1__1__3
+ B[2]=FE_OFN1031_backward_metrics_1__1__2
+ B[1]=FE_OFN1032_backward_metrics_1__1__1
+ B[0]=FE_OFN5642_backward_metrics_1__1__0 CI=n1 SUM[11]=LLR_sum[5][2][11]
+ SUM[10]=LLR_sum[5][2][10] SUM[9]=LLR_sum[5][2][9] SUM[8]=LLR_sum[5][2][8]
+ SUM[7]=LLR_sum[5][2][7] SUM[6]=LLR_sum[5][2][6] SUM[5]=LLR_sum[5][2][5]
+ SUM[4]=LLR_sum[5][2][4] SUM[3]=LLR_sum[5][2][3] SUM[2]=LLR_sum[5][2][2]
+ SUM[1]=LLR_sum[5][2][1] SUM[0]=LLR_sum[5][2][0]
+ FE_OFN242_backward_metrics_1__1__0=backward_metrics[1][1][0]
Xadd_108_G6 Siso_DW01_add_335 $PINS A[11]=forward_sum[5][7][11]
+ A[10]=forward_sum[5][7][10] A[9]=forward_sum[5][7][9] A[8]=forward_sum[5][7][8]
+ A[7]=forward_sum[5][7][7] A[6]=forward_sum[5][7][6] A[5]=forward_sum[5][7][5]
+ A[4]=forward_sum[5][7][4] A[3]=forward_sum[5][7][3] A[2]=forward_sum[5][7][2]
+ A[1]=forward_sum[5][7][1] A[0]=forward_sum[5][7][0]
+ B[11]=FE_OFN1046_backward_metrics_1__3__11
+ B[10]=FE_OFN1047_backward_metrics_1__3__10
+ B[9]=FE_OFN1048_backward_metrics_1__3__9
+ B[8]=FE_OFN1049_backward_metrics_1__3__8 B[7]=backward_metrics[1][3][7]
+ B[6]=backward_metrics[1][3][6] B[5]=backward_metrics[1][3][5]
+ B[4]=backward_metrics[1][3][4] B[3]=backward_metrics[1][3][3]
+ B[2]=backward_metrics[1][3][2] B[1]=backward_metrics[1][3][1]
+ B[0]=FE_OFN1057_backward_metrics_1__3__0 CI=n1 SUM[11]=LLR_sum[5][3][11]
+ SUM[10]=LLR_sum[5][3][10] SUM[9]=LLR_sum[5][3][9] SUM[8]=LLR_sum[5][3][8]
+ SUM[7]=LLR_sum[5][3][7] SUM[6]=LLR_sum[5][3][6] SUM[5]=LLR_sum[5][3][5]
+ SUM[4]=LLR_sum[5][3][4] SUM[3]=LLR_sum[5][3][3] SUM[2]=LLR_sum[5][3][2]
+ SUM[1]=LLR_sum[5][3][1] SUM[0]=LLR_sum[5][3][0]
+ FE_OFN191_backward_metrics_1__3__4=FE_OFN1053_backward_metrics_1__3__4
Xext_reg[0][11] QDFFRBN $PINS Q=ext[0][11] D=n2980 CK=clk_i_clone5
+ RB=FE_OFN71_i_reset_n_i
Xext_reg[0][10] QDFFRBN $PINS Q=ext[0][10] D=n2981 CK=clk_i_clone5
+ RB=FE_OFN71_i_reset_n_i
Xext_reg[1][11] QDFFRBN $PINS Q=ext[1][11] D=n2992 CK=clk_i_clone5
+ RB=FE_OFN29_i_reset_n_i
Xext_reg[1][10] QDFFRBN $PINS Q=ext[1][10] D=n2993 CK=clk_i_clone5
+ RB=FE_OFN29_i_reset_n_i
Xext_reg[2][11] QDFFRBN $PINS Q=ext[2][11] D=n3004 CK=clk_i_clone5
+ RB=FE_OFN47_i_reset_n_i
Xext_reg[2][10] QDFFRBN $PINS Q=ext[2][10] D=n3005 CK=clk_i_clone5
+ RB=FE_OFN70_i_reset_n_i
Xdone_reg QDFFRBN $PINS Q=finish D=done_nxt CK=clk_i_clone3
+ RB=FE_OFN6_i_reset_n_i
Xstate_reg[2] QDFFRBN $PINS Q=state[2] D=n3096 CK=clk_i_clone3
+ RB=FE_OFN6_i_reset_n_i
Xext_reg[3][11] QDFFRBN $PINS Q=ext[3][11] D=n3016 CK=clk_i_clone5
+ RB=FE_OFN28_i_reset_n_i
Xext_reg[3][10] QDFFRBN $PINS Q=ext[3][10] D=n3017 CK=clk_i_clone5
+ RB=FE_OFN46_i_reset_n_i
Xext_reg[3][9] QDFFRBN $PINS Q=ext[3][9] D=n3018 CK=clk_i_clone3
+ RB=FE_OFN97_i_reset_n_i
Xext_reg[5][11] QDFFRBN $PINS Q=ext[5][11] D=n3040 CK=clk_i_clone3
+ RB=FE_OFN46_i_reset_n_i
Xext_reg[5][10] QDFFRBN $PINS Q=ext[5][10] D=n3041 CK=clk_i_clone3
+ RB=FE_OFN380_i_reset_n_i
Xext_reg[5][9] QDFFRBN $PINS Q=ext[5][9] D=n3042 CK=clk_i_clone3
+ RB=FE_OFN380_i_reset_n_i
Xext_reg[4][11] QDFFRBN $PINS Q=ext[4][11] D=n3028 CK=clk_i_clone5
+ RB=FE_OFN29_i_reset_n_i
Xext_reg[4][10] QDFFRBN $PINS Q=ext[4][10] D=n3029 CK=clk_i_clone3
+ RB=FE_OFN442_i_reset_n_i
Xext_reg[4][9] QDFFRBN $PINS Q=ext[4][9] D=n3030 CK=clk_i_clone3
+ RB=FE_OFN81_i_reset_n_i
Xext_reg[6][11] QDFFRBN $PINS Q=ext[6][11] D=n3052 CK=clk_i_clone3
+ RB=FE_OFN442_i_reset_n_i
Xext_reg[6][10] QDFFRBN $PINS Q=ext[6][10] D=n3053 CK=clk_i_clone3
+ RB=FE_OFN380_i_reset_n_i
Xext_reg[6][9] QDFFRBN $PINS Q=ext[6][9] D=n3054 CK=clk_i_clone3
+ RB=FE_OFN380_i_reset_n_i
XLLR_reg[0][10] QDFFRBN $PINS Q=data_o[82] D=n1957 CK=clk_i_clone8
+ RB=FE_OFN88_i_reset_n_i
XLLR_reg[1][10] QDFFRBN $PINS Q=data_o[70] D=n1969 CK=clk_i_clone3
+ RB=FE_OFN27_i_reset_n_i
XLLR_reg[2][10] QDFFRBN $PINS Q=data_o[58] D=n1981 CK=clk_i_clone8
+ RB=FE_OFN88_i_reset_n_i
XLLR_reg[3][10] QDFFRBN $PINS Q=data_o[46] D=n1993 CK=clk_i_clone3
+ RB=FE_OFN59_i_reset_n_i
XLLR_reg[4][10] QDFFRBN $PINS Q=data_o[34] D=n2005 CK=clk_i_clone3
+ RB=FE_OFN39_i_reset_n_i
XLLR_reg[0][11] QDFFRBN $PINS Q=data_o[83] D=n1956 CK=clk_i_clone3
+ RB=FE_OFN20_i_reset_n_i
XLLR_reg[1][11] QDFFRBN $PINS Q=data_o[71] D=n1968 CK=clk_i_clone3
+ RB=FE_OFN39_i_reset_n_i
XLLR_reg[2][11] QDFFRBN $PINS Q=data_o[59] D=n1980 CK=clk_i_clone3
+ RB=FE_OFN57_i_reset_n_i
XLLR_reg[3][11] QDFFRBN $PINS Q=data_o[47] D=n1992 CK=clk_i_clone3
+ RB=FE_OFN58_i_reset_n_i
XLLR_reg[4][11] QDFFRBN $PINS Q=data_o[35] D=n2004 CK=clk_i_clone3
+ RB=FE_OFN39_i_reset_n_i
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=n3095 CK=clk_i_clone3
+ RB=FE_OFN265_i_reset_n_i
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=n3094 CK=clk_i_clone3
+ RB=FE_OFN6_i_reset_n_i
Xext_reg[0][9] QDFFRBN $PINS Q=ext[0][9] D=n2982 CK=clk_i_clone8
+ RB=FE_OFN88_i_reset_n_i
Xext_reg[0][8] QDFFRBN $PINS Q=ext[0][8] D=n2983 CK=clk_i_clone8
+ RB=FE_OFN45_i_reset_n_i
Xext_reg[0][7] QDFFRBN $PINS Q=ext[0][7] D=n2984 CK=clk_i_clone8
+ RB=FE_OFN69_i_reset_n_i
Xext_reg[1][9] QDFFRBN $PINS Q=ext[1][9] D=n2994 CK=clk_i_clone8
+ RB=FE_OFN45_i_reset_n_i
Xext_reg[1][8] QDFFRBN $PINS Q=ext[1][8] D=n2995 CK=clk_i_clone8
+ RB=FE_OFN69_i_reset_n_i
Xext_reg[1][7] QDFFRBN $PINS Q=ext[1][7] D=n2996 CK=clk_i_clone7
+ RB=FE_OFN23_i_reset_n_i
Xext_reg[2][9] QDFFRBN $PINS Q=ext[2][9] D=n3006 CK=clk_i_clone8
+ RB=FE_OFN67_i_reset_n_i
Xext_reg[2][8] QDFFRBN $PINS Q=ext[2][8] D=n3007 CK=clk_i_clone8
+ RB=FE_OFN69_i_reset_n_i
Xext_reg[2][7] QDFFRBN $PINS Q=ext[2][7] D=n3008 CK=clk_i_clone7
+ RB=FE_OFN386_i_reset_n_i
Xext_reg[3][8] QDFFRBN $PINS Q=ext[3][8] D=n3019 CK=clk_i_clone19
+ RB=FE_OFN121_i_reset_n_i
Xext_reg[3][7] QDFFRBN $PINS Q=ext[3][7] D=n3020 CK=clk_i_clone19
+ RB=FE_OFN121_i_reset_n_i
Xext_reg[3][6] QDFFRBN $PINS Q=ext[3][6] D=n3021 CK=clk_i_clone20
+ RB=FE_OFN135_i_reset_n_i
Xext_reg[5][8] QDFFRBN $PINS Q=ext[5][8] D=n3043 CK=clk_i_clone3
+ RB=FE_OFN98_i_reset_n_i
Xext_reg[5][7] QDFFRBN $PINS Q=ext[5][7] D=n3044 CK=clk_i_clone19
+ RB=FE_OFN98_i_reset_n_i
Xext_reg[5][6] QDFFRBN $PINS Q=ext[5][6] D=n3045 CK=clk_i_clone19
+ RB=FE_OFN121_i_reset_n_i
Xext_reg[4][8] QDFFRBN $PINS Q=ext[4][8] D=n3031 CK=clk_i_clone19
+ RB=FE_OFN121_i_reset_n_i
Xext_reg[4][7] QDFFRBN $PINS Q=ext[4][7] D=n3032 CK=clk_i_clone19
+ RB=FE_OFN135_i_reset_n_i
Xext_reg[4][6] QDFFRBN $PINS Q=ext[4][6] D=n3033 CK=clk_i_clone20
+ RB=FE_OFN21_i_reset_n_i
Xext_reg[6][8] QDFFRBN $PINS Q=ext[6][8] D=n3055 CK=clk_i_clone3
+ RB=FE_OFN98_i_reset_n_i
Xext_reg[6][7] QDFFRBN $PINS Q=ext[6][7] D=n3056 CK=clk_i_clone19
+ RB=FE_OFN121_i_reset_n_i
Xext_reg[6][6] QDFFRBN $PINS Q=ext[6][6] D=n3057 CK=clk_i_clone20
+ RB=FE_OFN135_i_reset_n_i
XLLR_reg[0][6] QDFFRBN $PINS Q=data_o[78] D=n1961 CK=clk_i_clone7
+ RB=FE_OFN23_i_reset_n_i
XLLR_reg[1][6] QDFFRBN $PINS Q=data_o[66] D=n1973 CK=clk_i_clone20
+ RB=FE_OFN8_i_reset_n_i
XLLR_reg[2][6] QDFFRBN $PINS Q=data_o[54] D=n1985 CK=clk_i_clone7
+ RB=FE_OFN25_i_reset_n_i
XLLR_reg[3][6] QDFFRBN $PINS Q=data_o[42] D=n1997 CK=clk_i_clone20
+ RB=FE_OFN136_i_reset_n_i
XLLR_reg[4][6] QDFFRBN $PINS Q=data_o[30] D=n2009 CK=clk_i_clone20
+ RB=FE_OFN136_i_reset_n_i
XLLR_reg[0][7] QDFFRBN $PINS Q=data_o[79] D=n1960 CK=clk_i_clone8
+ RB=FE_OFN89_i_reset_n_i
XLLR_reg[1][7] QDFFRBN $PINS Q=data_o[67] D=n1972 CK=clk_i_clone8
+ RB=FE_OFN132_i_reset_n_i
XLLR_reg[2][7] QDFFRBN $PINS Q=data_o[55] D=n1984 CK=clk_i_clone7
+ RB=FE_OFN386_i_reset_n_i
XLLR_reg[3][7] QDFFRBN $PINS Q=data_o[43] D=n1996 CK=clk_i_clone20
+ RB=FE_OFN136_i_reset_n_i
XLLR_reg[4][7] QDFFRBN $PINS Q=data_o[31] D=n2008 CK=clk_i_clone20
+ RB=FE_OFN136_i_reset_n_i
XLLR_reg[0][8] QDFFRBN $PINS Q=data_o[80] D=n1959 CK=clk_i_clone8
+ RB=FE_OFN68_i_reset_n_i
XLLR_reg[1][8] QDFFRBN $PINS Q=data_o[68] D=n1971 CK=clk_i_clone8
+ RB=FE_OFN132_i_reset_n_i
XLLR_reg[2][8] QDFFRBN $PINS Q=data_o[56] D=n1983 CK=clk_i_clone8
+ RB=FE_OFN89_i_reset_n_i
XLLR_reg[3][8] QDFFRBN $PINS Q=data_o[44] D=n1995 CK=clk_i_clone19
+ RB=FE_OFN99_i_reset_n_i
XLLR_reg[4][8] QDFFRBN $PINS Q=data_o[32] D=n2007 CK=clk_i_clone19
+ RB=FE_OFN122_i_reset_n_i
XLLR_reg[0][9] QDFFRBN $PINS Q=data_o[81] D=n1958 CK=clk_i_clone8
+ RB=FE_OFN67_i_reset_n_i
XLLR_reg[1][9] QDFFRBN $PINS Q=data_o[69] D=n1970 CK=clk_i_clone8
+ RB=FE_OFN27_i_reset_n_i
XLLR_reg[2][9] QDFFRBN $PINS Q=data_o[57] D=n1982 CK=clk_i_clone8
+ RB=FE_OFN45_i_reset_n_i
XLLR_reg[3][9] QDFFRBN $PINS Q=data_o[45] D=n1994 CK=clk_i_clone3
+ RB=FE_OFN59_i_reset_n_i
XLLR_reg[4][9] QDFFRBN $PINS Q=data_o[33] D=n2006 CK=clk_i_clone3
+ RB=FE_OFN122_i_reset_n_i
Xext_reg[0][6] QDFFRBN $PINS Q=ext[0][6] D=n2985 CK=clk_i_clone7
+ RB=FE_OFN23_i_reset_n_i
Xext_reg[0][5] QDFFRBN $PINS Q=ext[0][5] D=n2986 CK=clk_i_clone7
+ RB=FE_OFN25_i_reset_n_i
Xext_reg[0][4] QDFFRBN $PINS Q=ext[0][4] D=n2987 CK=clk_i_clone7
+ RB=FE_OFN64_i_reset_n_i
Xext_reg[1][6] QDFFRBN $PINS Q=ext[1][6] D=n2997 CK=clk_i_clone20
+ RB=FE_OFN8_i_reset_n_i
Xext_reg[1][5] QDFFRBN $PINS Q=ext[1][5] D=n2998 CK=clk_i_clone7
+ RB=FE_OFN64_i_reset_n_i
Xext_reg[1][4] QDFFRBN $PINS Q=ext[1][4] D=n2999 CK=clk_i_clone7
+ RB=FE_OFN64_i_reset_n_i
Xext_reg[2][6] QDFFRBN $PINS Q=ext[2][6] D=n3009 CK=clk_i_clone7
+ RB=FE_OFN25_i_reset_n_i
Xext_reg[2][5] QDFFRBN $PINS Q=ext[2][5] D=n3010 CK=clk_i_clone7
+ RB=FE_OFN64_i_reset_n_i
Xext_reg[2][4] QDFFRBN $PINS Q=ext[2][4] D=n3011 CK=clk_i_clone7
+ RB=FE_OFN85_i_reset_n_i
Xenc_reg[3][3] QDFFRBN $PINS Q=enc[3][3] D=n3078 CK=clk_i_clone19
+ RB=FE_OFN119_i_reset_n_i
Xenc_reg[5][3] QDFFRBN $PINS Q=enc[5][3] D=n3086 CK=clk_i_clone19
+ RB=FE_OFN118_i_reset_n_i
Xext_reg[3][5] QDFFRBN $PINS Q=ext[3][5] D=n3022 CK=clk_i_clone20
+ RB=FE_OFN40_i_reset_n_i
Xext_reg[3][4] QDFFRBN $PINS Q=ext[3][4] D=n3023 CK=clk_i_clone21
+ RB=FE_OFN307_i_reset_n_i
Xext_reg[3][3] QDFFRBN $PINS Q=ext[3][3] D=n3024 CK=clk_i_clone22
+ RB=FE_OFN434_i_reset_n_i
Xext_reg[5][5] QDFFRBN $PINS Q=ext[5][5] D=n3046 CK=clk_i_clone20
+ RB=FE_OFN21_i_reset_n_i
Xext_reg[5][4] QDFFRBN $PINS Q=ext[5][4] D=n3047 CK=clk_i_clone21
+ RB=FE_OFN307_i_reset_n_i
Xext_reg[5][3] QDFFRBN $PINS Q=ext[5][3] D=n3048 CK=clk_i_clone22
+ RB=FE_OFN434_i_reset_n_i
Xenc_reg[4][3] QDFFRBN $PINS Q=enc[4][3] D=n3082 CK=clk_i_clone19
+ RB=FE_OFN119_i_reset_n_i
Xenc_reg[6][3] QDFFRBN $PINS Q=enc[6][3] D=n3090 CK=clk_i_clone19
+ RB=FE_OFN118_i_reset_n_i
Xext_reg[4][5] QDFFRBN $PINS Q=ext[4][5] D=n3034 CK=clk_i_clone20
+ RB=FE_OFN40_i_reset_n_i
Xext_reg[4][4] QDFFRBN $PINS Q=ext[4][4] D=n3035 CK=clk_i_clone21
+ RB=FE_OFN62_i_reset_n_i
Xext_reg[4][3] QDFFRBN $PINS Q=ext[4][3] D=n3036 CK=clk_i_clone21
+ RB=FE_OFN307_i_reset_n_i
Xext_reg[6][5] QDFFRBN $PINS Q=ext[6][5] D=n3058 CK=clk_i_clone21
+ RB=FE_OFN60_i_reset_n_i
Xext_reg[6][4] QDFFRBN $PINS Q=ext[6][4] D=n3059 CK=clk_i_clone21
+ RB=FE_OFN60_i_reset_n_i
Xext_reg[6][3] QDFFRBN $PINS Q=ext[6][3] D=n3060 CK=clk_i_clone22
+ RB=FE_OFN123_i_reset_n_i
XLLR_reg[0][3] QDFFRBN $PINS Q=data_o[75] D=n1964 CK=clk_i_clone7
+ RB=FE_OFN65_i_reset_n_i
XLLR_reg[1][3] QDFFRBN $PINS Q=data_o[63] D=n1976 CK=clk_i_clone20
+ RB=FE_OFN124_i_reset_n_i
XLLR_reg[2][3] QDFFRBN $PINS Q=data_o[51] D=n1988 CK=clk_i_clone9
+ RB=FE_OFN86_i_reset_n_i
XLLR_reg[3][3] QDFFRBN $PINS Q=data_o[39] D=n2000 CK=clk_i_clone24
+ RB=FE_OFN101_i_reset_n_i
XLLR_reg[4][3] QDFFRBN $PINS Q=data_o[27] D=n2012 CK=clk_i_clone24
+ RB=FE_OFN101_i_reset_n_i
XLLR_reg[0][4] QDFFRBN $PINS Q=data_o[76] D=n1963 CK=clk_i_clone7
+ RB=FE_OFN43_i_reset_n_i
XLLR_reg[1][4] QDFFRBN $PINS Q=data_o[64] D=n1975 CK=clk_i_clone20
+ RB=FE_OFN108_i_reset_n_i
XLLR_reg[2][4] QDFFRBN $PINS Q=data_o[52] D=n1987 CK=clk_i_clone7
+ RB=FE_OFN65_i_reset_n_i
XLLR_reg[3][4] QDFFRBN $PINS Q=data_o[40] D=n1999 CK=clk_i_clone20
+ RB=FE_OFN102_i_reset_n_i
XLLR_reg[4][4] QDFFRBN $PINS Q=data_o[28] D=n2011 CK=clk_i_clone20
+ RB=FE_OFN102_i_reset_n_i
XLLR_reg[0][5] QDFFRBN $PINS Q=data_o[77] D=n1962 CK=clk_i_clone7
+ RB=FE_OFN25_i_reset_n_i
XLLR_reg[1][5] QDFFRBN $PINS Q=data_o[65] D=n1974 CK=clk_i_clone20
+ RB=FE_OFN24_i_reset_n_i
XLLR_reg[2][5] QDFFRBN $PINS Q=data_o[53] D=n1986 CK=clk_i_clone7
+ RB=FE_OFN43_i_reset_n_i
XLLR_reg[3][5] QDFFRBN $PINS Q=data_o[41] D=n1998 CK=clk_i_clone20
+ RB=FE_OFN61_i_reset_n_i
XLLR_reg[4][5] QDFFRBN $PINS Q=data_o[29] D=n2010 CK=clk_i_clone20
+ RB=FE_OFN125_i_reset_n_i
Xenc_reg[0][3] QDFFRBN $PINS Q=enc[0][3] D=n3066 CK=clk_i_clone23
+ RB=FE_OFN419_i_reset_n_i
Xenc_reg[0][2] QDFFRBN $PINS Q=enc[0][2] D=n3067 CK=clk_i_clone23
+ RB=FE_OFN113_i_reset_n_i
Xenc_reg[0][1] QDFFRBN $PINS Q=enc[0][1] D=n3068 CK=clk_i_clone22
+ RB=FE_OFN419_i_reset_n_i
Xenc_reg[1][3] QDFFRBN $PINS Q=enc[1][3] D=n3070 CK=clk_i_clone21
+ RB=FE_OFN95_i_reset_n_i
Xenc_reg[1][2] QDFFRBN $PINS Q=enc[1][2] D=n3071 CK=clk_i_clone23
+ RB=FE_OFN115_i_reset_n_i
Xenc_reg[1][1] QDFFRBN $PINS Q=enc[1][1] D=n3072 CK=clk_i_clone23
+ RB=FE_OFN113_i_reset_n_i
Xenc_reg[2][3] QDFFRBN $PINS Q=enc[2][3] D=n3074 CK=clk_i_clone21
+ RB=FE_OFN95_i_reset_n_i
Xenc_reg[2][2] QDFFRBN $PINS Q=enc[2][2] D=n3075 CK=clk_i_clone22
+ RB=FE_OFN114_i_reset_n_i
Xenc_reg[2][1] QDFFRBN $PINS Q=enc[2][1] D=n3076 CK=clk_i_clone22
+ RB=FE_OFN421_i_reset_n_i
Xext_reg[0][3] QDFFRBN $PINS Q=ext[0][3] D=n2988 CK=clk_i_clone7
+ RB=FE_OFN85_i_reset_n_i
Xext_reg[0][2] QDFFRBN $PINS Q=ext[0][2] D=n2989 CK=clk_i_clone9
+ RB=FE_OFN84_i_reset_n_i
Xext_reg[0][1] QDFFRBN $PINS Q=ext[0][1] D=n2990 CK=clk_i_clone9
+ RB=FE_OFN133_i_reset_n_i
Xext_reg[0][0] QDFFRBN $PINS Q=ext[0][0] D=n2991 CK=clk_i_clone9
+ RB=FE_OFN84_i_reset_n_i
Xext_reg[1][3] QDFFRBN $PINS Q=ext[1][3] D=n3000 CK=clk_i_clone20
+ RB=FE_OFN108_i_reset_n_i
Xext_reg[1][2] QDFFRBN $PINS Q=ext[1][2] D=n3001 CK=clk_i_clone24
+ RB=FE_OFN42_i_reset_n_i
Xext_reg[1][1] QDFFRBN $PINS Q=ext[1][1] D=n3002 CK=clk_i_clone24
+ RB=FE_OFN133_i_reset_n_i
Xext_reg[1][0] QDFFRBN $PINS Q=ext[1][0] D=n3003 CK=clk_i_clone24
+ RB=FE_OFN83_i_reset_n_i
Xext_reg[2][3] QDFFRBN $PINS Q=ext[2][3] D=n3012 CK=clk_i_clone7
+ RB=FE_OFN65_i_reset_n_i
Xext_reg[2][2] QDFFRBN $PINS Q=ext[2][2] D=n3013 CK=clk_i_clone9
+ RB=FE_OFN86_i_reset_n_i
Xext_reg[2][1] QDFFRBN $PINS Q=ext[2][1] D=n3014 CK=clk_i_clone9
+ RB=FE_OFN133_i_reset_n_i
Xext_reg[2][0] QDFFRBN $PINS Q=ext[2][0] D=n3015 CK=clk_i_clone9
+ RB=FE_OFN84_i_reset_n_i
Xsys_reg[0][3] QDFFRBN $PINS Q=sys[0][3] D=n2952 CK=clk_i_clone7
+ RB=FE_OFN85_i_reset_n_i
Xsys_reg[0][2] QDFFRBN $PINS Q=sys[0][2] D=n2953 CK=clk_i_clone9
+ RB=FE_OFN42_i_reset_n_i
Xsys_reg[0][1] QDFFRBN $PINS Q=sys[0][1] D=n2954 CK=clk_i_clone9
+ RB=FE_OFN63_i_reset_n_i
Xsys_reg[1][3] QDFFRBN $PINS Q=sys[1][3] D=n2956 CK=clk_i_clone20
+ RB=FE_OFN108_i_reset_n_i
Xsys_reg[1][2] QDFFRBN $PINS Q=sys[1][2] D=n2957 CK=clk_i_clone24
+ RB=FE_OFN22_i_reset_n_i
Xsys_reg[2][3] QDFFRBN $PINS Q=sys[2][3] D=n2960 CK=clk_i_clone20
+ RB=FE_OFN108_i_reset_n_i
Xsys_reg[2][2] QDFFRBN $PINS Q=sys[2][2] D=n2961 CK=clk_i_clone9
+ RB=FE_OFN63_i_reset_n_i
Xenc_reg[3][2] QDFFRBN $PINS Q=enc[3][2] D=n3079 CK=clk_i_clone19
+ RB=FE_OFN120_i_reset_n_i
Xenc_reg[3][1] QDFFRBN $PINS Q=enc[3][1] D=n3080 CK=clk_i_clone21
+ RB=FE_OFN117_i_reset_n_i
Xenc_reg[3][0] QDFFRBN $PINS Q=enc[3][0] D=n3081 CK=clk_i_clone21
+ RB=FE_OFN96_i_reset_n_i
Xenc_reg[5][2] QDFFRBN $PINS Q=enc[5][2] D=n3087 CK=clk_i_clone21
+ RB=FE_OFN55_i_reset_n_i
Xenc_reg[5][1] QDFFRBN $PINS Q=enc[5][1] D=n3088 CK=clk_i_clone21
+ RB=FE_OFN96_i_reset_n_i
Xenc_reg[5][0] QDFFRBN $PINS Q=enc[5][0] D=n3089 CK=clk_i_clone21
+ RB=FE_OFN79_i_reset_n_i
Xext_reg[3][2] QDFFRBN $PINS Q=ext[3][2] D=n3025 CK=clk_i_clone22
+ RB=FE_OFN7_i_reset_n_i
Xext_reg[3][1] QDFFRBN $PINS Q=ext[3][1] D=n3026 CK=clk_i_clone22
+ RB=FE_OFN370_i_reset_n_i
Xext_reg[3][0] QDFFRBN $PINS Q=ext[3][0] D=n3027 CK=clk_i_clone22
+ RB=FE_OFN82_i_reset_n_i
Xext_reg[5][2] QDFFRBN $PINS Q=ext[5][2] D=n3049 CK=clk_i_clone22
+ RB=FE_OFN421_i_reset_n_i
Xext_reg[5][1] QDFFRBN $PINS Q=ext[5][1] D=n3050 CK=clk_i_clone22
+ RB=FE_OFN419_i_reset_n_i
Xext_reg[5][0] QDFFRBN $PINS Q=ext[5][0] D=n3051 CK=clk_i_clone22
+ RB=FE_OFN419_i_reset_n_i
Xsys_reg[3][3] QDFFRBN $PINS Q=sys[3][3] D=n2964 CK=clk_i_clone22
+ RB=FE_OFN434_i_reset_n_i
Xsys_reg[3][2] QDFFRBN $PINS Q=sys[3][2] D=n2965 CK=clk_i_clone22
+ RB=FE_OFN7_i_reset_n_i
Xsys_reg[3][1] QDFFRBN $PINS Q=sys[3][1] D=n2966 CK=clk_i_clone22
+ RB=FE_OFN257_i_reset_n_i
Xsys_reg[3][0] QDFFRBN $PINS Q=sys[3][0] D=n2967 CK=clk_i_clone22
+ RB=FE_OFN370_i_reset_n_i
Xsys_reg[5][3] QDFFRBN $PINS Q=sys[5][3] D=n2972 CK=clk_i_clone23
+ RB=FE_OFN419_i_reset_n_i
Xsys_reg[5][2] QDFFRBN $PINS Q=sys[5][2] D=n2973 CK=clk_i_clone23
+ RB=FE_OFN78_i_reset_n_i
Xsys_reg[5][1] QDFFRBN $PINS Q=sys[5][1] D=n2974 CK=clk_i_clone23
+ RB=FE_OFN420_i_reset_n_i
Xsys_reg[5][0] QDFFRBN $PINS Q=sys[5][0] D=n2975 CK=clk_i_clone22
+ RB=FE_OFN370_i_reset_n_i
Xenc_reg[4][2] QDFFRBN $PINS Q=enc[4][2] D=n3083 CK=clk_i_clone19
+ RB=FE_OFN120_i_reset_n_i
Xenc_reg[4][1] QDFFRBN $PINS Q=enc[4][1] D=n3084 CK=clk_i_clone21
+ RB=FE_OFN117_i_reset_n_i
Xenc_reg[4][0] QDFFRBN $PINS Q=enc[4][0] D=n3085 CK=clk_i_clone21
+ RB=FE_OFN96_i_reset_n_i
Xenc_reg[6][2] QDFFRBN $PINS Q=enc[6][2] D=n3091 CK=clk_i_clone21
+ RB=FE_OFN96_i_reset_n_i
Xenc_reg[6][1] QDFFRBN $PINS Q=enc[6][1] D=n3092 CK=clk_i_clone21
+ RB=FE_OFN95_i_reset_n_i
Xenc_reg[6][0] QDFFRBN $PINS Q=enc[6][0] D=n3093 CK=clk_i_clone21
+ RB=FE_OFN95_i_reset_n_i
Xext_reg[4][2] QDFFRBN $PINS Q=ext[4][2] D=n3037 CK=clk_i_clone22
+ RB=FE_OFN7_i_reset_n_i
Xext_reg[4][1] QDFFRBN $PINS Q=ext[4][1] D=n3038 CK=clk_i_clone22
+ RB=FE_OFN369_i_reset_n_i
Xext_reg[4][0] QDFFRBN $PINS Q=ext[4][0] D=n3039 CK=clk_i_clone22
+ RB=FE_OFN369_i_reset_n_i
Xext_reg[6][2] QDFFRBN $PINS Q=ext[6][2] D=n3061 CK=clk_i_clone22
+ RB=FE_OFN421_i_reset_n_i
Xext_reg[6][1] QDFFRBN $PINS Q=ext[6][1] D=n3062 CK=clk_i_clone22
+ RB=FE_OFN419_i_reset_n_i
Xext_reg[6][0] QDFFRBN $PINS Q=ext[6][0] D=n3063 CK=clk_i_clone22
+ RB=FE_OFN257_i_reset_n_i
Xsys_reg[4][3] QDFFRBN $PINS Q=sys[4][3] D=n2968 CK=clk_i_clone22
+ RB=FE_OFN123_i_reset_n_i
Xsys_reg[4][2] QDFFRBN $PINS Q=sys[4][2] D=n2969 CK=clk_i_clone22
+ RB=FE_OFN257_i_reset_n_i
Xsys_reg[4][1] QDFFRBN $PINS Q=sys[4][1] D=n2970 CK=clk_i_clone22
+ RB=FE_OFN257_i_reset_n_i
Xsys_reg[4][0] QDFFRBN $PINS Q=sys[4][0] D=n2971 CK=clk_i_clone22
+ RB=FE_OFN370_i_reset_n_i
Xsys_reg[6][3] QDFFRBN $PINS Q=sys[6][3] D=n2976 CK=clk_i_clone23
+ RB=FE_OFN420_i_reset_n_i
Xsys_reg[6][2] QDFFRBN $PINS Q=sys[6][2] D=n2977 CK=clk_i_clone23
+ RB=FE_OFN420_i_reset_n_i
Xsys_reg[6][1] QDFFRBN $PINS Q=sys[6][1] D=n2978 CK=clk_i_clone22
+ RB=FE_OFN420_i_reset_n_i
Xsys_reg[6][0] QDFFRBN $PINS Q=sys[6][0] D=n2979 CK=clk_i_clone22
+ RB=FE_OFN370_i_reset_n_i
XLLR_reg[0][1] QDFFRBN $PINS Q=data_o[73] D=n1966 CK=clk_i_clone9
+ RB=FE_OFN128_i_reset_n_i
XLLR_reg[1][1] QDFFRBN $PINS Q=data_o[61] D=n1978 CK=clk_i_clone24
+ RB=FE_OFN104_i_reset_n_i
XLLR_reg[2][1] QDFFRBN $PINS Q=data_o[49] D=n1990 CK=clk_i_clone9
+ RB=FE_OFN127_i_reset_n_i
XLLR_reg[3][1] QDFFRBN $PINS Q=data_o[37] D=n2002 CK=clk_i_clone24
+ RB=FE_OFN103_i_reset_n_i
XLLR_reg[4][1] QDFFRBN $PINS Q=data_o[25] D=n2014 CK=clk_i_clone24
+ RB=FE_OFN103_i_reset_n_i
XLLR_reg[0][2] QDFFRBN $PINS Q=data_o[74] D=n1965 CK=clk_i_clone9
+ RB=FE_OFN106_i_reset_n_i
XLLR_reg[1][2] QDFFRBN $PINS Q=data_o[62] D=n1977 CK=clk_i_clone24
+ RB=FE_OFN22_i_reset_n_i
XLLR_reg[2][2] QDFFRBN $PINS Q=data_o[50] D=n1989 CK=clk_i_clone9
+ RB=FE_OFN106_i_reset_n_i
XLLR_reg[3][2] QDFFRBN $PINS Q=data_o[38] D=n2001 CK=clk_i_clone24
+ RB=FE_OFN101_i_reset_n_i
XLLR_reg[4][2] QDFFRBN $PINS Q=data_o[26] D=n2013 CK=clk_i_clone24
+ RB=FE_OFN126_i_reset_n_i
XLLR_reg[0][0] QDFFRBN $PINS Q=data_o[72] D=n1967 CK=clk_i_clone9
+ RB=FE_OFN107_i_reset_n_i
XLLR_reg[1][0] QDFFRBN $PINS Q=data_o[60] D=n1979 CK=clk_i_clone24
+ RB=FE_OFN104_i_reset_n_i
XLLR_reg[2][0] QDFFRBN $PINS Q=data_o[48] D=n1991 CK=clk_i_clone9
+ RB=FE_OFN107_i_reset_n_i
XLLR_reg[3][0] QDFFRBN $PINS Q=data_o[36] D=n2003 CK=clk_i_clone24
+ RB=FE_OFN103_i_reset_n_i
XLLR_reg[4][0] QDFFRBN $PINS Q=data_o[24] D=n2015 CK=clk_i_clone24
+ RB=FE_OFN103_i_reset_n_i
Xenc_reg[0][0] QDFFRBN $PINS Q=enc[0][0] D=n3069 CK=clk_i_clone23
+ RB=FE_OFN93_i_reset_n_i
Xenc_reg[1][0] QDFFRBN $PINS Q=enc[1][0] D=n3073 CK=clk_i_clone22
+ RB=FE_OFN421_i_reset_n_i
Xenc_reg[2][0] QDFFRBN $PINS Q=enc[2][0] D=n3077 CK=clk_i_clone22
+ RB=FE_OFN421_i_reset_n_i
Xsys_reg[0][0] QDFFRBN $PINS Q=sys[0][0] D=n2955 CK=clk_i_clone9
+ RB=FE_OFN133_i_reset_n_i
Xsys_reg[1][1] QDFFRBN $PINS Q=sys[1][1] D=n2958 CK=clk_i_clone24
+ RB=FE_OFN83_i_reset_n_i
Xsys_reg[1][0] QDFFRBN $PINS Q=sys[1][0] D=n2959 CK=clk_i_clone24
+ RB=FE_OFN137_i_reset_n_i
Xsys_reg[2][1] QDFFRBN $PINS Q=sys[2][1] D=n2962 CK=clk_i_clone9
+ RB=FE_OFN105_i_reset_n_i
Xsys_reg[2][0] QDFFRBN $PINS Q=sys[2][0] D=n2963 CK=clk_i_clone9
+ RB=FE_OFN137_i_reset_n_i
Xbranch_metrics_reg[0][3][11] QDFFRBN $PINS Q=branch_metrics[0][3][11] D=n2652
+ CK=CTS_59 RB=FE_OFN267_i_reset_n_i
Xbranch_metrics_reg[0][3][10] QDFFRBN $PINS Q=branch_metrics[0][3][10] D=n2653
+ CK=clk_i_clone5 RB=FE_OFN29_i_reset_n_i
Xbranch_metrics_reg[0][0][11] QDFFRBN $PINS Q=forward_sum[0][0][11] D=n2616
+ CK=clk_i RB=FE_OFN318_i_reset_n_i
Xbranch_metrics_reg[0][1][11] QDFFRBN $PINS Q=forward_sum[0][4][11] D=n2628
+ CK=clk_i_clone5 RB=FE_OFN47_i_reset_n_i
Xbranch_metrics_reg[6][1][9] QDFFRBN $PINS Q=backward_sum[0][1][9] D=n2918
+ CK=CTS_61 RB=FE_OFN497_i_reset_n_i
Xbranch_metrics_reg[6][3][9] QDFFRBN $PINS Q=backward_sum[0][3][9] D=n2942
+ CK=CTS_61 RB=FE_OFN497_i_reset_n_i
Xforward_metrics_reg[1][3][11] QDFFRBN $PINS Q=forward_metrics[1][3][11]
+ D=n2076 CK=CTS_58 RB=FE_OFN449_i_reset_n_i
Xforward_metrics_reg[2][3][11] QDFFRBN $PINS Q=forward_metrics[2][3][11]
+ D=n2124 CK=CTS_58 RB=FE_OFN449_i_reset_n_i
Xforward_metrics_reg[5][3][11] QDFFRBN $PINS Q=forward_metrics[5][3][11]
+ D=n2268 CK=CTS_58 RB=FE_OFN273_i_reset_n_i
Xforward_metrics_reg[6][3][11] QDFFRBN $PINS Q=forward_metrics[6][3][11]
+ D=n2316 CK=CTS_58 RB=FE_OFN390_i_reset_n_i
Xforward_metrics_reg[5][1][11] QDFFRBN $PINS Q=forward_metrics[5][1][11]
+ D=n2244 CK=CTS_58 RB=FE_OFN273_i_reset_n_i
Xforward_metrics_reg[6][1][11] QDFFRBN $PINS Q=forward_metrics[6][1][11]
+ D=n2292 CK=CTS_58 RB=FE_OFN448_i_reset_n_i
Xforward_metrics_reg[1][2][11] QDFFRBN $PINS Q=forward_metrics[1][2][11]
+ D=n2064 CK=CTS_58 RB=FE_OFN449_i_reset_n_i
Xforward_metrics_reg[2][2][11] QDFFRBN $PINS Q=forward_metrics[2][2][11]
+ D=n2112 CK=CTS_58 RB=FE_OFN390_i_reset_n_i
Xforward_metrics_reg[5][2][11] QDFFRBN $PINS Q=forward_metrics[5][2][11]
+ D=n2256 CK=CTS_58 RB=FE_OFN273_i_reset_n_i
Xforward_metrics_reg[6][2][11] QDFFRBN $PINS Q=forward_metrics[6][2][11]
+ D=n2304 CK=CTS_58 RB=FE_OFN390_i_reset_n_i
Xforward_metrics_reg[1][3][10] QDFFRBN $PINS Q=forward_metrics[1][3][10]
+ D=n2077 CK=CTS_58 RB=FE_OFN330_i_reset_n_i
Xforward_metrics_reg[2][3][10] QDFFRBN $PINS Q=forward_metrics[2][3][10]
+ D=n2125 CK=CTS_58 RB=FE_OFN273_i_reset_n_i
Xforward_metrics_reg[6][1][10] QDFFRBN $PINS Q=forward_metrics[6][1][10]
+ D=n2293 CK=CTS_58 RB=FE_OFN389_i_reset_n_i
Xforward_metrics_reg[2][0][11] QDFFRBN $PINS Q=forward_metrics[2][0][11]
+ D=n2088 CK=CTS_58 RB=FE_OFN478_i_reset_n_i
Xforward_metrics_reg[5][0][11] QDFFRBN $PINS Q=forward_metrics[5][0][11]
+ D=n2232 CK=CTS_58 RB=FE_OFN222_i_reset_n_i
Xforward_metrics_reg[6][0][11] QDFFRBN $PINS Q=forward_metrics[6][0][11]
+ D=n2280 CK=CTS_58 RB=FE_OFN448_i_reset_n_i
Xforward_metrics_reg[1][2][10] QDFFRBN $PINS Q=forward_metrics[1][2][10]
+ D=n2065 CK=CTS_58 RB=FE_OFN390_i_reset_n_i
Xforward_metrics_reg[2][2][10] QDFFRBN $PINS Q=forward_metrics[2][2][10]
+ D=n2113 CK=CTS_58 RB=FE_OFN330_i_reset_n_i
Xforward_metrics_reg[6][0][10] QDFFRBN $PINS Q=forward_metrics[6][0][10]
+ D=n2281 CK=CTS_58 RB=FE_OFN330_i_reset_n_i
Xforward_metrics_reg[6][2][9] QDFFRBN $PINS Q=forward_metrics[6][2][9] D=n2306
+ CK=CTS_61 RB=FE_OFN480_i_reset_n_i
Xforward_metrics_reg[6][3][9] QDFFRBN $PINS Q=forward_metrics[6][3][9] D=n2318
+ CK=CTS_61 RB=FE_OFN444_i_reset_n_i
Xforward_metrics_reg[6][2][10] QDFFRBN $PINS Q=forward_metrics[6][2][10]
+ D=n2305 CK=CTS_58 RB=FE_OFN330_i_reset_n_i
Xforward_metrics_reg[6][3][10] QDFFRBN $PINS Q=forward_metrics[6][3][10]
+ D=n2317 CK=CTS_58 RB=FE_OFN389_i_reset_n_i
Xbranch_metrics_reg[6][1][11] QDFFRBN $PINS Q=branch_metrics[6][1][11] D=n2916
+ CK=CTS_59 RB=FE_OFN481_i_reset_n_i
Xbranch_metrics_reg[6][3][11] QDFFRBN $PINS Q=branch_metrics[6][3][11] D=n2940
+ CK=CTS_59 RB=FE_OFN481_i_reset_n_i
Xbranch_metrics_reg[0][0][9] QDFFRBN $PINS Q=forward_sum[0][2][9] D=n2618
+ CK=clk_i_clone1 RB=FE_OFN48_i_reset_n_i
Xbranch_metrics_reg[0][0][8] QDFFRBN $PINS Q=forward_sum[0][2][8] D=n2619
+ CK=clk_i_clone1 RB=FE_OFN223_i_reset_n_i
Xbranch_metrics_reg[0][1][9] QDFFRBN $PINS Q=forward_sum[0][6][9] D=n2630
+ CK=clk_i_clone3 RB=FE_OFN320_i_reset_n_i
Xbranch_metrics_reg[0][1][8] QDFFRBN $PINS Q=forward_sum[0][6][8] D=n2631
+ CK=CTS_60 RB=FE_OFN215_i_reset_n_i
Xbranch_metrics_reg[6][0][11] QDFFRBN $PINS Q=backward_sum[0][0][11] D=n2904
+ CK=clk_i RB=FE_OFN379_i_reset_n_i
Xbackward_metrics_reg[6][2][11] QDFFRBN $PINS Q=backward_metrics[6][2][11]
+ D=n2592 CK=CTS_59 RB=FE_OFN218_i_reset_n_i
Xbackward_metrics_reg[6][2][10] QDFFRBN $PINS Q=backward_metrics[6][2][10]
+ D=n2593 CK=CTS_59 RB=FE_OFN218_i_reset_n_i
Xbackward_metrics_reg[6][0][11] QDFFRBN $PINS Q=backward_metrics[6][0][11]
+ D=n2568 CK=clk_i RB=FE_OFN26_i_reset_n_i
Xbackward_metrics_reg[6][0][10] QDFFRBN $PINS Q=backward_metrics[6][0][10]
+ D=n2569 CK=clk_i RB=FE_OFN26_i_reset_n_i
Xbackward_metrics_reg[6][0][8] QDFFRBN $PINS Q=backward_metrics[6][0][8]
+ D=n2571 CK=clk_i_clone10 RB=FE_OFN183_i_reset_n_i
Xbackward_metrics_reg[6][0][9] QDFFRBN $PINS Q=backward_metrics[6][0][9]
+ D=n2570 CK=clk_i_clone1 RB=FE_OFN30_i_reset_n_i
Xbackward_metrics_reg[6][2][8] QDFFRBN $PINS Q=backward_metrics[6][2][8]
+ D=n2595 CK=CTS_60 RB=FE_OFN214_i_reset_n_i
Xbackward_metrics_reg[6][2][9] QDFFRBN $PINS Q=backward_metrics[6][2][9]
+ D=n2594 CK=CTS_61 RB=FE_OFN443_i_reset_n_i
Xbranch_metrics_reg[1][1][11] QDFFRBN $PINS Q=branch_metrics[1][1][11] D=n2676
+ CK=CTS_59 RB=FE_OFN323_i_reset_n_i
Xbranch_metrics_reg[1][3][11] QDFFRBN $PINS Q=branch_metrics[1][3][11] D=n2700
+ CK=CTS_59 RB=FE_OFN323_i_reset_n_i
Xbranch_metrics_reg[2][0][11] QDFFRBN $PINS Q=branch_metrics[2][0][11] D=n2712
+ CK=clk_i RB=FE_OFN129_i_reset_n_i
Xbranch_metrics_reg[2][1][11] QDFFRBN $PINS Q=branch_metrics[2][1][11] D=n2724
+ CK=CTS_59 RB=FE_OFN385_i_reset_n_i
Xbranch_metrics_reg[2][3][11] QDFFRBN $PINS Q=branch_metrics[2][3][11] D=n2748
+ CK=CTS_59 RB=FE_OFN385_i_reset_n_i
Xbranch_metrics_reg[4][0][11] QDFFRBN $PINS Q=branch_metrics[4][0][11] D=n2808
+ CK=clk_i RB=FE_OFN109_i_reset_n_i
Xbranch_metrics_reg[5][0][11] QDFFRBN $PINS Q=branch_metrics[5][0][11] D=n2856
+ CK=CTS_58 RB=FE_OFN479_i_reset_n_i
Xbranch_metrics_reg[5][1][11] QDFFRBN $PINS Q=branch_metrics[5][1][11] D=n2868
+ CK=CTS_59 RB=FE_OFN499_i_reset_n_i
Xbranch_metrics_reg[0][2][9] QDFFRBN $PINS Q=forward_sum[0][1][9] D=n2642
+ CK=clk_i_clone1 RB=FE_OFN11_i_reset_n_i
Xbranch_metrics_reg[0][2][8] QDFFRBN $PINS Q=forward_sum[0][1][8] D=n2643
+ CK=clk_i_clone10 RB=FE_OFN223_i_reset_n_i
Xbranch_metrics_reg[0][3][9] QDFFRBN $PINS Q=forward_sum[0][5][9] D=n2654
+ CK=clk_i_clone3 RB=FE_OFN381_i_reset_n_i
Xbranch_metrics_reg[0][3][8] QDFFRBN $PINS Q=forward_sum[0][5][8] D=n2655
+ CK=CTS_60 RB=FE_OFN215_i_reset_n_i
Xbackward_metrics_reg[1][3][11] QDFFRBN $PINS Q=backward_metrics[1][3][11]
+ D=n2364 CK=CTS_59 RB=FE_OFN267_i_reset_n_i
Xbackward_metrics_reg[2][3][11] QDFFRBN $PINS Q=backward_metrics[2][3][11]
+ D=n2412 CK=clk_i_clone5 RB=FE_OFN90_i_reset_n_i
Xbackward_metrics_reg[3][3][11] QDFFRBN $PINS Q=backward_metrics[3][3][11]
+ D=n2460 CK=clk_i_clone3 RB=FE_OFN442_i_reset_n_i
Xbackward_metrics_reg[4][3][11] QDFFRBN $PINS Q=backward_metrics[4][3][11]
+ D=n2508 CK=clk_i_clone5 RB=FE_OFN90_i_reset_n_i
Xbackward_metrics_reg[5][3][11] QDFFRBN $PINS Q=backward_metrics[5][3][11]
+ D=n2556 CK=clk_i_clone5 RB=FE_OFN90_i_reset_n_i
Xbackward_metrics_reg[6][3][11] QDFFRBN $PINS Q=backward_metrics[6][3][11]
+ D=n2604 CK=clk_i_clone5 RB=FE_OFN47_i_reset_n_i
Xbackward_metrics_reg[1][3][10] QDFFRBN $PINS Q=backward_metrics[1][3][10]
+ D=n2365 CK=clk_i_clone3 RB=FE_OFN442_i_reset_n_i
Xbackward_metrics_reg[2][3][10] QDFFRBN $PINS Q=backward_metrics[2][3][10]
+ D=n2413 CK=CTS_59 RB=FE_OFN267_i_reset_n_i
Xbackward_metrics_reg[3][3][10] QDFFRBN $PINS Q=backward_metrics[3][3][10]
+ D=n2461 CK=clk_i_clone3 RB=FE_OFN442_i_reset_n_i
Xbackward_metrics_reg[4][3][10] QDFFRBN $PINS Q=backward_metrics[4][3][10]
+ D=n2509 CK=clk_i_clone5 RB=FE_OFN47_i_reset_n_i
Xbackward_metrics_reg[5][3][10] QDFFRBN $PINS Q=backward_metrics[5][3][10]
+ D=n2557 CK=clk_i_clone5 RB=FE_OFN90_i_reset_n_i
Xbackward_metrics_reg[6][3][10] QDFFRBN $PINS Q=backward_metrics[6][3][10]
+ D=n2605 CK=clk_i_clone5 RB=FE_OFN29_i_reset_n_i
Xbackward_metrics_reg[1][2][11] QDFFRBN $PINS Q=backward_metrics[1][2][11]
+ D=n2352 CK=CTS_59 RB=FE_OFN178_i_reset_n_i
Xbackward_metrics_reg[2][2][11] QDFFRBN $PINS Q=backward_metrics[2][2][11]
+ D=n2400 CK=CTS_59 RB=FE_OFN385_i_reset_n_i
Xbackward_metrics_reg[3][2][11] QDFFRBN $PINS Q=backward_metrics[3][2][11]
+ D=n2448 CK=CTS_59 RB=FE_OFN178_i_reset_n_i
Xbackward_metrics_reg[4][2][11] QDFFRBN $PINS Q=backward_metrics[4][2][11]
+ D=n2496 CK=CTS_59 RB=FE_OFN218_i_reset_n_i
Xbackward_metrics_reg[5][2][11] QDFFRBN $PINS Q=backward_metrics[5][2][11]
+ D=n2544 CK=CTS_59 RB=FE_OFN385_i_reset_n_i
Xbackward_metrics_reg[1][1][11] QDFFRBN $PINS Q=backward_metrics[1][1][11]
+ D=n2340 CK=clk_i RB=FE_OFN479_i_reset_n_i
Xbackward_metrics_reg[2][1][11] QDFFRBN $PINS Q=backward_metrics[2][1][11]
+ D=n2388 CK=clk_i RB=FE_OFN66_i_reset_n_i
Xbackward_metrics_reg[3][1][11] QDFFRBN $PINS Q=backward_metrics[3][1][11]
+ D=n2436 CK=CTS_58 RB=FE_OFN495_i_reset_n_i
Xbackward_metrics_reg[4][1][11] QDFFRBN $PINS Q=backward_metrics[4][1][11]
+ D=n2484 CK=clk_i RB=FE_OFN318_i_reset_n_i
Xbackward_metrics_reg[5][1][11] QDFFRBN $PINS Q=backward_metrics[5][1][11]
+ D=n2532 CK=clk_i RB=FE_OFN263_i_reset_n_i
Xbackward_metrics_reg[6][1][11] QDFFRBN $PINS Q=backward_metrics[6][1][11]
+ D=n2580 CK=clk_i RB=FE_OFN318_i_reset_n_i
Xbackward_metrics_reg[1][3][9] QDFFRBN $PINS Q=backward_metrics[1][3][9]
+ D=n2366 CK=CTS_61 RB=FE_OFN265_i_reset_n_i
Xbackward_metrics_reg[2][3][9] QDFFRBN $PINS Q=backward_metrics[2][3][9]
+ D=n2414 CK=CTS_61 RB=FE_OFN381_i_reset_n_i
Xbackward_metrics_reg[3][3][9] QDFFRBN $PINS Q=backward_metrics[3][3][9]
+ D=n2462 CK=CTS_61 RB=FE_OFN265_i_reset_n_i
Xbackward_metrics_reg[4][3][9] QDFFRBN $PINS Q=backward_metrics[4][3][9]
+ D=n2510 CK=CTS_61 RB=FE_OFN265_i_reset_n_i
Xbackward_metrics_reg[5][3][9] QDFFRBN $PINS Q=backward_metrics[5][3][9]
+ D=n2558 CK=CTS_61 RB=FE_OFN381_i_reset_n_i
Xbackward_metrics_reg[1][2][10] QDFFRBN $PINS Q=backward_metrics[1][2][10]
+ D=n2353 CK=CTS_59 RB=FE_OFN178_i_reset_n_i
Xbackward_metrics_reg[2][2][10] QDFFRBN $PINS Q=backward_metrics[2][2][10]
+ D=n2401 CK=CTS_59 RB=FE_OFN498_i_reset_n_i
Xbackward_metrics_reg[3][2][10] QDFFRBN $PINS Q=backward_metrics[3][2][10]
+ D=n2449 CK=CTS_59 RB=FE_OFN443_i_reset_n_i
Xbackward_metrics_reg[4][2][10] QDFFRBN $PINS Q=backward_metrics[4][2][10]
+ D=n2497 CK=CTS_59 RB=FE_OFN218_i_reset_n_i
Xbackward_metrics_reg[5][2][10] QDFFRBN $PINS Q=backward_metrics[5][2][10]
+ D=n2545 CK=CTS_59 RB=FE_OFN385_i_reset_n_i
Xbackward_metrics_reg[1][0][11] QDFFRBN $PINS Q=backward_metrics[1][0][11]
+ D=n2328 CK=CTS_58 RB=FE_OFN479_i_reset_n_i
Xbackward_metrics_reg[2][0][11] QDFFRBN $PINS Q=backward_metrics[2][0][11]
+ D=n2376 CK=clk_i RB=FE_OFN66_i_reset_n_i
Xbackward_metrics_reg[3][0][11] QDFFRBN $PINS Q=backward_metrics[3][0][11]
+ D=n2424 CK=CTS_58 RB=FE_OFN495_i_reset_n_i
Xbackward_metrics_reg[4][0][11] QDFFRBN $PINS Q=backward_metrics[4][0][11]
+ D=n2472 CK=clk_i RB=FE_OFN318_i_reset_n_i
Xbackward_metrics_reg[5][0][11] QDFFRBN $PINS Q=backward_metrics[5][0][11]
+ D=n2520 CK=clk_i RB=FE_OFN44_i_reset_n_i
Xbackward_metrics_reg[1][1][10] QDFFRBN $PINS Q=backward_metrics[1][1][10]
+ D=n2341 CK=CTS_58 RB=FE_OFN495_i_reset_n_i
Xbackward_metrics_reg[2][1][10] QDFFRBN $PINS Q=backward_metrics[2][1][10]
+ D=n2389 CK=clk_i RB=FE_OFN9_i_reset_n_i
Xbackward_metrics_reg[3][1][10] QDFFRBN $PINS Q=backward_metrics[3][1][10]
+ D=n2437 CK=CTS_58 RB=FE_OFN495_i_reset_n_i
Xbackward_metrics_reg[4][1][10] QDFFRBN $PINS Q=backward_metrics[4][1][10]
+ D=n2485 CK=clk_i RB=FE_OFN318_i_reset_n_i
Xbackward_metrics_reg[5][1][10] QDFFRBN $PINS Q=backward_metrics[5][1][10]
+ D=n2533 CK=clk_i RB=FE_OFN9_i_reset_n_i
Xbackward_metrics_reg[1][3][8] QDFFRBN $PINS Q=backward_metrics[1][3][8]
+ D=n2367 CK=CTS_60 RB=FE_OFN265_i_reset_n_i
Xbackward_metrics_reg[4][3][8] QDFFRBN $PINS Q=backward_metrics[4][3][8]
+ D=n2511 CK=CTS_60 RB=FE_OFN215_i_reset_n_i
Xbackward_metrics_reg[1][2][9] QDFFRBN $PINS Q=backward_metrics[1][2][9]
+ D=n2354 CK=CTS_61 RB=FE_OFN216_i_reset_n_i
Xbackward_metrics_reg[2][2][9] QDFFRBN $PINS Q=backward_metrics[2][2][9]
+ D=n2402 CK=CTS_61 RB=FE_OFN216_i_reset_n_i
Xbackward_metrics_reg[3][2][9] QDFFRBN $PINS Q=backward_metrics[3][2][9]
+ D=n2450 CK=CTS_60 RB=FE_OFN216_i_reset_n_i
Xbackward_metrics_reg[4][2][9] QDFFRBN $PINS Q=backward_metrics[4][2][9]
+ D=n2498 CK=CTS_61 RB=FE_OFN216_i_reset_n_i
Xbackward_metrics_reg[5][2][9] QDFFRBN $PINS Q=backward_metrics[5][2][9]
+ D=n2546 CK=CTS_61 RB=FE_OFN443_i_reset_n_i
Xbackward_metrics_reg[1][0][10] QDFFRBN $PINS Q=backward_metrics[1][0][10]
+ D=n2329 CK=CTS_58 RB=FE_OFN495_i_reset_n_i
Xbackward_metrics_reg[2][0][10] QDFFRBN $PINS Q=backward_metrics[2][0][10]
+ D=n2377 CK=clk_i RB=FE_OFN66_i_reset_n_i
Xbackward_metrics_reg[3][0][10] QDFFRBN $PINS Q=backward_metrics[3][0][10]
+ D=n2425 CK=CTS_58 RB=FE_OFN495_i_reset_n_i
Xbackward_metrics_reg[4][0][10] QDFFRBN $PINS Q=backward_metrics[4][0][10]
+ D=n2473 CK=clk_i RB=FE_OFN318_i_reset_n_i
Xbackward_metrics_reg[5][0][10] QDFFRBN $PINS Q=backward_metrics[5][0][10]
+ D=n2521 CK=clk_i RB=FE_OFN44_i_reset_n_i
Xbackward_metrics_reg[1][1][9] QDFFRBN $PINS Q=backward_metrics[1][1][9]
+ D=n2342 CK=clk_i_clone1 RB=FE_OFN336_i_reset_n_i
Xbackward_metrics_reg[2][1][9] QDFFRBN $PINS Q=backward_metrics[2][1][9]
+ D=n2390 CK=clk_i_clone1 RB=FE_OFN72_i_reset_n_i
Xbackward_metrics_reg[3][1][9] QDFFRBN $PINS Q=backward_metrics[3][1][9]
+ D=n2438 CK=clk_i_clone1 RB=FE_OFN279_i_reset_n_i
Xbackward_metrics_reg[4][1][9] QDFFRBN $PINS Q=backward_metrics[4][1][9]
+ D=n2486 CK=clk_i_clone1 RB=FE_OFN30_i_reset_n_i
Xbackward_metrics_reg[5][1][9] QDFFRBN $PINS Q=backward_metrics[5][1][9]
+ D=n2534 CK=clk_i_clone1 RB=FE_OFN72_i_reset_n_i
Xbackward_metrics_reg[4][2][8] QDFFRBN $PINS Q=backward_metrics[4][2][8]
+ D=n2499 CK=CTS_60 RB=FE_OFN177_i_reset_n_i
Xbackward_metrics_reg[1][1][8] QDFFRBN $PINS Q=backward_metrics[1][1][8]
+ D=n2343 CK=clk_i_clone1 RB=FE_OFN333_i_reset_n_i
Xbackward_metrics_reg[4][1][8] QDFFRBN $PINS Q=backward_metrics[4][1][8]
+ D=n2487 CK=clk_i_clone1 RB=FE_OFN223_i_reset_n_i
Xbackward_metrics_reg[1][0][9] QDFFRBN $PINS Q=backward_metrics[1][0][9]
+ D=n2330 CK=clk_i_clone1 RB=FE_OFN279_i_reset_n_i
Xbackward_metrics_reg[2][0][9] QDFFRBN $PINS Q=backward_metrics[2][0][9]
+ D=n2378 CK=clk_i_clone1 RB=FE_OFN72_i_reset_n_i
Xbackward_metrics_reg[3][0][9] QDFFRBN $PINS Q=backward_metrics[3][0][9]
+ D=n2426 CK=clk_i_clone1 RB=FE_OFN226_i_reset_n_i
Xbackward_metrics_reg[4][0][9] QDFFRBN $PINS Q=backward_metrics[4][0][9]
+ D=n2474 CK=clk_i_clone1 RB=FE_OFN30_i_reset_n_i
Xbackward_metrics_reg[5][0][9] QDFFRBN $PINS Q=backward_metrics[5][0][9]
+ D=n2522 CK=clk_i_clone1 RB=FE_OFN48_i_reset_n_i
Xbackward_metrics_reg[1][0][8] QDFFRBN $PINS Q=backward_metrics[1][0][8]
+ D=n2331 CK=clk_i_clone10 RB=FE_OFN224_i_reset_n_i
Xbackward_metrics_reg[3][0][8] QDFFRBN $PINS Q=backward_metrics[3][0][8]
+ D=n2427 CK=clk_i_clone10 RB=FE_OFN275_i_reset_n_i
Xbackward_metrics_reg[1][0][7] QDFFRBN $PINS Q=backward_metrics[1][0][7]
+ D=n2332 CK=CTS_57 RB=FE_OFN188_i_reset_n_i
Xbackward_metrics_reg[5][1][8] QDFFRBN $PINS Q=backward_metrics[5][1][8]
+ D=n2535 CK=clk_i_clone1 RB=FE_OFN1_i_reset_n_i
Xbackward_metrics_reg[6][1][8] QDFFRBN $PINS Q=backward_metrics[6][1][8]
+ D=n2583 CK=clk_i_clone1 RB=FE_OFN223_i_reset_n_i
Xbackward_metrics_reg[5][2][8] QDFFRBN $PINS Q=backward_metrics[5][2][8]
+ D=n2547 CK=CTS_60 RB=FE_OFN177_i_reset_n_i
Xbackward_metrics_reg[6][1][9] QDFFRBN $PINS Q=backward_metrics[6][1][9]
+ D=n2582 CK=clk_i_clone1 RB=FE_OFN30_i_reset_n_i
Xbackward_metrics_reg[5][3][8] QDFFRBN $PINS Q=backward_metrics[5][3][8]
+ D=n2559 CK=CTS_60 RB=FE_OFN215_i_reset_n_i
Xbackward_metrics_reg[6][3][8] QDFFRBN $PINS Q=backward_metrics[6][3][8]
+ D=n2607 CK=CTS_60 RB=FE_OFN215_i_reset_n_i
Xbackward_metrics_reg[6][1][10] QDFFRBN $PINS Q=backward_metrics[6][1][10]
+ D=n2581 CK=clk_i RB=FE_OFN9_i_reset_n_i
Xbackward_metrics_reg[6][3][9] QDFFRBN $PINS Q=backward_metrics[6][3][9]
+ D=n2606 CK=clk_i_clone3 RB=FE_OFN320_i_reset_n_i
Xbranch_metrics_reg[0][2][11] QDFFRBN $PINS Q=branch_metrics[0][2][11] D=n2640
+ CK=clk_i RB=FE_OFN26_i_reset_n_i
Xbranch_metrics_reg[0][2][10] QDFFRBN $PINS Q=branch_metrics[0][2][10] D=n2641
+ CK=clk_i RB=FE_OFN26_i_reset_n_i
Xbranch_metrics_reg[0][1][10] QDFFRBN $PINS Q=forward_sum[0][4][10] D=n2629
+ CK=clk_i_clone3 RB=FE_OFN442_i_reset_n_i
Xbranch_metrics_reg[6][0][9] QDFFRBN $PINS Q=backward_sum[0][4][9] D=n2906
+ CK=CTS_62 RB=FE_OFN383_i_reset_n_i
Xbranch_metrics_reg[6][0][8] QDFFRBN $PINS Q=backward_sum[0][4][8] D=n2907
+ CK=clk_i_clone1 RB=FE_OFN333_i_reset_n_i
Xbranch_metrics_reg[6][0][7] QDFFRBN $PINS Q=backward_sum[0][4][7] D=n2908
+ CK=clk_i_clone10 RB=FE_OFN331_i_reset_n_i
Xbranch_metrics_reg[6][0][6] QDFFRBN $PINS Q=backward_sum[0][4][6] D=n2909
+ CK=clk_i_clone10 RB=FE_OFN187_i_reset_n_i
Xbranch_metrics_reg[6][0][5] QDFFRBN $PINS Q=backward_sum[0][4][5] D=n2910
+ CK=clk_i_clone12 RB=FE_OFN281_i_reset_n_i
Xbranch_metrics_reg[6][0][4] QDFFRBN $PINS Q=backward_sum[0][4][4] D=n2911
+ CK=clk_i_clone13 RB=FE_OFN33_i_reset_n_i
Xbranch_metrics_reg[6][0][3] QDFFRBN $PINS Q=backward_sum[0][4][3] D=n2912
+ CK=CTS_56 RB=FE_OFN337_i_reset_n_i
Xbranch_metrics_reg[6][1][8] QDFFRBN $PINS Q=backward_sum[0][1][8] D=n2919
+ CK=CTS_62 RB=FE_OFN321_i_reset_n_i
Xbranch_metrics_reg[6][1][7] QDFFRBN $PINS Q=backward_sum[0][1][7] D=n2920
+ CK=CTS_62 RB=FE_OFN452_i_reset_n_i
Xbranch_metrics_reg[6][1][6] QDFFRBN $PINS Q=backward_sum[0][1][6] D=n2921
+ CK=CTS_57 RB=FE_OFN350_i_reset_n_i
Xbranch_metrics_reg[6][1][5] QDFFRBN $PINS Q=backward_sum[0][1][5] D=n2922
+ CK=CTS_55 RB=FE_OFN352_i_reset_n_i
Xbranch_metrics_reg[6][1][4] QDFFRBN $PINS Q=backward_sum[0][1][4] D=n2923
+ CK=CTS_53 RB=FE_OFN157_i_reset_n_i
Xbranch_metrics_reg[6][1][3] QDFFRBN $PINS Q=backward_sum[0][1][3] D=n2924
+ CK=CTS_53 RB=FE_OFN342_i_reset_n_i
Xbranch_metrics_reg[6][2][9] QDFFRBN $PINS Q=backward_sum[0][6][9] D=n2930
+ CK=clk_i_clone1 RB=FE_OFN336_i_reset_n_i
Xbranch_metrics_reg[6][2][8] QDFFRBN $PINS Q=backward_sum[0][6][8] D=n2931
+ CK=clk_i_clone1 RB=FE_OFN275_i_reset_n_i
Xbranch_metrics_reg[6][2][7] QDFFRBN $PINS Q=backward_sum[0][6][7] D=n2932
+ CK=clk_i_clone10 RB=FE_OFN224_i_reset_n_i
Xbranch_metrics_reg[6][2][6] QDFFRBN $PINS Q=backward_sum[0][6][6] D=n2933
+ CK=clk_i_clone10 RB=FE_OFN188_i_reset_n_i
Xbranch_metrics_reg[6][2][5] QDFFRBN $PINS Q=backward_sum[0][6][5] D=n2934
+ CK=clk_i_clone12 RB=FE_OFN281_i_reset_n_i
Xbranch_metrics_reg[6][2][4] QDFFRBN $PINS Q=backward_sum[0][6][4] D=n2935
+ CK=clk_i_clone13 RB=FE_OFN33_i_reset_n_i
Xbranch_metrics_reg[6][2][3] QDFFRBN $PINS Q=backward_sum[0][6][3] D=n2936
+ CK=CTS_52 RB=FE_OFN337_i_reset_n_i
Xbranch_metrics_reg[6][3][8] QDFFRBN $PINS Q=backward_sum[0][3][8] D=n2943
+ CK=CTS_62 RB=FE_OFN217_i_reset_n_i
Xbranch_metrics_reg[6][3][7] QDFFRBN $PINS Q=backward_sum[0][3][7] D=n2944
+ CK=CTS_62 RB=FE_OFN452_i_reset_n_i
Xbranch_metrics_reg[6][3][6] QDFFRBN $PINS Q=backward_sum[0][3][6] D=n2945
+ CK=CTS_57 RB=FE_OFN451_i_reset_n_i
Xbranch_metrics_reg[6][3][5] QDFFRBN $PINS Q=backward_sum[0][3][5] D=n2946
+ CK=CTS_55 RB=FE_OFN411_i_reset_n_i
Xbranch_metrics_reg[6][3][4] QDFFRBN $PINS Q=backward_sum[0][3][4] D=n2947
+ CK=CTS_53 RB=FE_OFN157_i_reset_n_i
Xbranch_metrics_reg[6][3][3] QDFFRBN $PINS Q=backward_sum[0][3][3] D=n2948
+ CK=CTS_53 RB=FE_OFN342_i_reset_n_i
Xforward_metrics_reg[3][3][11] QDFFRBN $PINS Q=forward_metrics[3][3][11]
+ D=n2172 CK=CTS_59 RB=FE_OFN182_i_reset_n_i
Xforward_metrics_reg[4][3][11] QDFFRBN $PINS Q=forward_metrics[4][3][11]
+ D=n2220 CK=CTS_59 RB=FE_OFN449_i_reset_n_i
Xforward_metrics_reg[1][1][11] QDFFRBN $PINS Q=forward_metrics[1][1][11]
+ D=n2052 CK=clk_i RB=FE_OFN379_i_reset_n_i
Xforward_metrics_reg[2][1][11] QDFFRBN $PINS Q=forward_metrics[2][1][11]
+ D=n2100 CK=CTS_58 RB=FE_OFN448_i_reset_n_i
Xforward_metrics_reg[3][1][11] QDFFRBN $PINS Q=forward_metrics[3][1][11]
+ D=n2148 CK=CTS_59 RB=FE_OFN182_i_reset_n_i
Xforward_metrics_reg[4][1][11] QDFFRBN $PINS Q=forward_metrics[4][1][11]
+ D=n2196 CK=clk_i RB=FE_OFN379_i_reset_n_i
Xforward_metrics_reg[3][2][11] QDFFRBN $PINS Q=forward_metrics[3][2][11]
+ D=n2160 CK=CTS_58 RB=FE_OFN182_i_reset_n_i
Xforward_metrics_reg[4][2][11] QDFFRBN $PINS Q=forward_metrics[4][2][11]
+ D=n2208 CK=CTS_58 RB=FE_OFN449_i_reset_n_i
Xforward_metrics_reg[3][3][10] QDFFRBN $PINS Q=forward_metrics[3][3][10]
+ D=n2173 CK=CTS_61 RB=FE_OFN496_i_reset_n_i
Xforward_metrics_reg[4][3][10] QDFFRBN $PINS Q=forward_metrics[4][3][10]
+ D=n2221 CK=CTS_58 RB=FE_OFN273_i_reset_n_i
Xforward_metrics_reg[5][3][10] QDFFRBN $PINS Q=forward_metrics[5][3][10]
+ D=n2269 CK=CTS_58 RB=FE_OFN182_i_reset_n_i
Xforward_metrics_reg[1][1][10] QDFFRBN $PINS Q=forward_metrics[1][1][10]
+ D=n2053 CK=CTS_58 RB=FE_OFN441_i_reset_n_i
Xforward_metrics_reg[2][1][10] QDFFRBN $PINS Q=forward_metrics[2][1][10]
+ D=n2101 CK=CTS_58 RB=FE_OFN441_i_reset_n_i
Xforward_metrics_reg[3][1][10] QDFFRBN $PINS Q=forward_metrics[3][1][10]
+ D=n2149 CK=CTS_61 RB=FE_OFN496_i_reset_n_i
Xforward_metrics_reg[4][1][10] QDFFRBN $PINS Q=forward_metrics[4][1][10]
+ D=n2197 CK=clk_i RB=FE_OFN379_i_reset_n_i
Xforward_metrics_reg[5][1][10] QDFFRBN $PINS Q=forward_metrics[5][1][10]
+ D=n2245 CK=CTS_58 RB=FE_OFN222_i_reset_n_i
Xforward_metrics_reg[1][0][11] QDFFRBN $PINS Q=forward_metrics[1][0][11]
+ D=n2040 CK=CTS_58 RB=FE_OFN478_i_reset_n_i
Xforward_metrics_reg[3][0][11] QDFFRBN $PINS Q=forward_metrics[3][0][11]
+ D=n2136 CK=CTS_58 RB=FE_OFN222_i_reset_n_i
Xforward_metrics_reg[4][0][11] QDFFRBN $PINS Q=forward_metrics[4][0][11]
+ D=n2184 CK=CTS_58 RB=FE_OFN478_i_reset_n_i
Xforward_metrics_reg[3][2][10] QDFFRBN $PINS Q=forward_metrics[3][2][10]
+ D=n2161 CK=CTS_61 RB=FE_OFN149_i_reset_n_i
Xforward_metrics_reg[4][2][10] QDFFRBN $PINS Q=forward_metrics[4][2][10]
+ D=n2209 CK=CTS_58 RB=FE_OFN448_i_reset_n_i
Xforward_metrics_reg[5][2][10] QDFFRBN $PINS Q=forward_metrics[5][2][10]
+ D=n2257 CK=CTS_59 RB=FE_OFN182_i_reset_n_i
Xforward_metrics_reg[1][3][9] QDFFRBN $PINS Q=forward_metrics[1][3][9] D=n2078
+ CK=CTS_61 RB=FE_OFN480_i_reset_n_i
Xforward_metrics_reg[2][3][9] QDFFRBN $PINS Q=forward_metrics[2][3][9] D=n2126
+ CK=CTS_61 RB=FE_OFN444_i_reset_n_i
Xforward_metrics_reg[3][3][9] QDFFRBN $PINS Q=forward_metrics[3][3][9] D=n2174
+ CK=CTS_61 RB=FE_OFN382_i_reset_n_i
Xforward_metrics_reg[4][3][9] QDFFRBN $PINS Q=forward_metrics[4][3][9] D=n2222
+ CK=CTS_61 RB=FE_OFN496_i_reset_n_i
Xforward_metrics_reg[1][3][8] QDFFRBN $PINS Q=forward_metrics[1][3][8] D=n2079
+ CK=CTS_62 RB=FE_OFN453_i_reset_n_i
Xforward_metrics_reg[2][3][8] QDFFRBN $PINS Q=forward_metrics[2][3][8] D=n2127
+ CK=clk_i_clone1 RB=FE_OFN335_i_reset_n_i
Xforward_metrics_reg[3][3][8] QDFFRBN $PINS Q=forward_metrics[3][3][8] D=n2175
+ CK=CTS_62 RB=FE_OFN453_i_reset_n_i
Xforward_metrics_reg[4][3][8] QDFFRBN $PINS Q=forward_metrics[4][3][8] D=n2223
+ CK=CTS_62 RB=FE_OFN453_i_reset_n_i
Xforward_metrics_reg[1][1][9] QDFFRBN $PINS Q=forward_metrics[1][1][9] D=n2054
+ CK=CTS_61 RB=FE_OFN444_i_reset_n_i
Xforward_metrics_reg[2][1][9] QDFFRBN $PINS Q=forward_metrics[2][1][9] D=n2102
+ CK=CTS_62 RB=FE_OFN383_i_reset_n_i
Xforward_metrics_reg[3][1][9] QDFFRBN $PINS Q=forward_metrics[3][1][9] D=n2150
+ CK=CTS_62 RB=FE_OFN322_i_reset_n_i
Xforward_metrics_reg[4][1][9] QDFFRBN $PINS Q=forward_metrics[4][1][9] D=n2198
+ CK=CTS_61 RB=FE_OFN444_i_reset_n_i
Xforward_metrics_reg[5][1][9] QDFFRBN $PINS Q=forward_metrics[5][1][9] D=n2246
+ CK=CTS_62 RB=FE_OFN383_i_reset_n_i
Xforward_metrics_reg[1][0][10] QDFFRBN $PINS Q=forward_metrics[1][0][10]
+ D=n2041 CK=CTS_58 RB=FE_OFN448_i_reset_n_i
Xforward_metrics_reg[2][0][10] QDFFRBN $PINS Q=forward_metrics[2][0][10]
+ D=n2089 CK=CTS_58 RB=FE_OFN441_i_reset_n_i
Xforward_metrics_reg[3][0][10] QDFFRBN $PINS Q=forward_metrics[3][0][10]
+ D=n2137 CK=CTS_61 RB=FE_OFN496_i_reset_n_i
Xforward_metrics_reg[4][0][10] QDFFRBN $PINS Q=forward_metrics[4][0][10]
+ D=n2185 CK=CTS_58 RB=FE_OFN448_i_reset_n_i
Xforward_metrics_reg[5][0][10] QDFFRBN $PINS Q=forward_metrics[5][0][10]
+ D=n2233 CK=CTS_58 RB=FE_OFN222_i_reset_n_i
Xforward_metrics_reg[1][2][9] QDFFRBN $PINS Q=forward_metrics[1][2][9] D=n2066
+ CK=CTS_61 RB=FE_OFN480_i_reset_n_i
Xforward_metrics_reg[2][2][9] QDFFRBN $PINS Q=forward_metrics[2][2][9] D=n2114
+ CK=CTS_62 RB=FE_OFN322_i_reset_n_i
Xforward_metrics_reg[3][2][9] QDFFRBN $PINS Q=forward_metrics[3][2][9] D=n2162
+ CK=CTS_62 RB=FE_OFN266_i_reset_n_i
Xforward_metrics_reg[4][2][9] QDFFRBN $PINS Q=forward_metrics[4][2][9] D=n2210
+ CK=CTS_61 RB=FE_OFN480_i_reset_n_i
Xforward_metrics_reg[5][2][9] QDFFRBN $PINS Q=forward_metrics[5][2][9] D=n2258
+ CK=CTS_62 RB=FE_OFN322_i_reset_n_i
Xforward_metrics_reg[1][1][8] QDFFRBN $PINS Q=forward_metrics[1][1][8] D=n2055
+ CK=clk_i_clone1 RB=FE_OFN278_i_reset_n_i
Xforward_metrics_reg[2][1][8] QDFFRBN $PINS Q=forward_metrics[2][1][8] D=n2103
+ CK=CTS_62 RB=FE_OFN334_i_reset_n_i
Xforward_metrics_reg[3][1][8] QDFFRBN $PINS Q=forward_metrics[3][1][8] D=n2151
+ CK=CTS_62 RB=FE_OFN394_i_reset_n_i
Xforward_metrics_reg[4][1][8] QDFFRBN $PINS Q=forward_metrics[4][1][8] D=n2199
+ CK=clk_i_clone1 RB=FE_OFN278_i_reset_n_i
Xforward_metrics_reg[1][2][8] QDFFRBN $PINS Q=forward_metrics[1][2][8] D=n2067
+ CK=clk_i_clone1 RB=FE_OFN278_i_reset_n_i
Xforward_metrics_reg[2][2][8] QDFFRBN $PINS Q=forward_metrics[2][2][8] D=n2115
+ CK=CTS_62 RB=FE_OFN453_i_reset_n_i
Xforward_metrics_reg[3][2][8] QDFFRBN $PINS Q=forward_metrics[3][2][8] D=n2163
+ CK=CTS_62 RB=FE_OFN456_i_reset_n_i
Xforward_metrics_reg[4][2][8] QDFFRBN $PINS Q=forward_metrics[4][2][8] D=n2211
+ CK=CTS_62 RB=FE_OFN334_i_reset_n_i
Xforward_metrics_reg[1][3][7] QDFFRBN $PINS Q=forward_metrics[1][3][7] D=n2080
+ CK=CTS_57 RB=FE_OFN332_i_reset_n_i
Xforward_metrics_reg[2][3][7] QDFFRBN $PINS Q=forward_metrics[2][3][7] D=n2128
+ CK=CTS_62 RB=FE_OFN452_i_reset_n_i
Xforward_metrics_reg[3][3][7] QDFFRBN $PINS Q=forward_metrics[3][3][7] D=n2176
+ CK=CTS_62 RB=FE_OFN392_i_reset_n_i
Xforward_metrics_reg[1][3][6] QDFFRBN $PINS Q=forward_metrics[1][3][6] D=n2081
+ CK=CTS_57 RB=FE_OFN409_i_reset_n_i
Xforward_metrics_reg[2][3][6] QDFFRBN $PINS Q=forward_metrics[2][3][6] D=n2129
+ CK=CTS_57 RB=FE_OFN409_i_reset_n_i
Xforward_metrics_reg[3][3][6] QDFFRBN $PINS Q=forward_metrics[3][3][6] D=n2177
+ CK=CTS_57 RB=FE_OFN350_i_reset_n_i
Xforward_metrics_reg[1][1][7] QDFFRBN $PINS Q=forward_metrics[1][1][7] D=n2056
+ CK=CTS_57 RB=FE_OFN275_i_reset_n_i
Xforward_metrics_reg[2][1][7] QDFFRBN $PINS Q=forward_metrics[2][1][7] D=n2104
+ CK=CTS_57 RB=FE_OFN275_i_reset_n_i
Xforward_metrics_reg[3][1][7] QDFFRBN $PINS Q=forward_metrics[3][1][7] D=n2152
+ CK=CTS_57 RB=FE_OFN451_i_reset_n_i
Xforward_metrics_reg[4][1][7] QDFFRBN $PINS Q=forward_metrics[4][1][7] D=n2200
+ CK=clk_i_clone10 RB=FE_OFN274_i_reset_n_i
Xforward_metrics_reg[1][0][9] QDFFRBN $PINS Q=forward_metrics[1][0][9] D=n2042
+ CK=CTS_62 RB=FE_OFN384_i_reset_n_i
Xforward_metrics_reg[2][0][9] QDFFRBN $PINS Q=forward_metrics[2][0][9] D=n2090
+ CK=CTS_61 RB=FE_OFN384_i_reset_n_i
Xforward_metrics_reg[3][0][9] QDFFRBN $PINS Q=forward_metrics[3][0][9] D=n2138
+ CK=CTS_62 RB=FE_OFN266_i_reset_n_i
Xforward_metrics_reg[4][0][9] QDFFRBN $PINS Q=forward_metrics[4][0][9] D=n2186
+ CK=CTS_62 RB=FE_OFN384_i_reset_n_i
Xforward_metrics_reg[5][0][9] QDFFRBN $PINS Q=forward_metrics[5][0][9] D=n2234
+ CK=CTS_62 RB=FE_OFN383_i_reset_n_i
Xforward_metrics_reg[1][0][8] QDFFRBN $PINS Q=forward_metrics[1][0][8] D=n2043
+ CK=clk_i_clone1 RB=FE_OFN333_i_reset_n_i
Xforward_metrics_reg[2][0][8] QDFFRBN $PINS Q=forward_metrics[2][0][8] D=n2091
+ CK=CTS_62 RB=FE_OFN456_i_reset_n_i
Xforward_metrics_reg[3][0][8] QDFFRBN $PINS Q=forward_metrics[3][0][8] D=n2139
+ CK=CTS_62 RB=FE_OFN394_i_reset_n_i
Xforward_metrics_reg[4][0][8] QDFFRBN $PINS Q=forward_metrics[4][0][8] D=n2187
+ CK=clk_i_clone1 RB=FE_OFN333_i_reset_n_i
Xforward_metrics_reg[1][2][7] QDFFRBN $PINS Q=forward_metrics[1][2][7] D=n2068
+ CK=CTS_62 RB=FE_OFN332_i_reset_n_i
Xforward_metrics_reg[2][2][7] QDFFRBN $PINS Q=forward_metrics[2][2][7] D=n2116
+ CK=CTS_57 RB=FE_OFN332_i_reset_n_i
Xforward_metrics_reg[3][2][7] QDFFRBN $PINS Q=forward_metrics[3][2][7] D=n2164
+ CK=CTS_57 RB=FE_OFN451_i_reset_n_i
Xforward_metrics_reg[4][2][7] QDFFRBN $PINS Q=forward_metrics[4][2][7] D=n2212
+ CK=CTS_57 RB=FE_OFN391_i_reset_n_i
Xforward_metrics_reg[1][1][6] QDFFRBN $PINS Q=forward_metrics[1][1][6] D=n2057
+ CK=clk_i_clone10 RB=FE_OFN188_i_reset_n_i
Xforward_metrics_reg[2][1][6] QDFFRBN $PINS Q=forward_metrics[2][1][6] D=n2105
+ CK=CTS_57 RB=FE_OFN228_i_reset_n_i
Xforward_metrics_reg[3][1][6] QDFFRBN $PINS Q=forward_metrics[3][1][6] D=n2153
+ CK=CTS_57 RB=FE_OFN295_i_reset_n_i
Xforward_metrics_reg[1][2][6] QDFFRBN $PINS Q=forward_metrics[1][2][6] D=n2069
+ CK=CTS_57 RB=FE_OFN295_i_reset_n_i
Xforward_metrics_reg[2][2][6] QDFFRBN $PINS Q=forward_metrics[2][2][6] D=n2117
+ CK=CTS_57 RB=FE_OFN228_i_reset_n_i
Xforward_metrics_reg[3][2][6] QDFFRBN $PINS Q=forward_metrics[3][2][6] D=n2165
+ CK=CTS_57 RB=FE_OFN295_i_reset_n_i
Xforward_metrics_reg[1][3][5] QDFFRBN $PINS Q=forward_metrics[1][3][5] D=n2082
+ CK=CTS_55 RB=FE_OFN352_i_reset_n_i
Xforward_metrics_reg[2][3][5] QDFFRBN $PINS Q=forward_metrics[2][3][5] D=n2130
+ CK=CTS_55 RB=FE_OFN412_i_reset_n_i
Xforward_metrics_reg[1][3][4] QDFFRBN $PINS Q=forward_metrics[1][3][4] D=n2083
+ CK=CTS_56 RB=FE_OFN337_i_reset_n_i
Xforward_metrics_reg[2][3][4] QDFFRBN $PINS Q=forward_metrics[2][3][4] D=n2131
+ CK=CTS_53 RB=FE_OFN395_i_reset_n_i
Xforward_metrics_reg[2][1][5] QDFFRBN $PINS Q=forward_metrics[2][1][5] D=n2106
+ CK=CTS_55 RB=FE_OFN296_i_reset_n_i
Xforward_metrics_reg[3][1][5] QDFFRBN $PINS Q=forward_metrics[3][1][5] D=n2154
+ CK=CTS_55 RB=FE_OFN296_i_reset_n_i
Xforward_metrics_reg[1][0][7] QDFFRBN $PINS Q=forward_metrics[1][0][7] D=n2044
+ CK=clk_i_clone10 RB=FE_OFN224_i_reset_n_i
Xforward_metrics_reg[2][0][7] QDFFRBN $PINS Q=forward_metrics[2][0][7] D=n2092
+ CK=clk_i_clone10 RB=FE_OFN224_i_reset_n_i
Xforward_metrics_reg[3][0][7] QDFFRBN $PINS Q=forward_metrics[3][0][7] D=n2140
+ CK=CTS_57 RB=FE_OFN451_i_reset_n_i
Xforward_metrics_reg[4][0][7] QDFFRBN $PINS Q=forward_metrics[4][0][7] D=n2188
+ CK=clk_i_clone10 RB=FE_OFN331_i_reset_n_i
Xforward_metrics_reg[1][0][6] QDFFRBN $PINS Q=forward_metrics[1][0][6] D=n2045
+ CK=CTS_57 RB=FE_OFN188_i_reset_n_i
Xforward_metrics_reg[2][0][6] QDFFRBN $PINS Q=forward_metrics[2][0][6] D=n2093
+ CK=clk_i_clone10 RB=FE_OFN187_i_reset_n_i
Xforward_metrics_reg[3][0][6] QDFFRBN $PINS Q=forward_metrics[3][0][6] D=n2141
+ CK=CTS_57 RB=FE_OFN201_i_reset_n_i
Xforward_metrics_reg[1][2][5] QDFFRBN $PINS Q=forward_metrics[1][2][5] D=n2070
+ CK=CTS_57 RB=FE_OFN243_i_reset_n_i
Xforward_metrics_reg[2][2][5] QDFFRBN $PINS Q=forward_metrics[2][2][5] D=n2118
+ CK=CTS_55 RB=FE_OFN352_i_reset_n_i
Xforward_metrics_reg[3][2][5] QDFFRBN $PINS Q=forward_metrics[3][2][5] D=n2166
+ CK=CTS_55 RB=FE_OFN412_i_reset_n_i
Xforward_metrics_reg[1][2][4] QDFFRBN $PINS Q=forward_metrics[1][2][4] D=n2071
+ CK=CTS_56 RB=FE_OFN51_i_reset_n_i
Xforward_metrics_reg[1][0][5] QDFFRBN $PINS Q=forward_metrics[1][0][5] D=n2046
+ CK=CTS_57 RB=FE_OFN243_i_reset_n_i
Xforward_metrics_reg[2][0][5] QDFFRBN $PINS Q=forward_metrics[2][0][5] D=n2094
+ CK=CTS_57 RB=FE_OFN242_i_reset_n_i
Xforward_metrics_reg[6][0][3] QDFFRBN $PINS Q=forward_metrics[6][0][3] D=n2288
+ CK=CTS_53 RB=FE_OFN192_i_reset_n_i
Xforward_metrics_reg[6][2][3] QDFFRBN $PINS Q=forward_metrics[6][2][3] D=n2312
+ CK=CTS_53 RB=FE_OFN233_i_reset_n_i
Xforward_metrics_reg[6][0][4] QDFFRBN $PINS Q=forward_metrics[6][0][4] D=n2287
+ CK=CTS_55 RB=FE_OFN483_i_reset_n_i
Xforward_metrics_reg[4][0][5] QDFFRBN $PINS Q=forward_metrics[4][0][5] D=n2190
+ CK=CTS_57 RB=FE_OFN243_i_reset_n_i
Xforward_metrics_reg[5][0][5] QDFFRBN $PINS Q=forward_metrics[5][0][5] D=n2238
+ CK=CTS_57 RB=FE_OFN242_i_reset_n_i
Xforward_metrics_reg[6][0][5] QDFFRBN $PINS Q=forward_metrics[6][0][5] D=n2286
+ CK=CTS_57 RB=FE_OFN161_i_reset_n_i
Xforward_metrics_reg[6][1][3] QDFFRBN $PINS Q=forward_metrics[6][1][3] D=n2300
+ CK=CTS_52 RB=FE_OFN232_i_reset_n_i
Xforward_metrics_reg[6][3][3] QDFFRBN $PINS Q=forward_metrics[6][3][3] D=n2324
+ CK=CTS_53 RB=FE_OFN232_i_reset_n_i
Xforward_metrics_reg[6][2][4] QDFFRBN $PINS Q=forward_metrics[6][2][4] D=n2311
+ CK=CTS_53 RB=FE_OFN458_i_reset_n_i
Xforward_metrics_reg[6][1][4] QDFFRBN $PINS Q=forward_metrics[6][1][4] D=n2299
+ CK=CTS_55 RB=FE_OFN483_i_reset_n_i
Xforward_metrics_reg[4][2][5] QDFFRBN $PINS Q=forward_metrics[4][2][5] D=n2214
+ CK=CTS_55 RB=FE_OFN296_i_reset_n_i
Xforward_metrics_reg[5][2][5] QDFFRBN $PINS Q=forward_metrics[5][2][5] D=n2262
+ CK=CTS_57 RB=FE_OFN351_i_reset_n_i
Xforward_metrics_reg[6][2][5] QDFFRBN $PINS Q=forward_metrics[6][2][5] D=n2310
+ CK=CTS_55 RB=FE_OFN296_i_reset_n_i
Xforward_metrics_reg[4][0][6] QDFFRBN $PINS Q=forward_metrics[4][0][6] D=n2189
+ CK=CTS_57 RB=FE_OFN188_i_reset_n_i
Xforward_metrics_reg[5][0][6] QDFFRBN $PINS Q=forward_metrics[5][0][6] D=n2237
+ CK=CTS_57 RB=FE_OFN201_i_reset_n_i
Xforward_metrics_reg[6][0][6] QDFFRBN $PINS Q=forward_metrics[6][0][6] D=n2285
+ CK=CTS_57 RB=FE_OFN228_i_reset_n_i
Xforward_metrics_reg[5][0][7] QDFFRBN $PINS Q=forward_metrics[5][0][7] D=n2236
+ CK=CTS_57 RB=FE_OFN391_i_reset_n_i
Xforward_metrics_reg[6][0][7] QDFFRBN $PINS Q=forward_metrics[6][0][7] D=n2284
+ CK=CTS_57 RB=FE_OFN450_i_reset_n_i
Xforward_metrics_reg[5][1][5] QDFFRBN $PINS Q=forward_metrics[5][1][5] D=n2250
+ CK=CTS_57 RB=FE_OFN243_i_reset_n_i
Xforward_metrics_reg[6][1][5] QDFFRBN $PINS Q=forward_metrics[6][1][5] D=n2298
+ CK=CTS_57 RB=FE_OFN351_i_reset_n_i
Xforward_metrics_reg[6][3][4] QDFFRBN $PINS Q=forward_metrics[6][3][4] D=n2323
+ CK=CTS_53 RB=FE_OFN395_i_reset_n_i
Xforward_metrics_reg[4][3][5] QDFFRBN $PINS Q=forward_metrics[4][3][5] D=n2226
+ CK=CTS_55 RB=FE_OFN352_i_reset_n_i
Xforward_metrics_reg[5][3][5] QDFFRBN $PINS Q=forward_metrics[5][3][5] D=n2274
+ CK=CTS_55 RB=FE_OFN412_i_reset_n_i
Xforward_metrics_reg[6][3][5] QDFFRBN $PINS Q=forward_metrics[6][3][5] D=n2322
+ CK=CTS_55 RB=FE_OFN412_i_reset_n_i
Xforward_metrics_reg[4][2][6] QDFFRBN $PINS Q=forward_metrics[4][2][6] D=n2213
+ CK=CTS_57 RB=FE_OFN409_i_reset_n_i
Xforward_metrics_reg[5][2][6] QDFFRBN $PINS Q=forward_metrics[5][2][6] D=n2261
+ CK=CTS_57 RB=FE_OFN295_i_reset_n_i
Xforward_metrics_reg[6][2][6] QDFFRBN $PINS Q=forward_metrics[6][2][6] D=n2309
+ CK=CTS_57 RB=FE_OFN350_i_reset_n_i
Xforward_metrics_reg[4][1][6] QDFFRBN $PINS Q=forward_metrics[4][1][6] D=n2201
+ CK=CTS_57 RB=FE_OFN228_i_reset_n_i
Xforward_metrics_reg[5][1][6] QDFFRBN $PINS Q=forward_metrics[5][1][6] D=n2249
+ CK=CTS_57 RB=FE_OFN228_i_reset_n_i
Xforward_metrics_reg[6][1][6] QDFFRBN $PINS Q=forward_metrics[6][1][6] D=n2297
+ CK=CTS_57 RB=FE_OFN295_i_reset_n_i
Xforward_metrics_reg[5][2][7] QDFFRBN $PINS Q=forward_metrics[5][2][7] D=n2260
+ CK=CTS_57 RB=FE_OFN392_i_reset_n_i
Xforward_metrics_reg[6][2][7] QDFFRBN $PINS Q=forward_metrics[6][2][7] D=n2308
+ CK=CTS_57 RB=FE_OFN451_i_reset_n_i
Xforward_metrics_reg[5][0][8] QDFFRBN $PINS Q=forward_metrics[5][0][8] D=n2235
+ CK=CTS_62 RB=FE_OFN334_i_reset_n_i
Xforward_metrics_reg[6][0][8] QDFFRBN $PINS Q=forward_metrics[6][0][8] D=n2283
+ CK=CTS_62 RB=FE_OFN456_i_reset_n_i
Xforward_metrics_reg[6][0][9] QDFFRBN $PINS Q=forward_metrics[6][0][9] D=n2282
+ CK=CTS_61 RB=FE_OFN444_i_reset_n_i
Xforward_metrics_reg[5][1][7] QDFFRBN $PINS Q=forward_metrics[5][1][7] D=n2248
+ CK=CTS_57 RB=FE_OFN391_i_reset_n_i
Xforward_metrics_reg[6][1][7] QDFFRBN $PINS Q=forward_metrics[6][1][7] D=n2296
+ CK=CTS_57 RB=FE_OFN450_i_reset_n_i
Xforward_metrics_reg[4][3][6] QDFFRBN $PINS Q=forward_metrics[4][3][6] D=n2225
+ CK=CTS_57 RB=FE_OFN409_i_reset_n_i
Xforward_metrics_reg[5][3][6] QDFFRBN $PINS Q=forward_metrics[5][3][6] D=n2273
+ CK=CTS_57 RB=FE_OFN409_i_reset_n_i
Xforward_metrics_reg[6][3][6] QDFFRBN $PINS Q=forward_metrics[6][3][6] D=n2321
+ CK=CTS_57 RB=FE_OFN350_i_reset_n_i
Xforward_metrics_reg[4][3][7] QDFFRBN $PINS Q=forward_metrics[4][3][7] D=n2224
+ CK=CTS_62 RB=FE_OFN332_i_reset_n_i
Xforward_metrics_reg[5][3][7] QDFFRBN $PINS Q=forward_metrics[5][3][7] D=n2272
+ CK=CTS_62 RB=FE_OFN452_i_reset_n_i
Xforward_metrics_reg[6][3][7] QDFFRBN $PINS Q=forward_metrics[6][3][7] D=n2320
+ CK=CTS_62 RB=FE_OFN392_i_reset_n_i
Xforward_metrics_reg[5][2][8] QDFFRBN $PINS Q=forward_metrics[5][2][8] D=n2259
+ CK=clk_i_clone1 RB=FE_OFN335_i_reset_n_i
Xforward_metrics_reg[6][2][8] QDFFRBN $PINS Q=forward_metrics[6][2][8] D=n2307
+ CK=CTS_62 RB=FE_OFN393_i_reset_n_i
Xforward_metrics_reg[5][1][8] QDFFRBN $PINS Q=forward_metrics[5][1][8] D=n2247
+ CK=CTS_62 RB=FE_OFN334_i_reset_n_i
Xforward_metrics_reg[6][1][8] QDFFRBN $PINS Q=forward_metrics[6][1][8] D=n2295
+ CK=CTS_62 RB=FE_OFN394_i_reset_n_i
Xforward_metrics_reg[6][1][9] QDFFRBN $PINS Q=forward_metrics[6][1][9] D=n2294
+ CK=CTS_61 RB=FE_OFN384_i_reset_n_i
Xforward_metrics_reg[5][3][8] QDFFRBN $PINS Q=forward_metrics[5][3][8] D=n2271
+ CK=CTS_62 RB=FE_OFN453_i_reset_n_i
Xforward_metrics_reg[6][3][8] QDFFRBN $PINS Q=forward_metrics[6][3][8] D=n2319
+ CK=CTS_62 RB=FE_OFN393_i_reset_n_i
Xforward_metrics_reg[5][3][9] QDFFRBN $PINS Q=forward_metrics[5][3][9] D=n2270
+ CK=CTS_61 RB=FE_OFN384_i_reset_n_i
Xbranch_metrics_reg[0][0][7] QDFFRBN $PINS Q=forward_sum[0][2][7] D=n2620
+ CK=clk_i_clone10 RB=FE_OFN49_i_reset_n_i
Xbranch_metrics_reg[0][0][6] QDFFRBN $PINS Q=forward_sum[0][2][6] D=n2621
+ CK=clk_i_clone12 RB=FE_OFN153_i_reset_n_i
Xbranch_metrics_reg[0][0][5] QDFFRBN $PINS Q=forward_sum[0][2][5] D=n2622
+ CK=clk_i_clone12 RB=FE_OFN73_i_reset_n_i
Xbranch_metrics_reg[0][0][4] QDFFRBN $PINS Q=forward_sum[0][2][4] D=n2623
+ CK=clk_i_clone13 RB=FE_OFN134_i_reset_n_i
Xbranch_metrics_reg[0][0][3] QDFFRBN $PINS Q=forward_sum[0][2][3] D=n2624
+ CK=CTS_56 RB=FE_OFN110_i_reset_n_i
Xbranch_metrics_reg[0][0][2] QDFFRBN $PINS Q=forward_sum[0][2][2] D=n2625
+ CK=clk_i_clone16 RB=FE_OFN54_i_reset_n_i
Xbranch_metrics_reg[0][1][7] QDFFRBN $PINS Q=forward_sum[0][6][7] D=n2632
+ CK=CTS_60 RB=FE_OFN5_i_reset_n_i
Xbranch_metrics_reg[0][1][6] QDFFRBN $PINS Q=forward_sum[0][6][6] D=n2633
+ CK=CTS_60 RB=FE_OFN5_i_reset_n_i
Xbranch_metrics_reg[0][1][5] QDFFRBN $PINS Q=forward_sum[0][6][5] D=n2634
+ CK=CTS_60 RB=FE_OFN19_i_reset_n_i
Xbranch_metrics_reg[0][1][4] QDFFRBN $PINS Q=forward_sum[0][6][4] D=n2635
+ CK=CTS_60 RB=FE_OFN38_i_reset_n_i
Xbranch_metrics_reg[0][1][3] QDFFRBN $PINS Q=forward_sum[0][6][3] D=n2636
+ CK=CTS_49 RB=FE_OFN80_i_reset_n_i
Xbranch_metrics_reg[0][1][2] QDFFRBN $PINS Q=forward_sum[0][6][2] D=n2637
+ CK=CTS_49 RB=FE_OFN37_i_reset_n_i
Xbranch_metrics_reg[0][1][1] QDFFRBN $PINS Q=forward_sum[0][6][1] D=n2638
+ CK=clk_i_clone23 RB=FE_OFN112_i_reset_n_i
Xbackward_metrics_reg[6][0][2] QDFFRBN $PINS Q=backward_metrics[6][0][2]
+ D=n2577 CK=clk_i_clone16 RB=FE_OFN294_i_reset_n_i
Xbackward_metrics_reg[6][0][3] QDFFRBN $PINS Q=backward_metrics[6][0][3]
+ D=n2576 CK=CTS_56 RB=FE_OFN459_i_reset_n_i
Xbackward_metrics_reg[6][2][1] QDFFRBN $PINS Q=backward_metrics[6][2][1]
+ D=n2602 CK=CTS_50 RB=FE_OFN407_i_reset_n_i
Xbackward_metrics_reg[6][2][2] QDFFRBN $PINS Q=backward_metrics[6][2][2]
+ D=n2601 CK=CTS_49 RB=FE_OFN470_i_reset_n_i
Xbackward_metrics_reg[6][0][4] QDFFRBN $PINS Q=backward_metrics[6][0][4]
+ D=n2575 CK=clk_i_clone13 RB=FE_OFN155_i_reset_n_i
Xbackward_metrics_reg[6][0][5] QDFFRBN $PINS Q=backward_metrics[6][0][5]
+ D=n2574 CK=clk_i_clone12 RB=FE_OFN73_i_reset_n_i
Xbackward_metrics_reg[6][2][3] QDFFRBN $PINS Q=backward_metrics[6][2][3]
+ D=n2600 CK=CTS_49 RB=FE_OFN467_i_reset_n_i
Xbackward_metrics_reg[6][2][4] QDFFRBN $PINS Q=backward_metrics[6][2][4]
+ D=n2599 CK=CTS_53 RB=FE_OFN461_i_reset_n_i
Xbackward_metrics_reg[6][0][6] QDFFRBN $PINS Q=backward_metrics[6][0][6]
+ D=n2573 CK=clk_i_clone12 RB=FE_OFN3_i_reset_n_i
Xbackward_metrics_reg[6][0][7] QDFFRBN $PINS Q=backward_metrics[6][0][7]
+ D=n2572 CK=clk_i_clone10 RB=FE_OFN49_i_reset_n_i
Xbackward_metrics_reg[6][2][5] QDFFRBN $PINS Q=backward_metrics[6][2][5]
+ D=n2598 CK=CTS_55 RB=FE_OFN202_i_reset_n_i
Xbackward_metrics_reg[6][2][6] QDFFRBN $PINS Q=backward_metrics[6][2][6]
+ D=n2597 CK=CTS_55 RB=FE_OFN415_i_reset_n_i
Xbackward_metrics_reg[6][2][7] QDFFRBN $PINS Q=backward_metrics[6][2][7]
+ D=n2596 CK=CTS_60 RB=FE_OFN298_i_reset_n_i
Xbranch_metrics_reg[1][0][11] QDFFRBN $PINS Q=branch_metrics[1][0][11] D=n2664
+ CK=clk_i RB=FE_OFN129_i_reset_n_i
Xbranch_metrics_reg[1][0][9] QDFFRBN $PINS Q=branch_metrics[1][0][9] D=n2666
+ CK=clk_i_clone1 RB=FE_OFN72_i_reset_n_i
Xbranch_metrics_reg[1][0][8] QDFFRBN $PINS Q=branch_metrics[1][0][8] D=n2667
+ CK=clk_i_clone1 RB=FE_OFN11_i_reset_n_i
Xbranch_metrics_reg[1][0][7] QDFFRBN $PINS Q=branch_metrics[1][0][7] D=n2668
+ CK=clk_i_clone10 RB=FE_OFN150_i_reset_n_i
Xbranch_metrics_reg[1][0][6] QDFFRBN $PINS Q=branch_metrics[1][0][6] D=n2669
+ CK=clk_i_clone12 RB=FE_OFN153_i_reset_n_i
Xbranch_metrics_reg[1][1][9] QDFFRBN $PINS Q=branch_metrics[1][1][9] D=n2678
+ CK=CTS_61 RB=FE_OFN381_i_reset_n_i
Xbranch_metrics_reg[1][1][8] QDFFRBN $PINS Q=branch_metrics[1][1][8] D=n2679
+ CK=CTS_60 RB=FE_OFN176_i_reset_n_i
Xbranch_metrics_reg[1][1][7] QDFFRBN $PINS Q=branch_metrics[1][1][7] D=n2680
+ CK=CTS_60 RB=FE_OFN298_i_reset_n_i
Xbranch_metrics_reg[1][1][6] QDFFRBN $PINS Q=branch_metrics[1][1][6] D=n2681
+ CK=CTS_55 RB=FE_OFN353_i_reset_n_i
Xbranch_metrics_reg[1][1][5] QDFFRBN $PINS Q=branch_metrics[1][1][5] D=n2682
+ CK=CTS_55 RB=FE_OFN138_i_reset_n_i
Xbranch_metrics_reg[1][2][9] QDFFRBN $PINS Q=branch_metrics[1][2][9] D=n2690
+ CK=clk_i_clone1 RB=FE_OFN72_i_reset_n_i
Xbranch_metrics_reg[1][2][8] QDFFRBN $PINS Q=branch_metrics[1][2][8] D=n2691
+ CK=clk_i_clone1 RB=FE_OFN11_i_reset_n_i
Xbranch_metrics_reg[1][2][7] QDFFRBN $PINS Q=branch_metrics[1][2][7] D=n2692
+ CK=clk_i_clone10 RB=FE_OFN183_i_reset_n_i
Xbranch_metrics_reg[1][2][6] QDFFRBN $PINS Q=branch_metrics[1][2][6] D=n2693
+ CK=clk_i_clone10 RB=FE_OFN2_i_reset_n_i
Xbranch_metrics_reg[1][3][9] QDFFRBN $PINS Q=branch_metrics[1][3][9] D=n2702
+ CK=CTS_61 RB=FE_OFN381_i_reset_n_i
Xbranch_metrics_reg[1][3][8] QDFFRBN $PINS Q=branch_metrics[1][3][8] D=n2703
+ CK=CTS_60 RB=FE_OFN176_i_reset_n_i
Xbranch_metrics_reg[1][3][7] QDFFRBN $PINS Q=branch_metrics[1][3][7] D=n2704
+ CK=CTS_60 RB=FE_OFN147_i_reset_n_i
Xbranch_metrics_reg[1][3][6] QDFFRBN $PINS Q=branch_metrics[1][3][6] D=n2705
+ CK=CTS_55 RB=FE_OFN298_i_reset_n_i
Xbranch_metrics_reg[2][0][9] QDFFRBN $PINS Q=branch_metrics[2][0][9] D=n2714
+ CK=clk_i_clone1 RB=FE_OFN336_i_reset_n_i
Xbranch_metrics_reg[2][0][8] QDFFRBN $PINS Q=branch_metrics[2][0][8] D=n2715
+ CK=clk_i_clone1 RB=FE_OFN333_i_reset_n_i
Xbranch_metrics_reg[2][0][7] QDFFRBN $PINS Q=branch_metrics[2][0][7] D=n2716
+ CK=clk_i_clone10 RB=FE_OFN184_i_reset_n_i
Xbranch_metrics_reg[2][0][6] QDFFRBN $PINS Q=branch_metrics[2][0][6] D=n2717
+ CK=clk_i_clone12 RB=FE_OFN230_i_reset_n_i
Xbranch_metrics_reg[2][1][9] QDFFRBN $PINS Q=branch_metrics[2][1][9] D=n2726
+ CK=CTS_61 RB=FE_OFN214_i_reset_n_i
Xbranch_metrics_reg[2][1][8] QDFFRBN $PINS Q=branch_metrics[2][1][8] D=n2727
+ CK=CTS_60 RB=FE_OFN147_i_reset_n_i
Xbranch_metrics_reg[2][1][7] QDFFRBN $PINS Q=branch_metrics[2][1][7] D=n2728
+ CK=CTS_60 RB=FE_OFN147_i_reset_n_i
Xbranch_metrics_reg[2][1][6] QDFFRBN $PINS Q=branch_metrics[2][1][6] D=n2729
+ CK=CTS_55 RB=FE_OFN353_i_reset_n_i
Xbranch_metrics_reg[2][1][5] QDFFRBN $PINS Q=branch_metrics[2][1][5] D=n2730
+ CK=CTS_55 RB=FE_OFN138_i_reset_n_i
Xbranch_metrics_reg[2][1][4] QDFFRBN $PINS Q=branch_metrics[2][1][4] D=n2731
+ CK=CTS_53 RB=FE_OFN192_i_reset_n_i
Xbranch_metrics_reg[2][2][9] QDFFRBN $PINS Q=branch_metrics[2][2][9] D=n2738
+ CK=clk_i_clone1 RB=FE_OFN226_i_reset_n_i
Xbranch_metrics_reg[2][2][8] QDFFRBN $PINS Q=branch_metrics[2][2][8] D=n2739
+ CK=clk_i_clone1 RB=FE_OFN279_i_reset_n_i
Xbranch_metrics_reg[2][2][7] QDFFRBN $PINS Q=branch_metrics[2][2][7] D=n2740
+ CK=clk_i_clone10 RB=FE_OFN184_i_reset_n_i
Xbranch_metrics_reg[2][2][6] QDFFRBN $PINS Q=branch_metrics[2][2][6] D=n2741
+ CK=clk_i_clone10 RB=FE_OFN12_i_reset_n_i
Xbranch_metrics_reg[2][3][9] QDFFRBN $PINS Q=branch_metrics[2][3][9] D=n2750
+ CK=CTS_61 RB=FE_OFN443_i_reset_n_i
Xbranch_metrics_reg[2][3][8] QDFFRBN $PINS Q=branch_metrics[2][3][8] D=n2751
+ CK=CTS_60 RB=FE_OFN214_i_reset_n_i
Xbranch_metrics_reg[2][3][7] QDFFRBN $PINS Q=branch_metrics[2][3][7] D=n2752
+ CK=CTS_60 RB=FE_OFN147_i_reset_n_i
Xbranch_metrics_reg[2][3][6] QDFFRBN $PINS Q=branch_metrics[2][3][6] D=n2753
+ CK=CTS_55 RB=FE_OFN353_i_reset_n_i
Xbranch_metrics_reg[3][0][11] QDFFRBN $PINS Q=branch_metrics[3][0][11] D=n2760
+ CK=CTS_58 RB=FE_OFN222_i_reset_n_i
Xbranch_metrics_reg[3][0][9] QDFFRBN $PINS Q=branch_metrics[3][0][9] D=n2762
+ CK=CTS_62 RB=FE_OFN453_i_reset_n_i
Xbranch_metrics_reg[3][0][8] QDFFRBN $PINS Q=branch_metrics[3][0][8] D=n2763
+ CK=CTS_62 RB=FE_OFN452_i_reset_n_i
Xbranch_metrics_reg[3][0][7] QDFFRBN $PINS Q=branch_metrics[3][0][7] D=n2764
+ CK=CTS_57 RB=FE_OFN409_i_reset_n_i
Xbranch_metrics_reg[3][0][6] QDFFRBN $PINS Q=branch_metrics[3][0][6] D=n2765
+ CK=CTS_57 RB=FE_OFN161_i_reset_n_i
Xbranch_metrics_reg[3][1][11] QDFFRBN $PINS Q=branch_metrics[3][1][11] D=n2772
+ CK=CTS_59 RB=FE_OFN178_i_reset_n_i
Xbranch_metrics_reg[3][1][10] QDFFRBN $PINS Q=branch_metrics[3][1][10] D=n2773
+ CK=CTS_61 RB=FE_OFN443_i_reset_n_i
Xbranch_metrics_reg[3][1][9] QDFFRBN $PINS Q=branch_metrics[3][1][9] D=n2774
+ CK=CTS_61 RB=FE_OFN382_i_reset_n_i
Xbranch_metrics_reg[3][1][8] QDFFRBN $PINS Q=branch_metrics[3][1][8] D=n2775
+ CK=CTS_62 RB=FE_OFN266_i_reset_n_i
Xbranch_metrics_reg[3][1][7] QDFFRBN $PINS Q=branch_metrics[3][1][7] D=n2776
+ CK=CTS_62 RB=FE_OFN455_i_reset_n_i
Xbranch_metrics_reg[3][1][6] QDFFRBN $PINS Q=branch_metrics[3][1][6] D=n2777
+ CK=CTS_57 RB=FE_OFN410_i_reset_n_i
Xbranch_metrics_reg[3][2][11] QDFFRBN $PINS Q=branch_metrics[3][2][11] D=n2784
+ CK=CTS_58 RB=FE_OFN149_i_reset_n_i
Xbranch_metrics_reg[3][2][10] QDFFRBN $PINS Q=branch_metrics[3][2][10] D=n2785
+ CK=CTS_61 RB=FE_OFN496_i_reset_n_i
Xbranch_metrics_reg[3][2][9] QDFFRBN $PINS Q=branch_metrics[3][2][9] D=n2786
+ CK=CTS_62 RB=FE_OFN321_i_reset_n_i
Xbranch_metrics_reg[3][2][8] QDFFRBN $PINS Q=branch_metrics[3][2][8] D=n2787
+ CK=CTS_62 RB=FE_OFN452_i_reset_n_i
Xbranch_metrics_reg[3][2][7] QDFFRBN $PINS Q=branch_metrics[3][2][7] D=n2788
+ CK=CTS_57 RB=FE_OFN450_i_reset_n_i
Xbranch_metrics_reg[3][2][6] QDFFRBN $PINS Q=branch_metrics[3][2][6] D=n2789
+ CK=clk_i_clone12 RB=FE_OFN281_i_reset_n_i
Xbranch_metrics_reg[3][3][11] QDFFRBN $PINS Q=branch_metrics[3][3][11] D=n2796
+ CK=CTS_61 RB=FE_OFN178_i_reset_n_i
Xbranch_metrics_reg[3][3][10] QDFFRBN $PINS Q=branch_metrics[3][3][10] D=n2797
+ CK=CTS_61 RB=FE_OFN443_i_reset_n_i
Xbranch_metrics_reg[3][3][9] QDFFRBN $PINS Q=branch_metrics[3][3][9] D=n2798
+ CK=CTS_61 RB=FE_OFN214_i_reset_n_i
Xbranch_metrics_reg[3][3][8] QDFFRBN $PINS Q=branch_metrics[3][3][8] D=n2799
+ CK=CTS_62 RB=FE_OFN217_i_reset_n_i
Xbranch_metrics_reg[3][3][7] QDFFRBN $PINS Q=branch_metrics[3][3][7] D=n2800
+ CK=CTS_62 RB=FE_OFN455_i_reset_n_i
Xbranch_metrics_reg[3][3][6] QDFFRBN $PINS Q=branch_metrics[3][3][6] D=n2801
+ CK=CTS_57 RB=FE_OFN410_i_reset_n_i
Xbranch_metrics_reg[4][0][10] QDFFRBN $PINS Q=branch_metrics[4][0][10] D=n2809
+ CK=clk_i RB=FE_OFN87_i_reset_n_i
Xbranch_metrics_reg[4][0][9] QDFFRBN $PINS Q=branch_metrics[4][0][9] D=n2810
+ CK=clk_i_clone1 RB=FE_OFN336_i_reset_n_i
Xbranch_metrics_reg[4][0][8] QDFFRBN $PINS Q=branch_metrics[4][0][8] D=n2811
+ CK=clk_i_clone1 RB=FE_OFN226_i_reset_n_i
Xbranch_metrics_reg[4][0][7] QDFFRBN $PINS Q=branch_metrics[4][0][7] D=n2812
+ CK=clk_i_clone10 RB=FE_OFN184_i_reset_n_i
Xbranch_metrics_reg[4][0][6] QDFFRBN $PINS Q=branch_metrics[4][0][6] D=n2813
+ CK=clk_i_clone10 RB=FE_OFN12_i_reset_n_i
Xbranch_metrics_reg[4][1][11] QDFFRBN $PINS Q=branch_metrics[4][1][11] D=n2820
+ CK=CTS_59 RB=FE_OFN498_i_reset_n_i
Xbranch_metrics_reg[4][1][10] QDFFRBN $PINS Q=branch_metrics[4][1][10] D=n2821
+ CK=CTS_59 RB=FE_OFN498_i_reset_n_i
Xbranch_metrics_reg[4][1][9] QDFFRBN $PINS Q=branch_metrics[4][1][9] D=n2822
+ CK=CTS_61 RB=FE_OFN497_i_reset_n_i
Xbranch_metrics_reg[4][1][8] QDFFRBN $PINS Q=branch_metrics[4][1][8] D=n2823
+ CK=CTS_62 RB=FE_OFN217_i_reset_n_i
Xbranch_metrics_reg[4][1][7] QDFFRBN $PINS Q=branch_metrics[4][1][7] D=n2824
+ CK=CTS_62 RB=FE_OFN455_i_reset_n_i
Xbranch_metrics_reg[4][1][6] QDFFRBN $PINS Q=branch_metrics[4][1][6] D=n2825
+ CK=CTS_57 RB=FE_OFN410_i_reset_n_i
Xbranch_metrics_reg[4][2][11] QDFFRBN $PINS Q=branch_metrics[4][2][11] D=n2832
+ CK=clk_i RB=FE_OFN129_i_reset_n_i
Xbranch_metrics_reg[4][2][10] QDFFRBN $PINS Q=branch_metrics[4][2][10] D=n2833
+ CK=clk_i RB=FE_OFN66_i_reset_n_i
Xbranch_metrics_reg[4][2][9] QDFFRBN $PINS Q=branch_metrics[4][2][9] D=n2834
+ CK=clk_i_clone1 RB=FE_OFN336_i_reset_n_i
Xbranch_metrics_reg[4][2][8] QDFFRBN $PINS Q=branch_metrics[4][2][8] D=n2835
+ CK=clk_i_clone1 RB=FE_OFN11_i_reset_n_i
Xbranch_metrics_reg[4][2][7] QDFFRBN $PINS Q=branch_metrics[4][2][7] D=n2836
+ CK=clk_i_clone10 RB=FE_OFN184_i_reset_n_i
Xbranch_metrics_reg[4][2][6] QDFFRBN $PINS Q=branch_metrics[4][2][6] D=n2837
+ CK=clk_i_clone10 RB=FE_OFN12_i_reset_n_i
Xbranch_metrics_reg[4][3][11] QDFFRBN $PINS Q=branch_metrics[4][3][11] D=n2844
+ CK=CTS_59 RB=FE_OFN481_i_reset_n_i
Xbranch_metrics_reg[4][3][10] QDFFRBN $PINS Q=branch_metrics[4][3][10] D=n2845
+ CK=CTS_59 RB=FE_OFN499_i_reset_n_i
Xbranch_metrics_reg[4][3][9] QDFFRBN $PINS Q=branch_metrics[4][3][9] D=n2846
+ CK=CTS_61 RB=FE_OFN497_i_reset_n_i
Xbranch_metrics_reg[4][3][8] QDFFRBN $PINS Q=branch_metrics[4][3][8] D=n2847
+ CK=CTS_62 RB=FE_OFN217_i_reset_n_i
Xbranch_metrics_reg[4][3][7] QDFFRBN $PINS Q=branch_metrics[4][3][7] D=n2848
+ CK=CTS_62 RB=FE_OFN455_i_reset_n_i
Xbranch_metrics_reg[4][3][6] QDFFRBN $PINS Q=branch_metrics[4][3][6] D=n2849
+ CK=CTS_57 RB=FE_OFN410_i_reset_n_i
Xbranch_metrics_reg[5][0][9] QDFFRBN $PINS Q=branch_metrics[5][0][9] D=n2858
+ CK=CTS_62 RB=FE_OFN383_i_reset_n_i
Xbranch_metrics_reg[5][0][8] QDFFRBN $PINS Q=branch_metrics[5][0][8] D=n2859
+ CK=clk_i_clone1 RB=FE_OFN333_i_reset_n_i
Xbranch_metrics_reg[5][0][7] QDFFRBN $PINS Q=branch_metrics[5][0][7] D=n2860
+ CK=clk_i_clone10 RB=FE_OFN331_i_reset_n_i
Xbranch_metrics_reg[5][0][6] QDFFRBN $PINS Q=branch_metrics[5][0][6] D=n2861
+ CK=clk_i_clone12 RB=FE_OFN230_i_reset_n_i
Xbranch_metrics_reg[5][0][5] QDFFRBN $PINS Q=branch_metrics[5][0][5] D=n2862
+ CK=clk_i_clone12 RB=FE_OFN230_i_reset_n_i
Xbranch_metrics_reg[5][1][9] QDFFRBN $PINS Q=branch_metrics[5][1][9] D=n2870
+ CK=CTS_61 RB=FE_OFN382_i_reset_n_i
Xbranch_metrics_reg[5][1][8] QDFFRBN $PINS Q=branch_metrics[5][1][8] D=n2871
+ CK=CTS_62 RB=FE_OFN321_i_reset_n_i
Xbranch_metrics_reg[5][1][7] QDFFRBN $PINS Q=branch_metrics[5][1][7] D=n2872
+ CK=CTS_62 RB=FE_OFN455_i_reset_n_i
Xbranch_metrics_reg[5][1][6] QDFFRBN $PINS Q=branch_metrics[5][1][6] D=n2873
+ CK=CTS_57 RB=FE_OFN410_i_reset_n_i
Xbranch_metrics_reg[5][1][5] QDFFRBN $PINS Q=branch_metrics[5][1][5] D=n2874
+ CK=CTS_55 RB=FE_OFN411_i_reset_n_i
Xbranch_metrics_reg[5][2][9] QDFFRBN $PINS Q=branch_metrics[5][2][9] D=n2882
+ CK=clk_i_clone1 RB=FE_OFN336_i_reset_n_i
Xbranch_metrics_reg[5][2][8] QDFFRBN $PINS Q=branch_metrics[5][2][8] D=n2883
+ CK=clk_i_clone1 RB=FE_OFN278_i_reset_n_i
Xbranch_metrics_reg[5][2][7] QDFFRBN $PINS Q=branch_metrics[5][2][7] D=n2884
+ CK=clk_i_clone10 RB=FE_OFN331_i_reset_n_i
Xbranch_metrics_reg[5][2][6] QDFFRBN $PINS Q=branch_metrics[5][2][6] D=n2885
+ CK=clk_i_clone10 RB=FE_OFN187_i_reset_n_i
Xbranch_metrics_reg[5][2][5] QDFFRBN $PINS Q=branch_metrics[5][2][5] D=n2886
+ CK=clk_i_clone12 RB=FE_OFN230_i_reset_n_i
Xbranch_metrics_reg[5][3][11] QDFFRBN $PINS Q=branch_metrics[5][3][11] D=n2892
+ CK=CTS_59 RB=FE_OFN499_i_reset_n_i
Xbranch_metrics_reg[5][3][10] QDFFRBN $PINS Q=branch_metrics[5][3][10] D=n2893
+ CK=CTS_59 RB=FE_OFN499_i_reset_n_i
Xbranch_metrics_reg[5][3][9] QDFFRBN $PINS Q=branch_metrics[5][3][9] D=n2894
+ CK=CTS_61 RB=FE_OFN497_i_reset_n_i
Xbranch_metrics_reg[5][3][8] QDFFRBN $PINS Q=branch_metrics[5][3][8] D=n2895
+ CK=CTS_62 RB=FE_OFN266_i_reset_n_i
Xbranch_metrics_reg[5][3][7] QDFFRBN $PINS Q=branch_metrics[5][3][7] D=n2896
+ CK=CTS_62 RB=FE_OFN456_i_reset_n_i
Xbranch_metrics_reg[5][3][6] QDFFRBN $PINS Q=branch_metrics[5][3][6] D=n2897
+ CK=CTS_57 RB=FE_OFN410_i_reset_n_i
Xbranch_metrics_reg[0][2][7] QDFFRBN $PINS Q=forward_sum[0][1][7] D=n2644
+ CK=clk_i_clone10 RB=FE_OFN150_i_reset_n_i
Xbranch_metrics_reg[0][2][6] QDFFRBN $PINS Q=forward_sum[0][1][6] D=n2645
+ CK=clk_i_clone10 RB=FE_OFN2_i_reset_n_i
Xbranch_metrics_reg[0][2][5] QDFFRBN $PINS Q=forward_sum[0][1][5] D=n2646
+ CK=clk_i_clone12 RB=FE_OFN32_i_reset_n_i
Xbranch_metrics_reg[0][2][4] QDFFRBN $PINS Q=forward_sum[0][1][4] D=n2647
+ CK=clk_i_clone13 RB=FE_OFN134_i_reset_n_i
Xbranch_metrics_reg[0][2][3] QDFFRBN $PINS Q=forward_sum[0][1][3] D=n2648
+ CK=CTS_56 RB=FE_OFN110_i_reset_n_i
Xbranch_metrics_reg[0][2][2] QDFFRBN $PINS Q=forward_sum[0][1][2] D=n2649
+ CK=clk_i_clone16 RB=FE_OFN294_i_reset_n_i
Xbranch_metrics_reg[0][3][7] QDFFRBN $PINS Q=forward_sum[0][5][7] D=n2656
+ CK=CTS_60 RB=FE_OFN5_i_reset_n_i
Xbranch_metrics_reg[0][3][6] QDFFRBN $PINS Q=forward_sum[0][5][6] D=n2657
+ CK=CTS_60 RB=FE_OFN5_i_reset_n_i
Xbranch_metrics_reg[0][3][5] QDFFRBN $PINS Q=forward_sum[0][5][5] D=n2658
+ CK=CTS_60 RB=FE_OFN19_i_reset_n_i
Xbranch_metrics_reg[0][3][4] QDFFRBN $PINS Q=forward_sum[0][5][4] D=n2659
+ CK=CTS_60 RB=FE_OFN19_i_reset_n_i
Xbranch_metrics_reg[0][3][3] QDFFRBN $PINS Q=forward_sum[0][5][3] D=n2660
+ CK=CTS_49 RB=FE_OFN80_i_reset_n_i
Xbackward_metrics_reg[2][3][8] QDFFRBN $PINS Q=backward_metrics[2][3][8]
+ D=n2415 CK=CTS_60 RB=FE_OFN176_i_reset_n_i
Xbackward_metrics_reg[3][3][8] QDFFRBN $PINS Q=backward_metrics[3][3][8]
+ D=n2463 CK=CTS_60 RB=FE_OFN214_i_reset_n_i
Xbackward_metrics_reg[1][3][7] QDFFRBN $PINS Q=backward_metrics[1][3][7]
+ D=n2368 CK=CTS_60 RB=FE_OFN297_i_reset_n_i
Xbackward_metrics_reg[2][3][7] QDFFRBN $PINS Q=backward_metrics[2][3][7]
+ D=n2416 CK=CTS_60 RB=FE_OFN146_i_reset_n_i
Xbackward_metrics_reg[3][3][7] QDFFRBN $PINS Q=backward_metrics[3][3][7]
+ D=n2464 CK=CTS_60 RB=FE_OFN245_i_reset_n_i
Xbackward_metrics_reg[4][3][7] QDFFRBN $PINS Q=backward_metrics[4][3][7]
+ D=n2512 CK=CTS_60 RB=FE_OFN146_i_reset_n_i
Xbackward_metrics_reg[1][2][8] QDFFRBN $PINS Q=backward_metrics[1][2][8]
+ D=n2355 CK=CTS_60 RB=FE_OFN217_i_reset_n_i
Xbackward_metrics_reg[2][2][8] QDFFRBN $PINS Q=backward_metrics[2][2][8]
+ D=n2403 CK=CTS_60 RB=FE_OFN177_i_reset_n_i
Xbackward_metrics_reg[3][2][8] QDFFRBN $PINS Q=backward_metrics[3][2][8]
+ D=n2451 CK=CTS_60 RB=FE_OFN177_i_reset_n_i
Xbackward_metrics_reg[2][1][8] QDFFRBN $PINS Q=backward_metrics[2][1][8]
+ D=n2391 CK=clk_i_clone1 RB=FE_OFN11_i_reset_n_i
Xbackward_metrics_reg[3][1][8] QDFFRBN $PINS Q=backward_metrics[3][1][8]
+ D=n2439 CK=clk_i_clone1 RB=FE_OFN275_i_reset_n_i
Xbackward_metrics_reg[1][3][6] QDFFRBN $PINS Q=backward_metrics[1][3][6]
+ D=n2369 CK=CTS_60 RB=FE_OFN245_i_reset_n_i
Xbackward_metrics_reg[2][3][6] QDFFRBN $PINS Q=backward_metrics[2][3][6]
+ D=n2417 CK=CTS_55 RB=FE_OFN202_i_reset_n_i
Xbackward_metrics_reg[3][3][6] QDFFRBN $PINS Q=backward_metrics[3][3][6]
+ D=n2465 CK=CTS_55 RB=FE_OFN202_i_reset_n_i
Xbackward_metrics_reg[1][3][5] QDFFRBN $PINS Q=backward_metrics[1][3][5]
+ D=n2370 CK=CTS_53 RB=FE_OFN463_i_reset_n_i
Xbackward_metrics_reg[2][3][5] QDFFRBN $PINS Q=backward_metrics[2][3][5]
+ D=n2418 CK=CTS_53 RB=FE_OFN463_i_reset_n_i
Xbackward_metrics_reg[3][3][5] QDFFRBN $PINS Q=backward_metrics[3][3][5]
+ D=n2466 CK=CTS_53 RB=FE_OFN244_i_reset_n_i
Xbackward_metrics_reg[1][2][7] QDFFRBN $PINS Q=backward_metrics[1][2][7]
+ D=n2356 CK=CTS_55 RB=FE_OFN414_i_reset_n_i
Xbackward_metrics_reg[2][2][7] QDFFRBN $PINS Q=backward_metrics[2][2][7]
+ D=n2404 CK=CTS_55 RB=FE_OFN414_i_reset_n_i
Xbackward_metrics_reg[3][2][7] QDFFRBN $PINS Q=backward_metrics[3][2][7]
+ D=n2452 CK=CTS_55 RB=FE_OFN414_i_reset_n_i
Xbackward_metrics_reg[4][2][7] QDFFRBN $PINS Q=backward_metrics[4][2][7]
+ D=n2500 CK=CTS_55 RB=FE_OFN298_i_reset_n_i
Xbackward_metrics_reg[2][0][8] QDFFRBN $PINS Q=backward_metrics[2][0][8]
+ D=n2379 CK=clk_i_clone10 RB=FE_OFN223_i_reset_n_i
Xbackward_metrics_reg[4][0][8] QDFFRBN $PINS Q=backward_metrics[4][0][8]
+ D=n2475 CK=clk_i_clone10 RB=FE_OFN184_i_reset_n_i
Xbackward_metrics_reg[1][1][7] QDFFRBN $PINS Q=backward_metrics[1][1][7]
+ D=n2344 CK=clk_i_clone10 RB=FE_OFN331_i_reset_n_i
Xbackward_metrics_reg[2][1][7] QDFFRBN $PINS Q=backward_metrics[2][1][7]
+ D=n2392 CK=clk_i_clone10 RB=FE_OFN150_i_reset_n_i
Xbackward_metrics_reg[3][1][7] QDFFRBN $PINS Q=backward_metrics[3][1][7]
+ D=n2440 CK=clk_i_clone10 RB=FE_OFN331_i_reset_n_i
Xbackward_metrics_reg[4][1][7] QDFFRBN $PINS Q=backward_metrics[4][1][7]
+ D=n2488 CK=clk_i_clone10 RB=FE_OFN49_i_reset_n_i
Xbackward_metrics_reg[1][2][6] QDFFRBN $PINS Q=backward_metrics[1][2][6]
+ D=n2357 CK=CTS_55 RB=FE_OFN415_i_reset_n_i
Xbackward_metrics_reg[2][2][6] QDFFRBN $PINS Q=backward_metrics[2][2][6]
+ D=n2405 CK=CTS_55 RB=FE_OFN415_i_reset_n_i
Xbackward_metrics_reg[3][2][6] QDFFRBN $PINS Q=backward_metrics[3][2][6]
+ D=n2453 CK=CTS_55 RB=FE_OFN415_i_reset_n_i
Xbackward_metrics_reg[1][1][6] QDFFRBN $PINS Q=backward_metrics[1][1][6]
+ D=n2345 CK=clk_i_clone10 RB=FE_OFN187_i_reset_n_i
Xbackward_metrics_reg[2][1][6] QDFFRBN $PINS Q=backward_metrics[2][1][6]
+ D=n2393 CK=clk_i_clone10 RB=FE_OFN2_i_reset_n_i
Xbackward_metrics_reg[3][1][6] QDFFRBN $PINS Q=backward_metrics[3][1][6]
+ D=n2441 CK=clk_i_clone10 RB=FE_OFN187_i_reset_n_i
Xbackward_metrics_reg[1][3][4] QDFFRBN $PINS Q=backward_metrics[1][3][4]
+ D=n2371 CK=CTS_53 RB=FE_OFN244_i_reset_n_i
Xbackward_metrics_reg[2][3][4] QDFFRBN $PINS Q=backward_metrics[2][3][4]
+ D=n2419 CK=CTS_53 RB=FE_OFN463_i_reset_n_i
Xbackward_metrics_reg[1][3][3] QDFFRBN $PINS Q=backward_metrics[1][3][3]
+ D=n2372 CK=CTS_49 RB=FE_OFN56_i_reset_n_i
Xbackward_metrics_reg[2][3][3] QDFFRBN $PINS Q=backward_metrics[2][3][3]
+ D=n2420 CK=CTS_53 RB=FE_OFN249_i_reset_n_i
Xbackward_metrics_reg[1][2][5] QDFFRBN $PINS Q=backward_metrics[1][2][5]
+ D=n2358 CK=CTS_55 RB=FE_OFN163_i_reset_n_i
Xbackward_metrics_reg[2][2][5] QDFFRBN $PINS Q=backward_metrics[2][2][5]
+ D=n2406 CK=CTS_55 RB=FE_OFN163_i_reset_n_i
Xbackward_metrics_reg[3][2][5] QDFFRBN $PINS Q=backward_metrics[3][2][5]
+ D=n2454 CK=CTS_55 RB=FE_OFN163_i_reset_n_i
Xbackward_metrics_reg[2][0][7] QDFFRBN $PINS Q=backward_metrics[2][0][7]
+ D=n2380 CK=clk_i_clone10 RB=FE_OFN31_i_reset_n_i
Xbackward_metrics_reg[3][0][7] QDFFRBN $PINS Q=backward_metrics[3][0][7]
+ D=n2428 CK=CTS_57 RB=FE_OFN228_i_reset_n_i
Xbackward_metrics_reg[4][0][7] QDFFRBN $PINS Q=backward_metrics[4][0][7]
+ D=n2476 CK=clk_i_clone10 RB=FE_OFN31_i_reset_n_i
Xbackward_metrics_reg[1][0][6] QDFFRBN $PINS Q=backward_metrics[1][0][6]
+ D=n2333 CK=clk_i_clone12 RB=FE_OFN190_i_reset_n_i
Xbackward_metrics_reg[2][0][6] QDFFRBN $PINS Q=backward_metrics[2][0][6]
+ D=n2381 CK=clk_i_clone12 RB=FE_OFN13_i_reset_n_i
Xbackward_metrics_reg[3][0][6] QDFFRBN $PINS Q=backward_metrics[3][0][6]
+ D=n2429 CK=clk_i_clone12 RB=FE_OFN230_i_reset_n_i
Xbackward_metrics_reg[1][1][5] QDFFRBN $PINS Q=backward_metrics[1][1][5]
+ D=n2346 CK=clk_i_clone12 RB=FE_OFN281_i_reset_n_i
Xbackward_metrics_reg[2][1][5] QDFFRBN $PINS Q=backward_metrics[2][1][5]
+ D=n2394 CK=clk_i_clone12 RB=FE_OFN50_i_reset_n_i
Xbackward_metrics_reg[3][1][5] QDFFRBN $PINS Q=backward_metrics[3][1][5]
+ D=n2442 CK=clk_i_clone12 RB=FE_OFN281_i_reset_n_i
Xbackward_metrics_reg[1][2][4] QDFFRBN $PINS Q=backward_metrics[1][2][4]
+ D=n2359 CK=CTS_53 RB=FE_OFN341_i_reset_n_i
Xbackward_metrics_reg[2][2][4] QDFFRBN $PINS Q=backward_metrics[2][2][4]
+ D=n2407 CK=CTS_53 RB=FE_OFN284_i_reset_n_i
Xbackward_metrics_reg[1][1][4] QDFFRBN $PINS Q=backward_metrics[1][1][4]
+ D=n2347 CK=clk_i_clone13 RB=FE_OFN14_i_reset_n_i
Xbackward_metrics_reg[2][1][4] QDFFRBN $PINS Q=backward_metrics[2][1][4]
+ D=n2395 CK=clk_i_clone13 RB=FE_OFN130_i_reset_n_i
Xbackward_metrics_reg[1][3][2] QDFFRBN $PINS Q=backward_metrics[1][3][2]
+ D=n2373 CK=CTS_49 RB=FE_OFN80_i_reset_n_i
Xbackward_metrics_reg[1][3][1] QDFFRBN $PINS Q=backward_metrics[1][3][1]
+ D=n2374 CK=clk_i_clone21 RB=FE_OFN116_i_reset_n_i
Xbackward_metrics_reg[1][2][3] QDFFRBN $PINS Q=backward_metrics[1][2][3]
+ D=n2360 CK=CTS_53 RB=FE_OFN462_i_reset_n_i
Xbackward_metrics_reg[2][2][3] QDFFRBN $PINS Q=backward_metrics[2][2][3]
+ D=n2408 CK=CTS_53 RB=FE_OFN400_i_reset_n_i
Xbackward_metrics_reg[1][0][5] QDFFRBN $PINS Q=backward_metrics[1][0][5]
+ D=n2334 CK=clk_i_clone12 RB=FE_OFN190_i_reset_n_i
Xbackward_metrics_reg[2][0][5] QDFFRBN $PINS Q=backward_metrics[2][0][5]
+ D=n2382 CK=clk_i_clone12 RB=FE_OFN73_i_reset_n_i
Xbackward_metrics_reg[3][0][5] QDFFRBN $PINS Q=backward_metrics[3][0][5]
+ D=n2430 CK=clk_i_clone12 RB=FE_OFN190_i_reset_n_i
Xbackward_metrics_reg[1][0][4] QDFFRBN $PINS Q=backward_metrics[1][0][4]
+ D=n2335 CK=clk_i_clone13 RB=FE_OFN14_i_reset_n_i
Xbackward_metrics_reg[2][0][4] QDFFRBN $PINS Q=backward_metrics[2][0][4]
+ D=n2383 CK=clk_i_clone13 RB=FE_OFN50_i_reset_n_i
Xbackward_metrics_reg[1][1][3] QDFFRBN $PINS Q=backward_metrics[1][1][3]
+ D=n2348 CK=CTS_52 RB=FE_OFN396_i_reset_n_i
Xbackward_metrics_reg[2][1][3] QDFFRBN $PINS Q=backward_metrics[2][1][3]
+ D=n2396 CK=CTS_56 RB=FE_OFN459_i_reset_n_i
Xbackward_metrics_reg[1][2][2] QDFFRBN $PINS Q=backward_metrics[1][2][2]
+ D=n2361 CK=CTS_49 RB=FE_OFN467_i_reset_n_i
Xbackward_metrics_reg[1][1][2] QDFFRBN $PINS Q=backward_metrics[1][1][2]
+ D=n2349 CK=clk_i_clone16 RB=FE_OFN239_i_reset_n_i
Xbackward_metrics_reg[1][2][1] QDFFRBN $PINS Q=backward_metrics[1][2][1]
+ D=n2362 CK=CTS_50 RB=FE_OFN349_i_reset_n_i
Xbackward_metrics_reg[1][0][3] QDFFRBN $PINS Q=backward_metrics[1][0][3]
+ D=n2336 CK=CTS_56 RB=FE_OFN74_i_reset_n_i
Xbackward_metrics_reg[2][0][3] QDFFRBN $PINS Q=backward_metrics[2][0][3]
+ D=n2384 CK=CTS_56 RB=FE_OFN459_i_reset_n_i
Xbackward_metrics_reg[1][0][2] QDFFRBN $PINS Q=backward_metrics[1][0][2]
+ D=n2337 CK=CTS_52 RB=FE_OFN239_i_reset_n_i
Xbackward_metrics_reg[1][0][1] QDFFRBN $PINS Q=backward_metrics[1][0][1]
+ D=n2338 CK=clk_i_clone16 RB=FE_OFN199_i_reset_n_i
Xbackward_metrics_reg[2][0][1] QDFFRBN $PINS Q=backward_metrics[2][0][1]
+ D=n2386 CK=clk_i_clone16 RB=FE_OFN52_i_reset_n_i
Xbackward_metrics_reg[3][0][1] QDFFRBN $PINS Q=backward_metrics[3][0][1]
+ D=n2434 CK=clk_i_clone16 RB=FE_OFN35_i_reset_n_i
Xbackward_metrics_reg[4][0][1] QDFFRBN $PINS Q=backward_metrics[4][0][1]
+ D=n2482 CK=clk_i_clone16 RB=FE_OFN77_i_reset_n_i
Xbackward_metrics_reg[5][0][1] QDFFRBN $PINS Q=backward_metrics[5][0][1]
+ D=n2530 CK=clk_i_clone16 RB=FE_OFN34_i_reset_n_i
Xbackward_metrics_reg[1][1][1] QDFFRBN $PINS Q=backward_metrics[1][1][1]
+ D=n2350 CK=clk_i_clone16 RB=FE_OFN199_i_reset_n_i
Xbackward_metrics_reg[2][1][1] QDFFRBN $PINS Q=backward_metrics[2][1][1]
+ D=n2398 CK=clk_i_clone16 RB=FE_OFN52_i_reset_n_i
Xbackward_metrics_reg[4][1][1] QDFFRBN $PINS Q=backward_metrics[4][1][1]
+ D=n2494 CK=clk_i_clone16 RB=FE_OFN53_i_reset_n_i
Xbackward_metrics_reg[5][1][1] QDFFRBN $PINS Q=backward_metrics[5][1][1]
+ D=n2542 CK=clk_i_clone16 RB=FE_OFN52_i_reset_n_i
Xbackward_metrics_reg[2][0][2] QDFFRBN $PINS Q=backward_metrics[2][0][2]
+ D=n2385 CK=clk_i_clone16 RB=FE_OFN294_i_reset_n_i
Xbackward_metrics_reg[3][0][2] QDFFRBN $PINS Q=backward_metrics[3][0][2]
+ D=n2433 CK=CTS_52 RB=FE_OFN239_i_reset_n_i
Xbackward_metrics_reg[4][0][2] QDFFRBN $PINS Q=backward_metrics[4][0][2]
+ D=n2481 CK=clk_i_clone16 RB=FE_OFN294_i_reset_n_i
Xbackward_metrics_reg[5][0][2] QDFFRBN $PINS Q=backward_metrics[5][0][2]
+ D=n2529 CK=clk_i_clone16 RB=FE_OFN294_i_reset_n_i
Xbackward_metrics_reg[3][0][3] QDFFRBN $PINS Q=backward_metrics[3][0][3]
+ D=n2432 CK=CTS_56 RB=FE_OFN74_i_reset_n_i
Xbackward_metrics_reg[4][0][3] QDFFRBN $PINS Q=backward_metrics[4][0][3]
+ D=n2480 CK=CTS_56 RB=FE_OFN110_i_reset_n_i
Xbackward_metrics_reg[5][0][3] QDFFRBN $PINS Q=backward_metrics[5][0][3]
+ D=n2528 CK=CTS_56 RB=FE_OFN459_i_reset_n_i
Xbackward_metrics_reg[2][2][1] QDFFRBN $PINS Q=backward_metrics[2][2][1]
+ D=n2410 CK=CTS_50 RB=FE_OFN406_i_reset_n_i
Xbackward_metrics_reg[4][2][1] QDFFRBN $PINS Q=backward_metrics[4][2][1]
+ D=n2506 CK=CTS_50 RB=FE_OFN406_i_reset_n_i
Xbackward_metrics_reg[5][2][1] QDFFRBN $PINS Q=backward_metrics[5][2][1]
+ D=n2554 CK=CTS_50 RB=FE_OFN406_i_reset_n_i
Xbackward_metrics_reg[2][1][2] QDFFRBN $PINS Q=backward_metrics[2][1][2]
+ D=n2397 CK=clk_i_clone16 RB=FE_OFN294_i_reset_n_i
Xbackward_metrics_reg[3][1][2] QDFFRBN $PINS Q=backward_metrics[3][1][2]
+ D=n2445 CK=CTS_52 RB=FE_OFN239_i_reset_n_i
Xbackward_metrics_reg[4][1][2] QDFFRBN $PINS Q=backward_metrics[4][1][2]
+ D=n2493 CK=clk_i_clone16 RB=FE_OFN54_i_reset_n_i
Xbackward_metrics_reg[5][1][2] QDFFRBN $PINS Q=backward_metrics[5][1][2]
+ D=n2541 CK=clk_i_clone16 RB=FE_OFN54_i_reset_n_i
Xbackward_metrics_reg[6][1][2] QDFFRBN $PINS Q=backward_metrics[6][1][2]
+ D=n2589 CK=clk_i_clone16 RB=FE_OFN54_i_reset_n_i
Xbackward_metrics_reg[2][2][2] QDFFRBN $PINS Q=backward_metrics[2][2][2]
+ D=n2409 CK=CTS_49 RB=FE_OFN404_i_reset_n_i
Xbackward_metrics_reg[3][2][2] QDFFRBN $PINS Q=backward_metrics[3][2][2]
+ D=n2457 CK=CTS_49 RB=FE_OFN404_i_reset_n_i
Xbackward_metrics_reg[4][2][2] QDFFRBN $PINS Q=backward_metrics[4][2][2]
+ D=n2505 CK=CTS_49 RB=FE_OFN470_i_reset_n_i
Xbackward_metrics_reg[5][2][2] QDFFRBN $PINS Q=backward_metrics[5][2][2]
+ D=n2553 CK=CTS_49 RB=FE_OFN470_i_reset_n_i
Xbackward_metrics_reg[3][1][3] QDFFRBN $PINS Q=backward_metrics[3][1][3]
+ D=n2444 CK=CTS_56 RB=FE_OFN74_i_reset_n_i
Xbackward_metrics_reg[4][1][3] QDFFRBN $PINS Q=backward_metrics[4][1][3]
+ D=n2492 CK=CTS_56 RB=FE_OFN484_i_reset_n_i
Xbackward_metrics_reg[5][1][3] QDFFRBN $PINS Q=backward_metrics[5][1][3]
+ D=n2540 CK=CTS_56 RB=FE_OFN110_i_reset_n_i
Xbackward_metrics_reg[6][1][3] QDFFRBN $PINS Q=backward_metrics[6][1][3]
+ D=n2588 CK=clk_i_clone13 RB=FE_OFN130_i_reset_n_i
Xbackward_metrics_reg[3][0][4] QDFFRBN $PINS Q=backward_metrics[3][0][4]
+ D=n2431 CK=clk_i_clone13 RB=FE_OFN14_i_reset_n_i
Xbackward_metrics_reg[4][0][4] QDFFRBN $PINS Q=backward_metrics[4][0][4]
+ D=n2479 CK=clk_i_clone13 RB=FE_OFN50_i_reset_n_i
Xbackward_metrics_reg[5][0][4] QDFFRBN $PINS Q=backward_metrics[5][0][4]
+ D=n2527 CK=clk_i_clone13 RB=FE_OFN50_i_reset_n_i
Xbackward_metrics_reg[4][0][5] QDFFRBN $PINS Q=backward_metrics[4][0][5]
+ D=n2478 CK=clk_i_clone12 RB=FE_OFN32_i_reset_n_i
Xbackward_metrics_reg[5][0][5] QDFFRBN $PINS Q=backward_metrics[5][0][5]
+ D=n2526 CK=clk_i_clone12 RB=FE_OFN32_i_reset_n_i
Xbackward_metrics_reg[3][2][3] QDFFRBN $PINS Q=backward_metrics[3][2][3]
+ D=n2456 CK=CTS_49 RB=FE_OFN467_i_reset_n_i
Xbackward_metrics_reg[4][2][3] QDFFRBN $PINS Q=backward_metrics[4][2][3]
+ D=n2504 CK=CTS_53 RB=FE_OFN400_i_reset_n_i
Xbackward_metrics_reg[5][2][3] QDFFRBN $PINS Q=backward_metrics[5][2][3]
+ D=n2552 CK=CTS_53 RB=FE_OFN462_i_reset_n_i
Xbackward_metrics_reg[2][3][1] QDFFRBN $PINS Q=backward_metrics[2][3][1]
+ D=n2422 CK=CTS_50 RB=FE_OFN94_i_reset_n_i
Xbackward_metrics_reg[4][3][1] QDFFRBN $PINS Q=backward_metrics[4][3][1]
+ D=n2518 CK=CTS_50 RB=FE_OFN17_i_reset_n_i
Xbackward_metrics_reg[5][3][1] QDFFRBN $PINS Q=backward_metrics[5][3][1]
+ D=n2566 CK=clk_i_clone23 RB=FE_OFN94_i_reset_n_i
Xbackward_metrics_reg[2][3][2] QDFFRBN $PINS Q=backward_metrics[2][3][2]
+ D=n2421 CK=CTS_49 RB=FE_OFN304_i_reset_n_i
Xbackward_metrics_reg[3][3][2] QDFFRBN $PINS Q=backward_metrics[3][3][2]
+ D=n2469 CK=CTS_49 RB=FE_OFN56_i_reset_n_i
Xbackward_metrics_reg[4][3][2] QDFFRBN $PINS Q=backward_metrics[4][3][2]
+ D=n2517 CK=CTS_49 RB=FE_OFN18_i_reset_n_i
Xbackward_metrics_reg[5][3][2] QDFFRBN $PINS Q=backward_metrics[5][3][2]
+ D=n2565 CK=CTS_49 RB=FE_OFN18_i_reset_n_i
Xbackward_metrics_reg[6][3][2] QDFFRBN $PINS Q=backward_metrics[6][3][2]
+ D=n2613 CK=CTS_49 RB=FE_OFN37_i_reset_n_i
Xbackward_metrics_reg[3][1][4] QDFFRBN $PINS Q=backward_metrics[3][1][4]
+ D=n2443 CK=clk_i_clone13 RB=FE_OFN14_i_reset_n_i
Xbackward_metrics_reg[4][1][4] QDFFRBN $PINS Q=backward_metrics[4][1][4]
+ D=n2491 CK=clk_i_clone13 RB=FE_OFN155_i_reset_n_i
Xbackward_metrics_reg[5][1][4] QDFFRBN $PINS Q=backward_metrics[5][1][4]
+ D=n2539 CK=clk_i_clone13 RB=FE_OFN134_i_reset_n_i
Xbackward_metrics_reg[6][1][4] QDFFRBN $PINS Q=backward_metrics[6][1][4]
+ D=n2587 CK=clk_i_clone13 RB=FE_OFN134_i_reset_n_i
Xbackward_metrics_reg[3][2][4] QDFFRBN $PINS Q=backward_metrics[3][2][4]
+ D=n2455 CK=CTS_53 RB=FE_OFN341_i_reset_n_i
Xbackward_metrics_reg[4][2][4] QDFFRBN $PINS Q=backward_metrics[4][2][4]
+ D=n2503 CK=CTS_53 RB=FE_OFN461_i_reset_n_i
Xbackward_metrics_reg[5][2][4] QDFFRBN $PINS Q=backward_metrics[5][2][4]
+ D=n2551 CK=CTS_53 RB=FE_OFN461_i_reset_n_i
Xbackward_metrics_reg[4][1][5] QDFFRBN $PINS Q=backward_metrics[4][1][5]
+ D=n2490 CK=clk_i_clone12 RB=FE_OFN32_i_reset_n_i
Xbackward_metrics_reg[5][1][5] QDFFRBN $PINS Q=backward_metrics[5][1][5]
+ D=n2538 CK=clk_i_clone12 RB=FE_OFN50_i_reset_n_i
Xbackward_metrics_reg[6][1][5] QDFFRBN $PINS Q=backward_metrics[6][1][5]
+ D=n2586 CK=clk_i_clone12 RB=FE_OFN73_i_reset_n_i
Xbackward_metrics_reg[4][0][6] QDFFRBN $PINS Q=backward_metrics[4][0][6]
+ D=n2477 CK=clk_i_clone12 RB=FE_OFN3_i_reset_n_i
Xbackward_metrics_reg[5][0][6] QDFFRBN $PINS Q=backward_metrics[5][0][6]
+ D=n2525 CK=clk_i_clone12 RB=FE_OFN3_i_reset_n_i
Xbackward_metrics_reg[5][0][7] QDFFRBN $PINS Q=backward_metrics[5][0][7]
+ D=n2524 CK=clk_i_clone10 RB=FE_OFN31_i_reset_n_i
Xbackward_metrics_reg[4][2][5] QDFFRBN $PINS Q=backward_metrics[4][2][5]
+ D=n2502 CK=CTS_55 RB=FE_OFN163_i_reset_n_i
Xbackward_metrics_reg[5][2][5] QDFFRBN $PINS Q=backward_metrics[5][2][5]
+ D=n2550 CK=CTS_55 RB=FE_OFN202_i_reset_n_i
Xbackward_metrics_reg[3][3][3] QDFFRBN $PINS Q=backward_metrics[3][3][3]
+ D=n2468 CK=CTS_49 RB=FE_OFN56_i_reset_n_i
Xbackward_metrics_reg[4][3][3] QDFFRBN $PINS Q=backward_metrics[4][3][3]
+ D=n2516 CK=CTS_53 RB=FE_OFN38_i_reset_n_i
Xbackward_metrics_reg[5][3][3] QDFFRBN $PINS Q=backward_metrics[5][3][3]
+ D=n2564 CK=CTS_53 RB=FE_OFN249_i_reset_n_i
Xbackward_metrics_reg[6][3][3] QDFFRBN $PINS Q=backward_metrics[6][3][3]
+ D=n2612 CK=CTS_49 RB=FE_OFN38_i_reset_n_i
Xbackward_metrics_reg[3][3][4] QDFFRBN $PINS Q=backward_metrics[3][3][4]
+ D=n2467 CK=CTS_53 RB=FE_OFN244_i_reset_n_i
Xbackward_metrics_reg[4][3][4] QDFFRBN $PINS Q=backward_metrics[4][3][4]
+ D=n2515 CK=CTS_60 RB=FE_OFN38_i_reset_n_i
Xbackward_metrics_reg[5][3][4] QDFFRBN $PINS Q=backward_metrics[5][3][4]
+ D=n2563 CK=CTS_53 RB=FE_OFN249_i_reset_n_i
Xbackward_metrics_reg[6][3][4] QDFFRBN $PINS Q=backward_metrics[6][3][4]
+ D=n2611 CK=CTS_53 RB=FE_OFN249_i_reset_n_i
Xbackward_metrics_reg[4][1][6] QDFFRBN $PINS Q=backward_metrics[4][1][6]
+ D=n2489 CK=clk_i_clone12 RB=FE_OFN153_i_reset_n_i
Xbackward_metrics_reg[5][1][6] QDFFRBN $PINS Q=backward_metrics[5][1][6]
+ D=n2537 CK=clk_i_clone10 RB=FE_OFN2_i_reset_n_i
Xbackward_metrics_reg[6][1][6] QDFFRBN $PINS Q=backward_metrics[6][1][6]
+ D=n2585 CK=clk_i_clone12 RB=FE_OFN153_i_reset_n_i
Xbackward_metrics_reg[4][2][6] QDFFRBN $PINS Q=backward_metrics[4][2][6]
+ D=n2501 CK=CTS_55 RB=FE_OFN415_i_reset_n_i
Xbackward_metrics_reg[5][2][6] QDFFRBN $PINS Q=backward_metrics[5][2][6]
+ D=n2549 CK=CTS_55 RB=FE_OFN415_i_reset_n_i
Xbackward_metrics_reg[5][1][7] QDFFRBN $PINS Q=backward_metrics[5][1][7]
+ D=n2536 CK=clk_i_clone10 RB=FE_OFN49_i_reset_n_i
Xbackward_metrics_reg[6][1][7] QDFFRBN $PINS Q=backward_metrics[6][1][7]
+ D=n2584 CK=clk_i_clone10 RB=FE_OFN49_i_reset_n_i
Xbackward_metrics_reg[5][0][8] QDFFRBN $PINS Q=backward_metrics[5][0][8]
+ D=n2523 CK=clk_i_clone10 RB=FE_OFN223_i_reset_n_i
Xbackward_metrics_reg[5][2][7] QDFFRBN $PINS Q=backward_metrics[5][2][7]
+ D=n2548 CK=CTS_55 RB=FE_OFN298_i_reset_n_i
Xbackward_metrics_reg[4][3][5] QDFFRBN $PINS Q=backward_metrics[4][3][5]
+ D=n2514 CK=CTS_60 RB=FE_OFN19_i_reset_n_i
Xbackward_metrics_reg[5][3][5] QDFFRBN $PINS Q=backward_metrics[5][3][5]
+ D=n2562 CK=CTS_53 RB=FE_OFN249_i_reset_n_i
Xbackward_metrics_reg[6][3][5] QDFFRBN $PINS Q=backward_metrics[6][3][5]
+ D=n2610 CK=CTS_60 RB=FE_OFN19_i_reset_n_i
Xbackward_metrics_reg[4][3][6] QDFFRBN $PINS Q=backward_metrics[4][3][6]
+ D=n2513 CK=CTS_60 RB=FE_OFN245_i_reset_n_i
Xbackward_metrics_reg[5][3][6] QDFFRBN $PINS Q=backward_metrics[5][3][6]
+ D=n2561 CK=CTS_60 RB=FE_OFN245_i_reset_n_i
Xbackward_metrics_reg[6][3][6] QDFFRBN $PINS Q=backward_metrics[6][3][6]
+ D=n2609 CK=CTS_60 RB=FE_OFN297_i_reset_n_i
Xbackward_metrics_reg[5][3][7] QDFFRBN $PINS Q=backward_metrics[5][3][7]
+ D=n2560 CK=CTS_60 RB=FE_OFN146_i_reset_n_i
Xbackward_metrics_reg[6][3][7] QDFFRBN $PINS Q=backward_metrics[6][3][7]
+ D=n2608 CK=CTS_60 RB=FE_OFN146_i_reset_n_i
Xbackward_metrics_reg[4][1][0] QDFFRBN $PINS Q=backward_metrics[4][1][0]
+ D=n2495 CK=clk_i_clone16 RB=FE_OFN15_i_reset_n_i
Xbackward_metrics_reg[3][0][0] QDFFRBN $PINS Q=backward_metrics[3][0][0]
+ D=n2435 CK=clk_i_clone16 RB=FE_OFN53_i_reset_n_i
Xbranch_metrics_reg[6][0][2] QDFFRBN $PINS Q=backward_sum[0][4][2] D=n2913
+ CK=clk_i_clone16 RB=FE_OFN199_i_reset_n_i
Xbranch_metrics_reg[6][0][1] QDFFRBN $PINS Q=backward_sum[0][4][1] D=n2914
+ CK=clk_i_clone17 RB=FE_OFN487_i_reset_n_i
Xbranch_metrics_reg[6][1][2] QDFFRBN $PINS Q=backward_sum[0][1][2] D=n2925
+ CK=CTS_49 RB=FE_OFN404_i_reset_n_i
Xbranch_metrics_reg[6][1][1] QDFFRBN $PINS Q=backward_sum[0][1][1] D=n2926
+ CK=CTS_50 RB=FE_OFN237_i_reset_n_i
Xbranch_metrics_reg[6][2][2] QDFFRBN $PINS Q=backward_sum[0][6][2] D=n2937
+ CK=clk_i_clone16 RB=FE_OFN199_i_reset_n_i
Xbranch_metrics_reg[6][2][1] QDFFRBN $PINS Q=backward_sum[0][6][1] D=n2938
+ CK=clk_i_clone17 RB=FE_OFN466_i_reset_n_i
Xforward_metrics_reg[1][1][5] QDFFRBN $PINS Q=forward_metrics[1][1][5] D=n2058
+ CK=CTS_57 RB=FE_OFN201_i_reset_n_i
Xforward_metrics_reg[1][1][4] QDFFRBN $PINS Q=forward_metrics[1][1][4] D=n2059
+ CK=CTS_56 RB=FE_OFN51_i_reset_n_i
Xforward_metrics_reg[2][1][4] QDFFRBN $PINS Q=forward_metrics[2][1][4] D=n2107
+ CK=CTS_53 RB=FE_OFN482_i_reset_n_i
Xforward_metrics_reg[1][3][2] QDFFRBN $PINS Q=forward_metrics[1][3][2] D=n2085
+ CK=CTS_52 RB=FE_OFN289_i_reset_n_i
Xforward_metrics_reg[3][0][5] QDFFRBN $PINS Q=forward_metrics[3][0][5] D=n2142
+ CK=CTS_57 RB=FE_OFN242_i_reset_n_i
Xforward_metrics_reg[1][2][3] QDFFRBN $PINS Q=forward_metrics[1][2][3] D=n2072
+ CK=CTS_52 RB=FE_OFN340_i_reset_n_i
Xforward_metrics_reg[1][1][2] QDFFRBN $PINS Q=forward_metrics[1][1][2] D=n2061
+ CK=CTS_52 RB=FE_OFN345_i_reset_n_i
Xforward_metrics_reg[1][2][2] QDFFRBN $PINS Q=forward_metrics[1][2][2] D=n2073
+ CK=clk_i_clone17 RB=FE_OFN346_i_reset_n_i
Xforward_metrics_reg[4][0][1] QDFFRBN $PINS Q=forward_metrics[4][0][1] D=n2194
+ CK=clk_i_clone17 RB=FE_OFN401_i_reset_n_i
Xforward_metrics_reg[5][0][1] QDFFRBN $PINS Q=forward_metrics[5][0][1] D=n2242
+ CK=clk_i_clone17 RB=FE_OFN238_i_reset_n_i
Xforward_metrics_reg[6][0][1] QDFFRBN $PINS Q=forward_metrics[6][0][1] D=n2290
+ CK=clk_i_clone17 RB=FE_OFN198_i_reset_n_i
Xforward_metrics_reg[6][2][1] QDFFRBN $PINS Q=forward_metrics[6][2][1] D=n2314
+ CK=CTS_50 RB=FE_OFN238_i_reset_n_i
Xforward_metrics_reg[5][0][2] QDFFRBN $PINS Q=forward_metrics[5][0][2] D=n2241
+ CK=CTS_52 RB=FE_OFN196_i_reset_n_i
Xforward_metrics_reg[6][0][2] QDFFRBN $PINS Q=forward_metrics[6][0][2] D=n2289
+ CK=CTS_52 RB=FE_OFN345_i_reset_n_i
Xforward_metrics_reg[3][1][1] QDFFRBN $PINS Q=forward_metrics[3][1][1] D=n2158
+ CK=CTS_49 RB=FE_OFN405_i_reset_n_i
Xforward_metrics_reg[6][1][1] QDFFRBN $PINS Q=forward_metrics[6][1][1] D=n2302
+ CK=clk_i_clone17 RB=FE_OFN237_i_reset_n_i
Xforward_metrics_reg[6][3][1] QDFFRBN $PINS Q=forward_metrics[6][3][1] D=n2326
+ CK=CTS_50 RB=FE_OFN237_i_reset_n_i
Xforward_metrics_reg[6][2][2] QDFFRBN $PINS Q=forward_metrics[6][2][2] D=n2313
+ CK=CTS_49 RB=FE_OFN289_i_reset_n_i
Xforward_metrics_reg[2][1][2] QDFFRBN $PINS Q=forward_metrics[2][1][2] D=n2109
+ CK=CTS_52 RB=FE_OFN236_i_reset_n_i
Xforward_metrics_reg[6][1][2] QDFFRBN $PINS Q=forward_metrics[6][1][2] D=n2301
+ CK=CTS_52 RB=FE_OFN345_i_reset_n_i
Xforward_metrics_reg[3][0][4] QDFFRBN $PINS Q=forward_metrics[3][0][4] D=n2143
+ CK=CTS_55 RB=FE_OFN483_i_reset_n_i
Xforward_metrics_reg[5][0][4] QDFFRBN $PINS Q=forward_metrics[5][0][4] D=n2239
+ CK=CTS_55 RB=FE_OFN483_i_reset_n_i
Xforward_metrics_reg[2][3][2] QDFFRBN $PINS Q=forward_metrics[2][3][2] D=n2133
+ CK=CTS_52 RB=FE_OFN288_i_reset_n_i
Xforward_metrics_reg[6][3][2] QDFFRBN $PINS Q=forward_metrics[6][3][2] D=n2325
+ CK=CTS_52 RB=FE_OFN289_i_reset_n_i
Xforward_metrics_reg[5][1][4] QDFFRBN $PINS Q=forward_metrics[5][1][4] D=n2251
+ CK=CTS_55 RB=FE_OFN483_i_reset_n_i
Xforward_metrics_reg[4][1][5] QDFFRBN $PINS Q=forward_metrics[4][1][5] D=n2202
+ CK=CTS_57 RB=FE_OFN201_i_reset_n_i
Xforward_metrics_reg[3][3][5] QDFFRBN $PINS Q=forward_metrics[3][3][5] D=n2178
+ CK=CTS_55 RB=FE_OFN412_i_reset_n_i
Xforward_metrics_reg[6][0][0] QDFFRBN $PINS Q=forward_metrics[6][0][0] D=n2291
+ CK=CTS_50 RB=FE_OFN197_i_reset_n_i
Xforward_metrics_reg[6][1][0] QDFFRBN $PINS Q=forward_metrics[6][1][0] D=n2303
+ CK=CTS_50 RB=FE_OFN237_i_reset_n_i
Xbackward_metrics_reg[6][0][1] QDFFRBN $PINS Q=backward_metrics[6][0][1]
+ D=n2578 CK=clk_i_clone16 RB=FE_OFN77_i_reset_n_i
Xbranch_metrics_reg[1][2][5] QDFFRBN $PINS Q=branch_metrics[1][2][5] D=n2694
+ CK=clk_i_clone12 RB=FE_OFN13_i_reset_n_i
Xbranch_metrics_reg[2][2][5] QDFFRBN $PINS Q=branch_metrics[2][2][5] D=n2742
+ CK=clk_i_clone12 RB=FE_OFN190_i_reset_n_i
Xbranch_metrics_reg[2][2][4] QDFFRBN $PINS Q=branch_metrics[2][2][4] D=n2743
+ CK=CTS_56 RB=FE_OFN484_i_reset_n_i
Xbranch_metrics_reg[3][1][5] QDFFRBN $PINS Q=branch_metrics[3][1][5] D=n2778
+ CK=CTS_55 RB=FE_OFN412_i_reset_n_i
Xbranch_metrics_reg[3][2][5] QDFFRBN $PINS Q=branch_metrics[3][2][5] D=n2790
+ CK=clk_i_clone12 RB=FE_OFN281_i_reset_n_i
Xbranch_metrics_reg[4][1][5] QDFFRBN $PINS Q=branch_metrics[4][1][5] D=n2826
+ CK=CTS_55 RB=FE_OFN411_i_reset_n_i
Xbranch_metrics_reg[4][2][5] QDFFRBN $PINS Q=branch_metrics[4][2][5] D=n2838
+ CK=clk_i_clone12 RB=FE_OFN32_i_reset_n_i
Xbranch_metrics_reg[0][1][0] QDFFRBN $PINS Q=forward_sum[0][6][0] D=n2639
+ CK=clk_i_clone23 RB=FE_OFN36_i_reset_n_i
Xbackward_metrics_reg[3][1][1] QDFFRBN $PINS Q=backward_metrics[3][1][1]
+ D=n2446 CK=clk_i_clone16 RB=FE_OFN53_i_reset_n_i
Xbackward_metrics_reg[3][2][1] QDFFRBN $PINS Q=backward_metrics[3][2][1]
+ D=n2458 CK=CTS_50 RB=FE_OFN349_i_reset_n_i
Xbackward_metrics_reg[3][2][0] QDFFRBN $PINS Q=backward_metrics[3][2][0]
+ D=n2459 CK=CTS_50 RB=FE_OFN349_i_reset_n_i
Xbranch_metrics_reg[3][1][0] QDFFRBN $PINS Q=branch_metrics[3][1][0] D=n2783
+ CK=CTS_50 RB=FE_OFN469_i_reset_n_i
Xforward_metrics_reg[2][0][4] QDFFRBN $PINS Q=forward_metrics[2][0][4] D=n2095
+ CK=CTS_53 RB=FE_OFN458_i_reset_n_i
Xforward_metrics_reg[2][1][3] QDFFRBN $PINS Q=forward_metrics[2][1][3] D=n2108
+ CK=CTS_52 RB=FE_OFN339_i_reset_n_i
Xforward_metrics_reg[1][1][3] QDFFRBN $PINS Q=forward_metrics[1][1][3] D=n2060
+ CK=CTS_52 RB=FE_OFN398_i_reset_n_i
Xforward_metrics_reg[3][0][3] QDFFRBN $PINS Q=forward_metrics[3][0][3] D=n2144
+ CK=CTS_52 RB=FE_OFN283_i_reset_n_i
Xforward_metrics_reg[3][1][4] QDFFRBN $PINS Q=forward_metrics[3][1][4] D=n2155
+ CK=CTS_55 RB=FE_OFN483_i_reset_n_i
Xforward_metrics_reg[5][0][3] QDFFRBN $PINS Q=forward_metrics[5][0][3] D=n2240
+ CK=CTS_52 RB=FE_OFN192_i_reset_n_i
Xforward_metrics_reg[4][0][4] QDFFRBN $PINS Q=forward_metrics[4][0][4] D=n2191
+ CK=CTS_56 RB=FE_OFN51_i_reset_n_i
Xforward_metrics_reg[4][1][4] QDFFRBN $PINS Q=forward_metrics[4][1][4] D=n2203
+ CK=CTS_56 RB=FE_OFN51_i_reset_n_i
Xforward_metrics_reg[1][0][4] QDFFRBN $PINS Q=forward_metrics[1][0][4] D=n2047
+ CK=CTS_56 RB=FE_OFN51_i_reset_n_i
Xbranch_metrics_reg[6][1][0] QDFFRBN $PINS Q=backward_sum[0][1][0] D=n2927
+ CK=CTS_50 RB=FE_OFN291_i_reset_n_i
Xbranch_metrics_reg[6][2][0] QDFFRBN $PINS Q=backward_sum[0][6][0] D=n2939
+ CK=clk_i_clone17 RB=FE_OFN466_i_reset_n_i
Xbranch_metrics_reg[6][3][1] QDFFRBN $PINS Q=backward_sum[0][3][1] D=n2950
+ CK=CTS_50 RB=FE_OFN290_i_reset_n_i
Xbranch_metrics_reg[0][0][1] QDFFRBN $PINS Q=forward_sum[0][2][1] D=n2626
+ CK=clk_i_clone16 RB=FE_OFN77_i_reset_n_i
Xbackward_metrics_reg[6][2][0] QDFFRBN $PINS Q=backward_metrics[6][2][0]
+ D=n2603 CK=CTS_50 RB=FE_OFN349_i_reset_n_i
Xbackward_metrics_reg[6][1][1] QDFFRBN $PINS Q=backward_metrics[6][1][1]
+ D=n2590 CK=clk_i_clone16 RB=FE_OFN77_i_reset_n_i
Xbranch_metrics_reg[1][1][2] QDFFRBN $PINS Q=branch_metrics[1][1][2] D=n2685
+ CK=CTS_49 RB=FE_OFN18_i_reset_n_i
Xbranch_metrics_reg[1][1][1] QDFFRBN $PINS Q=branch_metrics[1][1][1] D=n2686
+ CK=CTS_50 RB=FE_OFN94_i_reset_n_i
Xbranch_metrics_reg[1][2][4] QDFFRBN $PINS Q=branch_metrics[1][2][4] D=n2695
+ CK=CTS_56 RB=FE_OFN130_i_reset_n_i
Xbranch_metrics_reg[1][2][2] QDFFRBN $PINS Q=branch_metrics[1][2][2] D=n2697
+ CK=CTS_52 RB=FE_OFN35_i_reset_n_i
Xbranch_metrics_reg[1][2][1] QDFFRBN $PINS Q=branch_metrics[1][2][1] D=n2698
+ CK=clk_i_clone17 RB=FE_OFN343_i_reset_n_i
Xbranch_metrics_reg[1][3][5] QDFFRBN $PINS Q=branch_metrics[1][3][5] D=n2706
+ CK=CTS_55 RB=FE_OFN138_i_reset_n_i
Xbranch_metrics_reg[2][1][2] QDFFRBN $PINS Q=branch_metrics[2][1][2] D=n2733
+ CK=CTS_49 RB=FE_OFN470_i_reset_n_i
Xbranch_metrics_reg[2][1][1] QDFFRBN $PINS Q=branch_metrics[2][1][1] D=n2734
+ CK=CTS_50 RB=FE_OFN407_i_reset_n_i
Xbranch_metrics_reg[2][2][2] QDFFRBN $PINS Q=branch_metrics[2][2][2] D=n2745
+ CK=clk_i_clone16 RB=FE_OFN16_i_reset_n_i
Xbranch_metrics_reg[2][2][1] QDFFRBN $PINS Q=branch_metrics[2][2][1] D=n2746
+ CK=clk_i_clone17 RB=FE_OFN486_i_reset_n_i
Xbranch_metrics_reg[2][3][5] QDFFRBN $PINS Q=branch_metrics[2][3][5] D=n2754
+ CK=CTS_55 RB=FE_OFN163_i_reset_n_i
Xbranch_metrics_reg[3][1][1] QDFFRBN $PINS Q=branch_metrics[3][1][1] D=n2782
+ CK=CTS_49 RB=FE_OFN470_i_reset_n_i
Xbranch_metrics_reg[3][2][3] QDFFRBN $PINS Q=branch_metrics[3][2][3] D=n2792
+ CK=CTS_56 RB=FE_OFN337_i_reset_n_i
Xbranch_metrics_reg[3][2][2] QDFFRBN $PINS Q=branch_metrics[3][2][2] D=n2793
+ CK=CTS_52 RB=FE_OFN236_i_reset_n_i
Xbranch_metrics_reg[3][2][1] QDFFRBN $PINS Q=branch_metrics[3][2][1] D=n2794
+ CK=clk_i_clone17 RB=FE_OFN405_i_reset_n_i
Xbranch_metrics_reg[4][1][2] QDFFRBN $PINS Q=branch_metrics[4][1][2] D=n2829
+ CK=CTS_49 RB=FE_OFN288_i_reset_n_i
Xbranch_metrics_reg[4][1][1] QDFFRBN $PINS Q=branch_metrics[4][1][1] D=n2830
+ CK=CTS_50 RB=FE_OFN347_i_reset_n_i
Xbranch_metrics_reg[4][2][2] QDFFRBN $PINS Q=branch_metrics[4][2][2] D=n2841
+ CK=CTS_52 RB=FE_OFN16_i_reset_n_i
Xbranch_metrics_reg[4][2][1] QDFFRBN $PINS Q=branch_metrics[4][2][1] D=n2842
+ CK=clk_i_clone17 RB=FE_OFN465_i_reset_n_i
Xbranch_metrics_reg[5][1][2] QDFFRBN $PINS Q=branch_metrics[5][1][2] D=n2877
+ CK=CTS_49 RB=FE_OFN467_i_reset_n_i
Xbranch_metrics_reg[5][1][1] QDFFRBN $PINS Q=branch_metrics[5][1][1] D=n2878
+ CK=CTS_50 RB=FE_OFN468_i_reset_n_i
Xbranch_metrics_reg[5][2][4] QDFFRBN $PINS Q=branch_metrics[5][2][4] D=n2887
+ CK=clk_i_clone13 RB=FE_OFN33_i_reset_n_i
Xbranch_metrics_reg[5][2][3] QDFFRBN $PINS Q=branch_metrics[5][2][3] D=n2888
+ CK=CTS_52 RB=FE_OFN337_i_reset_n_i
Xbranch_metrics_reg[5][2][2] QDFFRBN $PINS Q=branch_metrics[5][2][2] D=n2889
+ CK=CTS_52 RB=FE_OFN239_i_reset_n_i
Xbranch_metrics_reg[5][2][1] QDFFRBN $PINS Q=branch_metrics[5][2][1] D=n2890
+ CK=clk_i_clone17 RB=FE_OFN405_i_reset_n_i
Xbranch_metrics_reg[5][3][5] QDFFRBN $PINS Q=branch_metrics[5][3][5] D=n2898
+ CK=CTS_55 RB=FE_OFN411_i_reset_n_i
Xbranch_metrics_reg[1][0][5] QDFFRBN $PINS Q=branch_metrics[1][0][5] D=n2670
+ CK=clk_i_clone12 RB=FE_OFN13_i_reset_n_i
Xbranch_metrics_reg[2][0][5] QDFFRBN $PINS Q=branch_metrics[2][0][5] D=n2718
+ CK=clk_i_clone12 RB=FE_OFN190_i_reset_n_i
Xbranch_metrics_reg[2][1][3] QDFFRBN $PINS Q=branch_metrics[2][1][3] D=n2732
+ CK=CTS_53 RB=FE_OFN342_i_reset_n_i
Xbranch_metrics_reg[3][1][4] QDFFRBN $PINS Q=branch_metrics[3][1][4] D=n2779
+ CK=CTS_53 RB=FE_OFN157_i_reset_n_i
Xbranch_metrics_reg[5][1][4] QDFFRBN $PINS Q=branch_metrics[5][1][4] D=n2875
+ CK=CTS_53 RB=FE_OFN233_i_reset_n_i
Xbranch_metrics_reg[1][1][3] QDFFRBN $PINS Q=branch_metrics[1][1][3] D=n2684
+ CK=CTS_53 RB=FE_OFN400_i_reset_n_i
Xbranch_metrics_reg[4][1][3] QDFFRBN $PINS Q=branch_metrics[4][1][3] D=n2828
+ CK=CTS_53 RB=FE_OFN399_i_reset_n_i
Xbranch_metrics_reg[3][1][2] QDFFRBN $PINS Q=branch_metrics[3][1][2] D=n2781
+ CK=CTS_49 RB=FE_OFN304_i_reset_n_i
Xbranch_metrics_reg[4][0][5] QDFFRBN $PINS Q=branch_metrics[4][0][5] D=n2814
+ CK=clk_i_clone12 RB=FE_OFN13_i_reset_n_i
Xbranch_metrics_reg[4][2][3] QDFFRBN $PINS Q=branch_metrics[4][2][3] D=n2840
+ CK=CTS_52 RB=FE_OFN396_i_reset_n_i
Xbranch_metrics_reg[2][2][3] QDFFRBN $PINS Q=branch_metrics[2][2][3] D=n2744
+ CK=CTS_56 RB=FE_OFN91_i_reset_n_i
Xbranch_metrics_reg[1][2][3] QDFFRBN $PINS Q=branch_metrics[1][2][3] D=n2696
+ CK=CTS_56 RB=FE_OFN91_i_reset_n_i
Xbranch_metrics_reg[3][1][3] QDFFRBN $PINS Q=branch_metrics[3][1][3] D=n2780
+ CK=CTS_49 RB=FE_OFN467_i_reset_n_i
Xbranch_metrics_reg[3][2][4] QDFFRBN $PINS Q=branch_metrics[3][2][4] D=n2791
+ CK=clk_i_clone13 RB=FE_OFN33_i_reset_n_i
Xbranch_metrics_reg[5][1][3] QDFFRBN $PINS Q=branch_metrics[5][1][3] D=n2876
+ CK=CTS_53 RB=FE_OFN399_i_reset_n_i
Xbranch_metrics_reg[4][1][4] QDFFRBN $PINS Q=branch_metrics[4][1][4] D=n2827
+ CK=CTS_53 RB=FE_OFN233_i_reset_n_i
Xbranch_metrics_reg[4][2][4] QDFFRBN $PINS Q=branch_metrics[4][2][4] D=n2839
+ CK=CTS_56 RB=FE_OFN484_i_reset_n_i
Xbranch_metrics_reg[1][0][4] QDFFRBN $PINS Q=branch_metrics[1][0][4] D=n2671
+ CK=clk_i_clone13 RB=FE_OFN130_i_reset_n_i
Xbranch_metrics_reg[1][1][4] QDFFRBN $PINS Q=branch_metrics[1][1][4] D=n2683
+ CK=CTS_53 RB=FE_OFN284_i_reset_n_i
Xbackward_metrics_reg[3][3][1] QDFFRBN $PINS Q=backward_metrics[3][3][1]
+ D=n2470 CK=clk_i_clone21 RB=FE_OFN116_i_reset_n_i
Xbranch_metrics_reg[0][2][1] QDFFRBN $PINS Q=forward_sum[0][1][1] D=n2650
+ CK=clk_i_clone16 RB=FE_OFN53_i_reset_n_i
Xbranch_metrics_reg[0][3][1] QDFFRBN $PINS Q=forward_sum[0][5][1] D=n2662
+ CK=clk_i_clone23 RB=FE_OFN112_i_reset_n_i
Xbranch_metrics_reg[0][3][2] QDFFRBN $PINS Q=forward_sum[0][5][2] D=n2661
+ CK=CTS_49 RB=FE_OFN37_i_reset_n_i
Xbranch_metrics_reg[4][1][0] QDFFRBN $PINS Q=branch_metrics[4][1][0] D=n2831
+ CK=CTS_50 RB=FE_OFN347_i_reset_n_i
Xbackward_metrics_reg[2][1][0] QDFFRBN $PINS Q=backward_metrics[2][1][0]
+ D=n2399 CK=clk_i_clone16 RB=FE_OFN76_i_reset_n_i
Xbackward_metrics_reg[2][0][0] QDFFRBN $PINS Q=backward_metrics[2][0][0]
+ D=n2387 CK=clk_i_clone16 RB=FE_OFN75_i_reset_n_i
Xbackward_metrics_reg[2][3][0] QDFFRBN $PINS Q=backward_metrics[2][3][0]
+ D=n2423 CK=CTS_50 RB=FE_OFN94_i_reset_n_i
Xbackward_metrics_reg[2][2][0] QDFFRBN $PINS Q=backward_metrics[2][2][0]
+ D=n2411 CK=CTS_50 RB=FE_OFN406_i_reset_n_i
Xbackward_metrics_reg[1][2][0] QDFFRBN $PINS Q=backward_metrics[1][2][0]
+ D=n2363 CK=CTS_50 RB=FE_OFN349_i_reset_n_i
Xbackward_metrics_reg[1][0][0] QDFFRBN $PINS Q=backward_metrics[1][0][0]
+ D=n2339 CK=clk_i_clone17 RB=FE_OFN193_i_reset_n_i
Xbackward_metrics_reg[5][2][0] QDFFRBN $PINS Q=backward_metrics[5][2][0]
+ D=n2555 CK=CTS_50 RB=FE_OFN406_i_reset_n_i
Xbackward_metrics_reg[5][3][0] QDFFRBN $PINS Q=backward_metrics[5][3][0]
+ D=n2567 CK=CTS_50 RB=FE_OFN94_i_reset_n_i
Xbackward_metrics_reg[5][0][0] QDFFRBN $PINS Q=backward_metrics[5][0][0]
+ D=n2531 CK=clk_i_clone16 RB=FE_OFN52_i_reset_n_i
Xbranch_metrics_reg[0][2][0] QDFFRBN $PINS Q=forward_sum[0][1][0] D=n2651
+ CK=clk_i_clone16 RB=FE_OFN34_i_reset_n_i
Xbackward_metrics_reg[4][0][0] QDFFRBN $PINS Q=backward_metrics[4][0][0]
+ D=n2483 CK=clk_i_clone16 RB=FE_OFN15_i_reset_n_i
Xbackward_metrics_reg[4][2][0] QDFFRBN $PINS Q=backward_metrics[4][2][0]
+ D=n2507 CK=CTS_50 RB=FE_OFN407_i_reset_n_i
Xbranch_metrics_reg[6][2][11] QDFFRBN $PINS Q=backward_sum[0][2][11] D=n2928
+ CK=clk_i RB=FE_OFN379_i_reset_n_i
Xbranch_metrics_reg[1][2][11] QDFFRBN $PINS Q=branch_metrics[1][2][11] D=n2688
+ CK=clk_i RB=FE_OFN129_i_reset_n_i
Xbranch_metrics_reg[2][2][11] QDFFRBN $PINS Q=branch_metrics[2][2][11] D=n2736
+ CK=clk_i RB=FE_OFN129_i_reset_n_i
Xbranch_metrics_reg[5][2][11] QDFFRBN $PINS Q=branch_metrics[5][2][11] D=n2880
+ CK=CTS_58 RB=FE_OFN479_i_reset_n_i
Xbranch_metrics_reg[6][1][10] QDFFRBN $PINS Q=branch_metrics[6][1][10] D=n2917
+ CK=CTS_59 RB=FE_OFN481_i_reset_n_i
Xbranch_metrics_reg[1][1][10] QDFFRBN $PINS Q=branch_metrics[1][1][10] D=n2677
+ CK=CTS_59 RB=FE_OFN323_i_reset_n_i
Xbranch_metrics_reg[1][2][10] QDFFRBN $PINS Q=branch_metrics[1][2][10] D=n2689
+ CK=clk_i RB=FE_OFN44_i_reset_n_i
Xbranch_metrics_reg[2][1][10] QDFFRBN $PINS Q=branch_metrics[2][1][10] D=n2725
+ CK=CTS_59 RB=FE_OFN267_i_reset_n_i
Xbranch_metrics_reg[2][2][10] QDFFRBN $PINS Q=branch_metrics[2][2][10] D=n2737
+ CK=clk_i RB=FE_OFN66_i_reset_n_i
Xbranch_metrics_reg[5][1][10] QDFFRBN $PINS Q=branch_metrics[5][1][10] D=n2869
+ CK=CTS_59 RB=FE_OFN499_i_reset_n_i
Xbranch_metrics_reg[5][2][10] QDFFRBN $PINS Q=branch_metrics[5][2][10] D=n2881
+ CK=clk_i RB=FE_OFN441_i_reset_n_i
Xbranch_metrics_reg[6][2][10] QDFFRBN $PINS Q=backward_sum[0][2][10] D=n2929
+ CK=clk_i RB=FE_OFN87_i_reset_n_i
Xbranch_metrics_reg[1][2][0] QDFFRBN $PINS Q=branch_metrics[1][2][0] D=n2699
+ CK=clk_i_clone17 RB=FE_OFN343_i_reset_n_i
Xbranch_metrics_reg[0][0][10] QDFFRBN $PINS Q=forward_sum[0][0][10] D=n2617
+ CK=clk_i RB=FE_OFN9_i_reset_n_i
Xbranch_metrics_reg[6][3][10] QDFFRBN $PINS Q=branch_metrics[6][3][10] D=n2941
+ CK=CTS_59 RB=FE_OFN499_i_reset_n_i
Xbranch_metrics_reg[1][0][10] QDFFRBN $PINS Q=branch_metrics[1][0][10] D=n2665
+ CK=clk_i RB=FE_OFN44_i_reset_n_i
Xbranch_metrics_reg[1][3][10] QDFFRBN $PINS Q=branch_metrics[1][3][10] D=n2701
+ CK=CTS_59 RB=FE_OFN323_i_reset_n_i
Xbranch_metrics_reg[2][0][10] QDFFRBN $PINS Q=branch_metrics[2][0][10] D=n2713
+ CK=clk_i RB=FE_OFN87_i_reset_n_i
Xbranch_metrics_reg[2][3][10] QDFFRBN $PINS Q=branch_metrics[2][3][10] D=n2749
+ CK=CTS_59 RB=FE_OFN267_i_reset_n_i
Xbranch_metrics_reg[5][0][10] QDFFRBN $PINS Q=branch_metrics[5][0][10] D=n2857
+ CK=CTS_58 RB=FE_OFN479_i_reset_n_i
Xbranch_metrics_reg[6][0][10] QDFFRBN $PINS Q=backward_sum[0][0][10] D=n2905
+ CK=clk_i RB=FE_OFN87_i_reset_n_i
Xbranch_metrics_reg[3][0][10] QDFFRBN $PINS Q=branch_metrics[3][0][10] D=n2761
+ CK=CTS_61 RB=FE_OFN149_i_reset_n_i
Xbranch_metrics_reg[4][2][0] QDFFRBN $PINS Q=branch_metrics[4][2][0] D=n2843
+ CK=clk_i_clone17 RB=FE_OFN465_i_reset_n_i
Xbranch_metrics_reg[0][3][0] QDFFRBN $PINS Q=forward_sum[0][5][0] D=n2663
+ CK=clk_i_clone23 RB=FE_OFN36_i_reset_n_i
Xbranch_metrics_reg[5][3][0] QDFFRBN $PINS Q=branch_metrics[5][3][0] D=n2903
+ CK=CTS_50 RB=FE_OFN469_i_reset_n_i
Xbranch_metrics_reg[3][0][0] QDFFRBN $PINS Q=branch_metrics[3][0][0] D=n2771
+ CK=clk_i_clone17 RB=FE_OFN159_i_reset_n_i
Xbranch_metrics_reg[1][0][0] QDFFRBP $PINS Q=branch_metrics[1][0][0] D=n2675
+ CK=clk_i_clone17 RB=FE_OFN76_i_reset_n_i
Xbranch_metrics_reg[4][0][0] QDFFRBN $PINS Q=branch_metrics[4][0][0] D=n2819
+ CK=clk_i_clone17 RB=FE_OFN92_i_reset_n_i
Xbranch_metrics_reg[0][0][0] QDFFRBN $PINS Q=forward_sum[0][2][0] D=n2627
+ CK=clk_i_clone16 RB=FE_OFN34_i_reset_n_i
Xbranch_metrics_reg[5][0][4] QDFFRBN $PINS Q=branch_metrics[5][0][4] D=n2863
+ CK=clk_i_clone13 RB=FE_OFN33_i_reset_n_i
Xbranch_metrics_reg[3][0][5] QDFFRBN $PINS Q=branch_metrics[3][0][5] D=n2766
+ CK=CTS_57 RB=FE_OFN161_i_reset_n_i
Xbranch_metrics_reg[5][0][3] QDFFRBN $PINS Q=branch_metrics[5][0][3] D=n2864
+ CK=CTS_52 RB=FE_OFN91_i_reset_n_i
Xbranch_metrics_reg[3][3][5] QDFFRBN $PINS Q=branch_metrics[3][3][5] D=n2802
+ CK=CTS_55 RB=FE_OFN138_i_reset_n_i
Xbranch_metrics_reg[5][3][4] QDFFRBN $PINS Q=branch_metrics[5][3][4] D=n2899
+ CK=CTS_53 RB=FE_OFN284_i_reset_n_i
Xbranch_metrics_reg[3][0][4] QDFFRBN $PINS Q=branch_metrics[3][0][4] D=n2767
+ CK=clk_i_clone13 RB=FE_OFN14_i_reset_n_i
Xbranch_metrics_reg[4][3][5] QDFFRBN $PINS Q=branch_metrics[4][3][5] D=n2850
+ CK=CTS_55 RB=FE_OFN411_i_reset_n_i
Xbranch_metrics_reg[2][0][4] QDFFRBN $PINS Q=branch_metrics[2][0][4] D=n2719
+ CK=clk_i_clone13 RB=FE_OFN484_i_reset_n_i
Xbranch_metrics_reg[3][3][4] QDFFRBN $PINS Q=branch_metrics[3][3][4] D=n2803
+ CK=CTS_53 RB=FE_OFN233_i_reset_n_i
Xbranch_metrics_reg[2][3][4] QDFFRBN $PINS Q=branch_metrics[2][3][4] D=n2755
+ CK=CTS_53 RB=FE_OFN284_i_reset_n_i
Xbranch_metrics_reg[1][3][4] QDFFRBN $PINS Q=branch_metrics[1][3][4] D=n2707
+ CK=CTS_53 RB=FE_OFN342_i_reset_n_i
Xbranch_metrics_reg[2][0][3] QDFFRBN $PINS Q=branch_metrics[2][0][3] D=n2720
+ CK=CTS_56 RB=FE_OFN484_i_reset_n_i
Xbranch_metrics_reg[3][3][2] QDFFRBN $PINS Q=branch_metrics[3][3][2] D=n2805
+ CK=CTS_49 RB=FE_OFN304_i_reset_n_i
Xbranch_metrics_reg[3][3][3] QDFFRBN $PINS Q=branch_metrics[3][3][3] D=n2804
+ CK=CTS_49 RB=FE_OFN56_i_reset_n_i
Xbranch_metrics_reg[1][3][3] QDFFRBN $PINS Q=branch_metrics[1][3][3] D=n2708
+ CK=CTS_53 RB=FE_OFN463_i_reset_n_i
Xbranch_metrics_reg[4][3][4] QDFFRBN $PINS Q=branch_metrics[4][3][4] D=n2851
+ CK=CTS_53 RB=FE_OFN233_i_reset_n_i
Xbranch_metrics_reg[4][0][4] QDFFRBN $PINS Q=branch_metrics[4][0][4] D=n2815
+ CK=clk_i_clone13 RB=FE_OFN484_i_reset_n_i
Xbranch_metrics_reg[4][3][2] QDFFRBN $PINS Q=branch_metrics[4][3][2] D=n2853
+ CK=CTS_49 RB=FE_OFN404_i_reset_n_i
Xbranch_metrics_reg[2][3][3] QDFFRBN $PINS Q=branch_metrics[2][3][3] D=n2756
+ CK=CTS_53 RB=FE_OFN463_i_reset_n_i
Xbranch_metrics_reg[4][3][3] QDFFRBN $PINS Q=branch_metrics[4][3][3] D=n2852
+ CK=CTS_53 RB=FE_OFN399_i_reset_n_i
Xbranch_metrics_reg[3][0][3] QDFFRBN $PINS Q=branch_metrics[3][0][3] D=n2768
+ CK=CTS_56 RB=FE_OFN74_i_reset_n_i
Xcount_reg[0] QDFFRBP $PINS Q=count[0] D=n3097 CK=clk_i_clone3
+ RB=FE_OFN320_i_reset_n_i
Xbranch_metrics_reg[2][1][0] QDFFRBN $PINS Q=branch_metrics[2][1][0] D=n2735
+ CK=CTS_50 RB=FE_OFN407_i_reset_n_i
Xbranch_metrics_reg[2][3][0] QDFFRBN $PINS Q=branch_metrics[2][3][0] D=n2759
+ CK=CTS_50 RB=FE_OFN36_i_reset_n_i
Xbackward_metrics_reg[6][1][0] QDFFRBN $PINS Q=backward_metrics[6][1][0]
+ D=n2591 CK=clk_i_clone16 RB=FE_OFN34_i_reset_n_i
Xbranch_metrics_reg[1][1][0] QDFFRBN $PINS Q=branch_metrics[1][1][0] D=n2687
+ CK=CTS_50 RB=FE_OFN406_i_reset_n_i
Xbackward_metrics_reg[6][3][0] QDFFRBN $PINS Q=backward_metrics[6][3][0]
+ D=n2615 CK=clk_i_clone23 RB=FE_OFN17_i_reset_n_i
Xbackward_metrics_reg[3][1][0] QDFFRBN $PINS Q=backward_metrics[3][1][0]
+ D=n2447 CK=clk_i_clone16 RB=FE_OFN53_i_reset_n_i
Xbackward_metrics_reg[3][3][0] QDFFRBN $PINS Q=backward_metrics[3][3][0]
+ D=n2471 CK=CTS_50 RB=FE_OFN116_i_reset_n_i
Xbackward_metrics_reg[1][3][0] QDFFRBN $PINS Q=backward_metrics[1][3][0]
+ D=n2375 CK=clk_i_clone21 RB=FE_OFN116_i_reset_n_i
Xbackward_metrics_reg[1][1][0] QDFFRBN $PINS Q=backward_metrics[1][1][0]
+ D=n2351 CK=clk_i_clone17 RB=FE_OFN193_i_reset_n_i
Xbackward_metrics_reg[5][1][0] QDFFRBN $PINS Q=backward_metrics[5][1][0]
+ D=n2543 CK=clk_i_clone16 RB=FE_OFN76_i_reset_n_i
Xbranch_metrics_reg[5][0][2] QDFFRBN $PINS Q=branch_metrics[5][0][2] D=n2865
+ CK=CTS_52 RB=FE_OFN239_i_reset_n_i
Xbackward_metrics_reg[6][0][0] QDFFRBN $PINS Q=backward_metrics[6][0][0]
+ D=n2579 CK=clk_i_clone16 RB=FE_OFN77_i_reset_n_i
Xbranch_metrics_reg[5][3][2] QDFFRBN $PINS Q=branch_metrics[5][3][2] D=n2901
+ CK=CTS_49 RB=FE_OFN467_i_reset_n_i
Xbranch_metrics_reg[5][3][3] QDFFRBN $PINS Q=branch_metrics[5][3][3] D=n2900
+ CK=CTS_53 RB=FE_OFN463_i_reset_n_i
Xbranch_metrics_reg[2][0][2] QDFFRBN $PINS Q=branch_metrics[2][0][2] D=n2721
+ CK=clk_i_clone16 RB=FE_OFN16_i_reset_n_i
Xbranch_metrics_reg[4][0][2] QDFFRBN $PINS Q=branch_metrics[4][0][2] D=n2817
+ CK=CTS_52 RB=FE_OFN16_i_reset_n_i
Xbranch_metrics_reg[4][0][3] QDFFRBN $PINS Q=branch_metrics[4][0][3] D=n2816
+ CK=CTS_52 RB=FE_OFN396_i_reset_n_i
Xbranch_metrics_reg[1][0][3] QDFFRBN $PINS Q=branch_metrics[1][0][3] D=n2672
+ CK=CTS_56 RB=FE_OFN91_i_reset_n_i
Xbranch_metrics_reg[2][3][2] QDFFRBN $PINS Q=branch_metrics[2][3][2] D=n2757
+ CK=CTS_49 RB=FE_OFN470_i_reset_n_i
Xbranch_metrics_reg[1][3][2] QDFFRBN $PINS Q=branch_metrics[1][3][2] D=n2709
+ CK=CTS_49 RB=FE_OFN18_i_reset_n_i
Xbackward_metrics_reg[4][3][0] QDFFRBN $PINS Q=backward_metrics[4][3][0]
+ D=n2519 CK=CTS_50 RB=FE_OFN36_i_reset_n_i
Xbranch_metrics_reg[5][0][1] QDFFRBN $PINS Q=branch_metrics[5][0][1] D=n2866
+ CK=clk_i_clone17 RB=FE_OFN405_i_reset_n_i
Xbranch_metrics_reg[5][3][1] QDFFRBN $PINS Q=branch_metrics[5][3][1] D=n2902
+ CK=CTS_49 RB=FE_OFN408_i_reset_n_i
Xbranch_metrics_reg[3][0][1] QDFFRBN $PINS Q=branch_metrics[3][0][1] D=n2770
+ CK=CTS_52 RB=FE_OFN346_i_reset_n_i
Xbranch_metrics_reg[2][0][1] QDFFRBN $PINS Q=branch_metrics[2][0][1] D=n2722
+ CK=clk_i_clone16 RB=FE_OFN15_i_reset_n_i
Xbranch_metrics_reg[1][3][1] QDFFRBN $PINS Q=branch_metrics[1][3][1] D=n2710
+ CK=CTS_50 RB=FE_OFN407_i_reset_n_i
Xbranch_metrics_reg[2][3][1] QDFFRBN $PINS Q=branch_metrics[2][3][1] D=n2758
+ CK=CTS_50 RB=FE_OFN36_i_reset_n_i
Xbranch_metrics_reg[1][0][1] QDFFRBN $PINS Q=branch_metrics[1][0][1] D=n2674
+ CK=clk_i_clone17 RB=FE_OFN76_i_reset_n_i
Xbranch_metrics_reg[4][3][1] QDFFRBN $PINS Q=branch_metrics[4][3][1] D=n2854
+ CK=CTS_50 RB=FE_OFN291_i_reset_n_i
Xbranch_metrics_reg[3][3][1] QDFFRBN $PINS Q=branch_metrics[3][3][1] D=n2806
+ CK=CTS_49 RB=FE_OFN408_i_reset_n_i
Xbranch_metrics_reg[4][0][1] QDFFRBN $PINS Q=branch_metrics[4][0][1] D=n2818
+ CK=clk_i_clone17 RB=FE_OFN92_i_reset_n_i
Xbackward_metrics_reg[6][3][1] QDFFRBN $PINS Q=backward_metrics[6][3][1]
+ D=n2614 CK=clk_i_clone21 RB=FE_OFN116_i_reset_n_i
Xbranch_metrics_reg[5][1][0] QDFFRBN $PINS Q=n1434 D=n2879 CK=CTS_50
+ RB=FE_OFN468_i_reset_n_i
Xforward_metrics_reg[2][0][2] QDFFRBN $PINS Q=forward_metrics[2][0][2] D=n2097
+ CK=CTS_52 RB=FE_OFN236_i_reset_n_i
Xbranch_metrics_reg[5][0][0] QDFFRBN $PINS Q=branch_metrics[5][0][0] D=n2867
+ CK=clk_i_clone17 RB=FE_OFN486_i_reset_n_i
Xbranch_metrics_reg[1][3][0] QDFFRBN $PINS Q=branch_metrics[1][3][0] D=n2711
+ CK=CTS_50 RB=FE_OFN407_i_reset_n_i
Xbranch_metrics_reg[3][0][2] QDFFRBN $PINS Q=branch_metrics[3][0][2] D=n2769
+ CK=CTS_52 RB=FE_OFN345_i_reset_n_i
Xbranch_metrics_reg[3][3][0] QDFFRBN $PINS Q=branch_metrics[3][3][0] D=n2807
+ CK=CTS_50 RB=FE_OFN408_i_reset_n_i
Xbranch_metrics_reg[5][2][0] QDFFRBN $PINS Q=branch_metrics[5][2][0] D=n2891
+ CK=clk_i_clone17 RB=FE_OFN486_i_reset_n_i
Xbranch_metrics_reg[2][2][0] QDFFRBN $PINS Q=branch_metrics[2][2][0] D=n2747
+ CK=clk_i_clone17 RB=FE_OFN194_i_reset_n_i
Xbranch_metrics_reg[3][2][0] QDFFRBN $PINS Q=branch_metrics[3][2][0] D=n2795
+ CK=clk_i_clone17 RB=FE_OFN159_i_reset_n_i
Xbranch_metrics_reg[2][0][0] QDFFRBP $PINS Q=branch_metrics[2][0][0] D=n2723
+ CK=clk_i_clone17 RB=FE_OFN194_i_reset_n_i
Xbranch_metrics_reg[4][3][0] QDFFRBN $PINS Q=branch_metrics[4][3][0] D=n2855
+ CK=CTS_50 RB=FE_OFN347_i_reset_n_i
Xbranch_metrics_reg[1][0][2] QDFFRBN $PINS Q=branch_metrics[1][0][2] D=n2673
+ CK=CTS_52 RB=FE_OFN35_i_reset_n_i
Xforward_metrics_reg[4][1][1] QDFFRBN $PINS Q=forward_metrics[4][1][1] D=n2206
+ CK=clk_i_clone17 RB=FE_OFN487_i_reset_n_i
Xforward_metrics_reg[3][1][3] QDFFRBN $PINS Q=forward_metrics[3][1][3] D=n2156
+ CK=CTS_52 RB=FE_OFN398_i_reset_n_i
Xforward_metrics_reg[1][1][1] QDFFRBN $PINS Q=forward_metrics[1][1][1] D=n2062
+ CK=CTS_50 RB=FE_OFN111_i_reset_n_i
Xforward_metrics_reg[4][1][3] QDFFRBN $PINS Q=forward_metrics[4][1][3] D=n2204
+ CK=CTS_52 RB=FE_OFN398_i_reset_n_i
Xforward_metrics_reg[4][2][1] QDFFRBP $PINS Q=forward_metrics[4][2][1] D=n2218
+ CK=clk_i_clone17 RB=FE_OFN111_i_reset_n_i
Xforward_metrics_reg[2][0][1] QDFFRBP $PINS Q=forward_metrics[2][0][1] D=n2098
+ CK=clk_i_clone17 RB=FE_OFN197_i_reset_n_i
Xforward_metrics_reg[1][0][1] QDFFRBN $PINS Q=forward_metrics[1][0][1] D=n2050
+ CK=clk_i_clone17 RB=FE_OFN92_i_reset_n_i
Xforward_metrics_reg[4][0][3] QDFFRBN $PINS Q=forward_metrics[4][0][3] D=n2192
+ CK=CTS_52 RB=FE_OFN398_i_reset_n_i
Xforward_metrics_reg[3][2][1] QDFFRBN $PINS Q=forward_metrics[3][2][1] D=n2170
+ CK=CTS_49 RB=FE_OFN405_i_reset_n_i
Xforward_metrics_reg[3][0][1] QDFFRBP $PINS Q=forward_metrics[3][0][1] D=n2146
+ CK=CTS_49 RB=FE_OFN405_i_reset_n_i
Xforward_metrics_reg[5][3][1] QDFFRBN $PINS Q=forward_metrics[5][3][1] D=n2278
+ CK=CTS_49 RB=FE_OFN292_i_reset_n_i
Xforward_metrics_reg[3][3][3] QDFFRBN $PINS Q=forward_metrics[3][3][3] D=n2180
+ CK=CTS_52 RB=FE_OFN340_i_reset_n_i
Xforward_metrics_reg[4][3][3] QDFFRBN $PINS Q=forward_metrics[4][3][3] D=n2228
+ CK=CTS_52 RB=FE_OFN340_i_reset_n_i
Xforward_metrics_reg[5][3][3] QDFFRBN $PINS Q=forward_metrics[5][3][3] D=n2276
+ CK=CTS_52 RB=FE_OFN340_i_reset_n_i
Xforward_metrics_reg[4][3][1] QDFFRBP $PINS Q=forward_metrics[4][3][1] D=n2230
+ CK=clk_i_clone17 RB=FE_OFN487_i_reset_n_i
Xforward_metrics_reg[4][2][3] QDFFRBN $PINS Q=forward_metrics[4][2][3] D=n2216
+ CK=CTS_52 RB=FE_OFN340_i_reset_n_i
Xforward_metrics_reg[3][2][3] QDFFRBN $PINS Q=forward_metrics[3][2][3] D=n2168
+ CK=CTS_52 RB=FE_OFN287_i_reset_n_i
Xforward_metrics_reg[5][1][1] QDFFRBN $PINS Q=forward_metrics[5][1][1] D=n2254
+ CK=CTS_49 RB=FE_OFN292_i_reset_n_i
Xforward_metrics_reg[2][2][1] QDFFRBN $PINS Q=forward_metrics[2][2][1] D=n2122
+ CK=clk_i_clone17 RB=FE_OFN486_i_reset_n_i
Xforward_metrics_reg[3][0][0] QDFFRBP $PINS Q=forward_metrics[3][0][0] D=n2147
+ CK=clk_i_clone17 RB=FE_OFN159_i_reset_n_i
Xforward_metrics_reg[5][1][3] QDFFRBN $PINS Q=forward_metrics[5][1][3] D=n2252
+ CK=CTS_52 RB=FE_OFN232_i_reset_n_i
Xforward_metrics_reg[3][0][2] QDFFRBN $PINS Q=forward_metrics[3][0][2] D=n2145
+ CK=CTS_52 RB=FE_OFN287_i_reset_n_i
Xforward_metrics_reg[3][1][2] QDFFRBN $PINS Q=forward_metrics[3][1][2] D=n2157
+ CK=CTS_52 RB=FE_OFN196_i_reset_n_i
Xforward_metrics_reg[5][2][2] QDFFRBN $PINS Q=forward_metrics[5][2][2] D=n2265
+ CK=CTS_52 RB=FE_OFN288_i_reset_n_i
Xforward_metrics_reg[4][0][2] QDFFRBN $PINS Q=forward_metrics[4][0][2] D=n2193
+ CK=CTS_52 RB=FE_OFN398_i_reset_n_i
Xforward_metrics_reg[2][0][3] QDFFRBN $PINS Q=forward_metrics[2][0][3] D=n2096
+ CK=CTS_52 RB=FE_OFN339_i_reset_n_i
Xforward_metrics_reg[4][1][2] QDFFRBN $PINS Q=forward_metrics[4][1][2] D=n2205
+ CK=CTS_52 RB=FE_OFN287_i_reset_n_i
Xforward_metrics_reg[1][0][3] QDFFRBN $PINS Q=forward_metrics[1][0][3] D=n2048
+ CK=CTS_52 RB=FE_OFN398_i_reset_n_i
Xforward_metrics_reg[2][2][2] QDFFRBN $PINS Q=forward_metrics[2][2][2] D=n2121
+ CK=CTS_49 RB=FE_OFN346_i_reset_n_i
Xforward_metrics_reg[5][1][2] QDFFRBN $PINS Q=forward_metrics[5][1][2] D=n2253
+ CK=CTS_52 RB=FE_OFN287_i_reset_n_i
Xforward_metrics_reg[4][2][2] QDFFRBN $PINS Q=forward_metrics[4][2][2] D=n2217
+ CK=CTS_52 RB=FE_OFN287_i_reset_n_i
Xforward_metrics_reg[3][2][2] QDFFRBN $PINS Q=forward_metrics[3][2][2] D=n2169
+ CK=CTS_49 RB=FE_OFN288_i_reset_n_i
Xforward_metrics_reg[4][3][2] QDFFRBN $PINS Q=forward_metrics[4][3][2] D=n2229
+ CK=CTS_49 RB=FE_OFN287_i_reset_n_i
Xforward_metrics_reg[5][3][2] QDFFRBN $PINS Q=forward_metrics[5][3][2] D=n2277
+ CK=CTS_52 RB=FE_OFN196_i_reset_n_i
Xforward_metrics_reg[3][3][2] QDFFRBN $PINS Q=forward_metrics[3][3][2] D=n2181
+ CK=CTS_49 RB=FE_OFN236_i_reset_n_i
Xforward_metrics_reg[1][0][2] QDFFRBN $PINS Q=forward_metrics[1][0][2] D=n2049
+ CK=CTS_49 RB=FE_OFN289_i_reset_n_i
Xforward_metrics_reg[1][3][3] QDFFRBN $PINS Q=forward_metrics[1][3][3] D=n2084
+ CK=CTS_52 RB=FE_OFN283_i_reset_n_i
Xforward_metrics_reg[5][3][4] QDFFRBN $PINS Q=forward_metrics[5][3][4] D=n2275
+ CK=CTS_53 RB=FE_OFN395_i_reset_n_i
Xforward_metrics_reg[4][2][4] QDFFRBN $PINS Q=forward_metrics[4][2][4] D=n2215
+ CK=CTS_56 RB=FE_OFN482_i_reset_n_i
Xforward_metrics_reg[4][3][4] QDFFRBN $PINS Q=forward_metrics[4][3][4] D=n2227
+ CK=CTS_53 RB=FE_OFN395_i_reset_n_i
Xforward_metrics_reg[3][3][4] QDFFRBN $PINS Q=forward_metrics[3][3][4] D=n2179
+ CK=CTS_53 RB=FE_OFN457_i_reset_n_i
Xforward_metrics_reg[2][2][3] QDFFRBN $PINS Q=forward_metrics[2][2][3] D=n2120
+ CK=CTS_53 RB=FE_OFN192_i_reset_n_i
Xforward_metrics_reg[3][2][4] QDFFRBN $PINS Q=forward_metrics[3][2][4] D=n2167
+ CK=CTS_53 RB=FE_OFN458_i_reset_n_i
Xforward_metrics_reg[5][2][3] QDFFRBN $PINS Q=forward_metrics[5][2][3] D=n2264
+ CK=CTS_52 RB=FE_OFN339_i_reset_n_i
Xforward_metrics_reg[2][2][4] QDFFRBN $PINS Q=forward_metrics[2][2][4] D=n2119
+ CK=CTS_53 RB=FE_OFN458_i_reset_n_i
Xforward_metrics_reg[5][2][4] QDFFRBN $PINS Q=forward_metrics[5][2][4] D=n2263
+ CK=CTS_53 RB=FE_OFN457_i_reset_n_i
Xbranch_metrics_reg[6][3][2] QDFFRBN $PINS Q=backward_sum[0][3][2] D=n2949
+ CK=CTS_49 RB=FE_OFN404_i_reset_n_i
Xforward_metrics_reg[3][3][1] QDFFRBN $PINS Q=forward_metrics[3][3][1] D=n2182
+ CK=CTS_49 RB=FE_OFN292_i_reset_n_i
Xforward_metrics_reg[1][3][1] QDFFRBP $PINS Q=forward_metrics[1][3][1] D=n2086
+ CK=CTS_50 RB=FE_OFN111_i_reset_n_i
Xforward_metrics_reg[5][2][1] QDFFRBN $PINS Q=forward_metrics[5][2][1] D=n2266
+ CK=clk_i_clone17 RB=FE_OFN198_i_reset_n_i
Xforward_metrics_reg[2][3][1] QDFFRBN $PINS Q=forward_metrics[2][3][1] D=n2134
+ CK=clk_i_clone17 RB=FE_OFN486_i_reset_n_i
Xforward_metrics_reg[2][1][0] QDFFRBN $PINS Q=forward_metrics[2][1][0] D=n2111
+ CK=clk_i_clone17 RB=FE_OFN487_i_reset_n_i
Xforward_metrics_reg[1][1][0] QDFFRBP $PINS Q=forward_metrics[1][1][0] D=n2063
+ CK=clk_i_clone17 RB=FE_OFN131_i_reset_n_i
Xcount_reg[1] QDFFRBP $PINS Q=count[1] D=n3065 CK=clk_i_clone3
+ RB=FE_OFN380_i_reset_n_i
Xcount_reg[2] QDFFRBP $PINS Q=count[2] D=n3064 CK=clk_i_clone3
+ RB=FE_OFN320_i_reset_n_i
Xforward_metrics_reg[4][1][0] QDFFRBN $PINS Q=forward_metrics[4][1][0] D=n2207
+ CK=clk_i_clone17 RB=FE_OFN487_i_reset_n_i
Xforward_metrics_reg[4][0][0] QDFFRBP $PINS Q=forward_metrics[4][0][0] D=n2195
+ CK=CTS_50 RB=FE_OFN131_i_reset_n_i
Xforward_metrics_reg[2][0][0] QDFFRBP $PINS Q=forward_metrics[2][0][0] D=n2099
+ CK=clk_i_clone17 RB=FE_OFN197_i_reset_n_i
Xforward_metrics_reg[3][1][0] QDFFRBN $PINS Q=forward_metrics[3][1][0] D=n2159
+ CK=clk_i_clone17 RB=FE_OFN238_i_reset_n_i
Xforward_metrics_reg[5][1][0] QDFFRBN $PINS Q=forward_metrics[5][1][0] D=n2255
+ CK=CTS_50 RB=FE_OFN198_i_reset_n_i
Xforward_metrics_reg[1][0][0] QDFFRBN $PINS Q=forward_metrics[1][0][0] D=n2051
+ CK=clk_i_clone17 RB=FE_OFN401_i_reset_n_i
Xforward_metrics_reg[4][3][0] QDFFRBP $PINS Q=forward_metrics[4][3][0] D=n2231
+ CK=clk_i_clone17 RB=FE_OFN487_i_reset_n_i
Xforward_metrics_reg[6][3][0] QDFFRBN $PINS Q=forward_metrics[6][3][0] D=n2327
+ CK=CTS_50 RB=FE_OFN290_i_reset_n_i
Xforward_metrics_reg[6][2][0] QDFFRBN $PINS Q=forward_metrics[6][2][0] D=n2315
+ CK=CTS_50 RB=FE_OFN197_i_reset_n_i
Xforward_metrics_reg[2][3][0] QDFFRBP $PINS Q=forward_metrics[2][3][0] D=n2135
+ CK=clk_i_clone17 RB=FE_OFN486_i_reset_n_i
Xforward_metrics_reg[5][2][0] QDFFRBN $PINS Q=forward_metrics[5][2][0] D=n2267
+ CK=CTS_50 RB=FE_OFN238_i_reset_n_i
Xforward_metrics_reg[1][3][0] QDFFRBP $PINS Q=forward_metrics[1][3][0] D=n2087
+ CK=clk_i_clone17 RB=FE_OFN465_i_reset_n_i
Xforward_metrics_reg[4][2][0] QDFFRBN $PINS Q=forward_metrics[4][2][0] D=n2219
+ CK=CTS_50 RB=FE_OFN131_i_reset_n_i
Xforward_metrics_reg[2][2][0] QDFFRBP $PINS Q=forward_metrics[2][2][0] D=n2123
+ CK=clk_i_clone17 RB=FE_OFN466_i_reset_n_i
Xforward_metrics_reg[5][3][0] QDFFRBP $PINS Q=forward_metrics[5][3][0] D=n2279
+ CK=CTS_50 RB=FE_OFN238_i_reset_n_i
Xforward_metrics_reg[3][3][0] QDFFRBN $PINS Q=forward_metrics[3][3][0] D=n2183
+ CK=CTS_49 RB=FE_OFN292_i_reset_n_i
Xforward_metrics_reg[3][2][0] QDFFRBN $PINS Q=forward_metrics[3][2][0] D=n2171
+ CK=CTS_49 RB=FE_OFN292_i_reset_n_i
Xforward_metrics_reg[1][2][0] QDFFRBN $PINS Q=forward_metrics[1][2][0] D=n2075
+ CK=clk_i_clone17 RB=FE_OFN131_i_reset_n_i
Xbranch_metrics_reg[6][3][0] QDFFRBN $PINS Q=backward_sum[0][3][0] D=n2951
+ CK=CTS_50 RB=FE_OFN291_i_reset_n_i
Xbranch_metrics_reg[6][0][0] QDFFRBN $PINS Q=backward_sum[0][4][0] D=n2915
+ CK=clk_i_clone17 RB=FE_OFN466_i_reset_n_i
Xforward_metrics_reg[5][0][0] QDFFRBN $PINS Q=forward_metrics[5][0][0] D=n2243
+ CK=CTS_50 RB=FE_OFN198_i_reset_n_i
Xforward_metrics_reg[2][1][1] QDFFRBN $PINS Q=forward_metrics[2][1][1] D=n2110
+ CK=clk_i_clone17 RB=FE_OFN197_i_reset_n_i
Xforward_metrics_reg[1][2][1] QDFFRBP $PINS Q=forward_metrics[1][2][1] D=n2074
+ CK=clk_i_clone17 RB=FE_OFN92_i_reset_n_i
Xforward_metrics_reg[2][3][3] QDFFRBN $PINS Q=forward_metrics[2][3][3] D=n2132
+ CK=CTS_52 RB=FE_OFN283_i_reset_n_i
XU3 TIE0 $PINS O=n1
XU4 MOAI1S $PINS O=n3063 A1=FE_OFN1337_n995 A2=n5873 B1=FE_OFN1358_n1
+ B2=FE_OFN1337_n995
XU8 MOAI1S $PINS O=n3059 A1=FE_OFN1310_n995 A2=n5869 B1=FE_OFN1356_n1
+ B2=FE_OFN1310_n995
XU11 MOAI1S $PINS O=n3056 A1=FE_OFN1292_n995 A2=n5866 B1=FE_OFN1355_n1
+ B2=FE_OFN1292_n995
XU13 MOAI1S $PINS O=n3054 A1=FE_OFN1284_n995 A2=n5864 B1=FE_OFN1357_n1 B2=n995
XU17 MOAI1S $PINS O=n3050 A1=FE_OFN1337_n995 A2=n5860 B1=FE_OFN1358_n1
+ B2=FE_OFN1337_n995
XU18 MOAI1S $PINS O=n3049 A1=FE_OFN1328_n995 A2=n5859 B1=FE_OFN1358_n1
+ B2=FE_OFN1328_n995
XU20 MOAI1S $PINS O=n3047 A1=FE_OFN1310_n995 A2=n5857 B1=FE_OFN1356_n1
+ B2=FE_OFN1310_n995
XU22 MOAI1S $PINS O=n3045 A1=FE_OFN1293_n995 A2=n5855 B1=FE_OFN1355_n1
+ B2=FE_OFN1293_n995
XU24 MOAI1S $PINS O=n3043 A1=FE_OFN1285_n995 A2=n5853 B1=FE_OFN1355_n1
+ B2=FE_OFN1285_n995
XU32 OR3B2 $PINS O=n985 I1=count[1] B1=FE_OFN5517_count_0 B2=n3667
XU35 OR3B2 $PINS O=n987 I1=FE_OFN5517_count_0 B1=count[1] B2=n3667
XU45 INV1S $PINS O=n5441 I=n4866
XU46 INV1S $PINS O=n4764 I=N628
XU47 INV1S $PINS O=n4603 I=N652
XU48 OA12 $PINS O=n4650 A1=n5755 B1=n4616 B2=n4869
XU49 MAOI1 $PINS O=n4824 A1=n4820 A2=n4819 B1=n4851 B2=n4821
XU50 INV1S $PINS O=n3628 I=N1042
XU51 INV1S $PINS O=n3636 I=sub_0_root_sub_0_root_add_184/A[2]
XU52 INV1S $PINS O=n3632 I=N696
XU53 INV2CK $PINS O=n4882 I=n4933
XU54 INV2 $PINS O=n4881 I=n4935
XU55 MAOI1H $PINS O=n4817 A1=n4814 A2=n4813 B1=n4859 B2=n4815
XU56 INV1S $PINS O=n4815 I=n4858
XU59 OAI222S $PINS O=n5331 A1=n5330 A2=n5329 B1=n5328 B2=n5327 C1=n5367
+ C2=n5326
XU66 OR2 $PINS O=n1437 I1=n4828 I2=n4827
XU67 ND2 $PINS O=n4454 I1=n4453 I2=n4452
XU68 ND2 $PINS O=n4466 I1=n4465 I2=n4464
XU74 INV1S $PINS O=n5273 I=n5154
XU75 INV1S $PINS O=n5112 I=n4993
XU76 INV1S $PINS O=n4672 I=n4553
XU80 OR3B2 $PINS O=n4182 I1=FE_DBTN75_n1441 B1=FE_OFN2057_n982
+ B2=FE_OFN1427_count_0
XU83 INV1S $PINS O=n3629 I=N1043
XU84 INV1S $PINS O=n3637 I=sub_0_root_sub_0_root_add_184/A[3]
XU85 INV1S $PINS O=n3633 I=N697
XU86 ND2 $PINS O=n1536 I1=n1560 I2=n5377
XU97 XNR3 $PINS O=n2 I1=N693 I2=FE_DBTN95_N336 I3=sub_1_root_sub_182_3/carry[5]
XU98 XNR3 $PINS O=n3 I1=N693 I2=FE_OFN2052_N336
+ I3=add_1_root_sub_185_2/carry[5]
XU100 OR2 $PINS O=n4 I1=n1438 I2=n1439
XU101 OAI222H $PINS O=n5 A1=n4672 A2=FE_OFN2202_n4671 B1=n4670 B2=n4669
+ C1=n4668 C2=n4667
XU132 AN2 $PINS O=n6 I1=n4332 I2=FE_OFN1800_n5419
XU133 AN2 $PINS O=n7 I1=n5386 I2=FE_OFN1800_n5419
XU134 XOR2HS $PINS O=n8 I1=n5512 I2=sub_0_root_sub_0_root_add_184/A[0]
XU135 XOR3 $PINS O=n9 I1=sub_0_root_sub_0_root_add_184/A[2] I2=N337 I3=n4004
XU136 XNR3 $PINS O=n10 I1=N357 I2=N1041 I3=n1498
XU137 XNR3 $PINS O=n11 I1=N695 I2=FE_OFN2055_N357 I3=n1499
XU285 INV2 $PINS O=n3667 I=count[2]
XU290 INV2 $PINS O=n5510 I=count[1]
XU292 OR3B2 $PINS O=n3782 I1=count[1] B1=count[2] B2=FE_OFN1427_count_0
XU856 NR2 $PINS O=n754 I1=n4 I2=n1440
XU857 NR2T $PINS O=n1453 I1=n4 I2=n1440
XU865 OR3B2 $PINS O=n1665 I1=FE_OFN5652_FE_OFN5518_count_0 B1=n5510 B2=n3667
XU1319 ND2 $PINS O=n1535 I1=FE_OFN1852_n5509 I2=n5377
XU1331 AN2 $PINS O=n3966 I1=count[2] I2=FE_OFN5652_FE_OFN5518_count_0
XU1339 NR2P $PINS O=n1440 I1=n5348 I2=n5347
XU1340 MUX2S $PINS O=N2966 S=n1453 A=n5369 B=n5368
XU1341 MUX3S $PINS O=N2963 S0=FE_OCPN5685_n1456 S1=n1453 A=n5376
+ B=FE_OFN5529_n5375 C=n5374
XU1342 OR2B1 $PINS O=n4667 I1=n4669 B1=n4666
XU1344 ND2 $PINS O=n5347 I1=n5346 I2=n5345
XU1345 NR2 $PINS O=n1438 I1=n5353 I2=FE_OFN2214_n5351
XU1346 NR2 $PINS O=n1439 I1=n5350 I2=n5349
XU1347 OR2 $PINS O=n1435 I1=n4832 I2=n4831
XU1348 OR2 $PINS O=n1436 I1=n4830 I2=n4829
XU1350 AOI22S $PINS O=n5336 A1=n5364 A2=n5333 B1=n5332 B2=n5331
XU1353 MUX2S $PINS O=N2964 S=n1453 A=n5373 B=n5372
XU1354 MUX2S $PINS O=N2968 S=n1453 A=n5365 B=n5364
XU1355 MUX2S $PINS O=N2970 S=n754 A=n5361 B=n5360
XU1356 MUX2S $PINS O=N2973 S=n754 A=n5355 B=n5354
XU1357 MUX2S $PINS O=N2974 S=n754 A=n5353 B=n5352
XU1358 MUX2S $PINS O=N2965 S=n1453 A=n5371 B=n5370
XU1359 MUX2S $PINS O=N2967 S=n1453 A=n5367 B=n5366
XU1360 MUX2 $PINS O=N2969 S=n754 A=n5363 B=FE_RN_3_0
XU1361 MUX2S $PINS O=N2971 S=n754 A=n5359 B=FE_RN_13_0
XU1362 MUX2S $PINS O=N2972 S=n754 A=n5357 B=n5356
XU1374 AO222 $PINS O=n4987 A1=FE_OFN1381_n1441 A2=n4984 B1=LLR_sum[3][2][10]
+ B2=FE_OFN5614_FE_OFN1728_FE_DBTN71_n4217 C1=LLR_sum[5][2][10]
+ C2=FE_OFN1515_n1442
XU1375 AN2 $PINS O=n1441 I1=count[2] I2=count[1]
XU1390 INV1S $PINS O=n4821 I=n4850
XU1391 ND2P $PINS O=n5267 I1=n5152 I2=n5274
XU1392 ND2 $PINS O=n4666 I1=n4551 I2=n4673
XU1394 ND2S $PINS O=n1443 I1=sub_182/carry[3] I2=n5528
XU1395 AO222S $PINS O=n4547 A1=FE_OFN1364_n1441 A2=n4544 B1=LLR_sum[3][6][10]
+ B2=FE_OFN1718_FE_DBTN71_n4217 C1=LLR_sum[5][6][10] C2=FE_OFN1482_n1442
XU1396 ND2 $PINS O=n4601 I1=n4600 I2=n4599
XU1397 ND2 $PINS O=n5160 I1=n5159 I2=n5158
XU1399 ND2 $PINS O=n4595 I1=n4594 I2=n4593
XU1400 ND2 $PINS O=n4520 I1=n4519 I2=n4518
XU1401 ND2 $PINS O=n5119 I1=n5118 I2=n5117
XU1402 XOR3 $PINS O=N941 I1=sub_0_root_sub_0_root_add_184/A[11]
+ I2=FE_OFN2061_FE_DBTN95_N336 I3=sub_0_root_sub_0_root_add_184/carry[11]
XU1403 INV1S $PINS O=n5512 I=N339
XU1407 XOR3S $PINS O=n4206 I1=N813 I2=FE_OFN2053_N355 I3=n3772
XU1408 MUX2S $PINS O=n2928 S=FE_OFN2147_n4223
+ A=FE_OFN1278_backward_sum_0__2__11 B=FE_OFN2173_N941
XU1409 MUX2S $PINS O=n2880 S=FE_OFN2073_n1514
+ A=FE_OFN944_branch_metrics_5__2__11 B=FE_OFN2173_N941
XU1410 MUX2S $PINS O=n2832 S=FE_OFN2085_n1515 A=branch_metrics[4][2][11]
+ B=FE_OFN2173_N941
XU1411 MUX2S $PINS O=n2784 S=FE_OFN2094_n1516
+ A=FE_OFN849_branch_metrics_3__2__11 B=N941
XU1412 MUX2S $PINS O=n2736 S=FE_OFN2107_n1517
+ A=FE_OFN801_branch_metrics_2__2__11 B=FE_OFN2173_N941
XU1413 MUX2S $PINS O=n2688 S=FE_OFN2114_n1518 A=branch_metrics[1][2][11]
+ B=FE_OFN2173_N941
XU1414 AN2 $PINS O=n1442 I1=count[2] I2=FE_OFN5518_count_0
XU1434 ND2S $PINS O=n5345 I1=n5356 I2=n5287
XU1435 ND2S $PINS O=n5332 I1=n5326 I2=n5367
XU1436 ND2S $PINS O=n4893 I1=n4887 I2=n4928
XU1438 ND2S $PINS O=n4906 I1=n4917 I2=n4847
XU1439 ND2S $PINS O=n5339 I1=n5337 I2=n5363
XU1440 ND2S $PINS O=n4900 I1=n4898 I2=n4924
XU1441 ND2S $PINS O=n4845 I1=n4920 I2=n4903
XU1445 OA222S $PINS O=n4911 A1=n4847 A2=n4917 B1=n4846 B2=n4845 C1=n4844
+ C2=n4915
XU1446 MUX2S $PINS O=n5367 S=FE_OCPN5685_n1456 A=n5305 B=FE_OFN5549_n5304
XU1448 MUX2 $PINS O=n5364 S=FE_OFN2060_n1457 A=n5299 B=n5298
XU1449 MUX2 $PINS O=n5365 S=FE_OCPN5686_n1456 A=n5301 B=n5300
XU1450 ND2S $PINS O=n5106 I1=n4991 I2=n5113
XU1451 MUX2 $PINS O=n5357 S=FE_OCPN5685_n1456 A=n5114 B=n5113
XU1452 MUX2 $PINS O=n5371 S=FE_OFN2059_n1456 A=n5309 B=n5308
XU1453 MUX2 $PINS O=n5366 S=FE_OFN2060_n1457 A=n5303 B=FE_OFN2225_n5302
XU1454 ND2S $PINS O=n5093 I1=n5087 I2=n5305
XU1455 ND2S $PINS O=n5254 I1=n5248 I2=n5303
XU1456 ND2S $PINS O=n4653 I1=n4647 I2=n4865
XU1457 ND2S $PINS O=n4814 I1=n4808 I2=n4863
XU1458 MUX2S $PINS O=n5363 S=FE_OCPN5686_n1456 A=n5297 B=FE_OFN5580_n5296
XU1459 MUX2S $PINS O=n5359 S=FE_OCPN5686_n1456 A=n5277 B=FE_OFN2222_n5276
XU1460 MUX2S $PINS O=n5355 S=FE_OCPN5685_n1456 A=FE_OFN5571_n5281 B=n4992
XU1461 MUX2S $PINS O=n5360 S=FE_OFN5554_n1457 A=n5291 B=n5290
XU1462 MUX2S $PINS O=n5356 S=n1457 A=n5275 B=n5274
XU1463 MUX2 $PINS O=n5361 S=FE_OCPN5686_n1456 A=n5293 B=n5292
XU1464 MUX2S $PINS O=n5354 S=n1457 A=n5283 B=n5282
XU1467 MUX2S $PINS O=n5358 S=FE_OFN5554_n1457 A=n5279 B=n5278
XU1468 ND2S $PINS O=n5100 I1=n5098 I2=n5297
XU1469 ND2S $PINS O=n5261 I1=n5259 I2=n5295
XU1470 ND2S $PINS O=n4660 I1=n4658 I2=n4857
XU1471 ND2S $PINS O=n4820 I1=n4818 I2=n4855
XU1472 ND2S $PINS O=n5150 I1=n5264 I2=n5279
XU1473 ND2S $PINS O=n4549 I1=n4663 I2=n4837
XU1479 ND2S $PINS O=n4608 I1=n4607 I2=n4606
XU1480 ND2S $PINS O=n5048 I1=n5047 I2=n5046
XU1481 ND2S $PINS O=n5209 I1=n5208 I2=n5207
XU1482 ND2 $PINS O=n4769 I1=n4768 I2=n4767
XU1483 ND2 $PINS O=n5029 I1=n5028 I2=n5027
XU1484 ND2S $PINS O=n5190 I1=n5189 I2=n5188
XU1485 MUX2 $PINS O=n5373 S=FE_OFN2059_n1456 A=n5316 B=FE_OFN2212_n5315
XU1486 ND2S $PINS O=n4496 I1=n4495 I2=n4494
XU1487 ND2S $PINS O=n4484 I1=n4483 I2=n4482
XU1488 ND2 $PINS O=n4472 I1=n4471 I2=n4470
XU1489 ND2S $PINS O=n4460 I1=n4459 I2=n4458
XU1490 ND2S $PINS O=n4490 I1=n4489 I2=n4488
XU1491 ND2S $PINS O=n4478 I1=n4477 I2=n4476
XU1492 ND2S $PINS O=n5054 I1=n5053 I2=n5052
XU1493 ND2S $PINS O=n5215 I1=n5214 I2=n5213
XU1494 ND2 $PINS O=n4614 I1=n4613 I2=n4612
XU1495 ND2S $PINS O=n4775 I1=n4774 I2=n4773
XU1496 ND2S $PINS O=n5023 I1=n5022 I2=n5021
XU1497 ND2S $PINS O=n5184 I1=n5183 I2=n5182
XU1498 ND2 $PINS O=n4583 I1=n4582 I2=n4581
XU1500 ND2 $PINS O=n5035 I1=n5034 I2=n5033
XU1501 ND2S $PINS O=n5041 I1=n5040 I2=n5039
XU1502 ND2P $PINS O=n5196 I1=n5195 I2=n5194
XU1503 ND2S $PINS O=n5202 I1=n5201 I2=n5200
XU1504 ND2S $PINS O=n4756 I1=n4755 I2=n4754
XU1505 ND2P $PINS O=n4762 I1=n4761 I2=n4760
XU1506 ND2S $PINS O=n4960 I1=n4959 I2=n4958
XU1507 XNR2HS $PINS O=N693 I1=n5528 I2=n1443
XU1508 ND2S $PINS O=n4978 I1=n4977 I2=n4976
XU1509 ND2S $PINS O=n5137 I1=n5136 I2=n5135
XU1510 ND2S $PINS O=n4538 I1=n4537 I2=n4536
XU1511 ND2S $PINS O=n4697 I1=n4696 I2=n4695
XU1512 ND2P $PINS O=n4703 I1=n4702 I2=n4701
XU1513 ND2S $PINS O=n5017 I1=n5016 I2=n5015
XU1514 ND2S $PINS O=n5178 I1=n5177 I2=n5176
XU1515 ND2 $PINS O=n4577 I1=n4576 I2=n4575
XU1516 ND2S $PINS O=n4738 I1=n4737 I2=n4736
XU1517 ND2S $PINS O=n4589 I1=n4588 I2=n4587
XU1518 ND2S $PINS O=n4750 I1=n4749 I2=n4748
XU1519 ND2S $PINS O=n5005 I1=n5004 I2=n5003
XU1520 ND2S $PINS O=n4565 I1=n4564 I2=n4563
XU1521 ND2S $PINS O=n4726 I1=n4725 I2=n4724
XU1522 ND2S $PINS O=n4685 I1=n4684 I2=n4683
XU1523 ND2S $PINS O=n4999 I1=n4998 I2=n4997
XU1524 ND2S $PINS O=n4744 I1=n4743 I2=n4742
XU1525 ND2S $PINS O=n4559 I1=n4558 I2=n4557
XU1526 ND2S $PINS O=n4720 I1=n4719 I2=n4718
XU1527 ND2S $PINS O=n5351 I1=n5154 I2=FE_OFN5537_n5272
XU1529 ND2S $PINS O=n5011 I1=n5010 I2=n5009
XU1530 ND2S $PINS O=n5172 I1=n5171 I2=n5170
XU1531 ND2S $PINS O=n4571 I1=n4570 I2=n4569
XU1532 ND2S $PINS O=n4732 I1=n4731 I2=n4730
XU1533 ND2S $PINS O=n4691 I1=n4690 I2=n4689
XU1534 ND2P $PINS O=n4679 I1=n4678 I2=n4677
XU1536 ND2S $PINS O=n5289 I1=n4993 I2=FE_OFN2210_n5111
XU1537 ND2S $PINS O=n4849 I1=n4553 I2=FE_OFN2202_n4671
XU1539 ND2S $PINS O=n4912 I1=n4714 I2=n4831
XU1543 ND2S $PINS O=n3964 I1=forward_sum[3][0][10]
+ I2=FE_OFN5613_FE_OFN1728_FE_DBTN71_n4217
XU1545 AO222 $PINS O=n4945 A1=LLR_sum[3][3][11] A2=FE_OFN1718_FE_DBTN71_n4217
+ B1=LLR_sum[4][3][11] B2=FE_OFN1846_n5509 C1=LLR_sum[5][3][11]
+ C2=FE_OFN1484_n1442
XU1546 ND2S $PINS O=n5061 I1=n5060 I2=n5059
XU1547 ND2S $PINS O=n5222 I1=n5221 I2=n5220
XU1548 ND2 $PINS O=n4621 I1=n4620 I2=n4619
XU1549 ND2P $PINS O=n4782 I1=n4781 I2=n4780
XU1550 ND2P $PINS O=n5228 I1=n5227 I2=n5226
XU1551 ND2 $PINS O=n5067 I1=n5066 I2=n5065
XU1552 ND2S $PINS O=n4627 I1=n4626 I2=n4625
XU1553 ND2S $PINS O=n4788 I1=n4787 I2=n4786
XU1554 ND2S $PINS O=n5242 I1=n5241 I2=n5240
XU1555 ND2S $PINS O=n4802 I1=n4801 I2=n4800
XU1556 ND2S $PINS O=n5081 I1=n5080 I2=n5079
XU1557 ND2P $PINS O=n5075 I1=n5074 I2=n5073
XU1558 ND2 $PINS O=n4641 I1=n4640 I2=n4639
XU1559 ND2S $PINS O=n4635 I1=n4634 I2=n4633
XU1560 ND2 $PINS O=n5236 I1=n5235 I2=n5234
XU1561 ND2S $PINS O=n4796 I1=n4795 I2=n4794
XU1562 XOR3S $PINS O=sub_0_root_sub_0_root_add_184/A[11] I1=N347
+ I2=FE_OFN2050_N325 I3=add_1_root_sub_0_root_add_184/carry[11]
XU1563 XNR3 $PINS O=N711 I1=FE_OFN2158_FE_DBTN84_n2 I2=N347
+ I3=sub_0_root_sub_182_3/carry[11]
XU1564 XNR3 $PINS O=N1057 I1=FE_DBTN83_n3 I2=N347
+ I3=sub_0_root_sub_185_2/carry[11]
XU1565 MAO222S $PINS O=n3813 A1=FE_OFN2055_N357
+ B1=add_0_root_add_183_2/carry[1] C1=N811
XU1566 XOR3 $PINS O=n1444 I1=FE_OFN2049_N325 I2=FE_OFN2051_N336
+ I3=add_1_root_add_183_2/carry[4]
XU1567 ND2S $PINS O=n1544 I1=N355 I2=n3629
XU1568 ND2S $PINS O=n1542 I1=N356 I2=n3628
XU1569 ND2S $PINS O=n1545 I1=FE_OFN2053_N355 I2=n3633
XU1570 ND2S $PINS O=n1540 I1=FE_OFN2051_N336 I2=n3637
XU1571 ND2S $PINS O=n1541 I1=N337 I2=n3636
XU1572 ND2S $PINS O=n1543 I1=FE_OFN2054_N356 I2=n3632
XU1573 ND3 $PINS O=N562 I1=n1445 I2=n1015 I3=n1016
XU1574 AOI12HS $PINS O=n1445 A1=n5437 B1=backward_sum[1][7][2] B2=FE_OFN5668_n
XU1575 ND3 $PINS O=N495 I1=n1446 I2=n1216 I3=n1217
XU1576 AOI12HS $PINS O=n1446 A1=n5378 B1=backward_sum[1][2][9]
+ B2=FE_OFN1618_FE_DBTN86_n985
XU1577 ND3 $PINS O=N496 I1=n1447 I2=n1213 I3=n1214
XU1578 AOI12HS $PINS O=n1447 A1=n5379 B1=backward_sum[1][2][8]
+ B2=FE_OFN1629_FE_DBTN86_n985
XU1579 ND3 $PINS O=N561 I1=n1448 I2=n1018 I3=n1019
XU1580 AOI12HS $PINS O=n1448 A1=n5436 B1=backward_sum[1][7][3]
+ B2=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985
XU1581 ND3 $PINS O=N560 I1=n1449 I2=n1021 I3=n1022
XU1582 AOI12HS $PINS O=n1449 A1=n5435 B1=backward_sum[1][7][4] B2=FE_OFN5550_n
XU1583 XNR3S $PINS O=n1557 I1=N697 I2=FE_OFN2053_N355 I3=n3975
XU1584 XNR3S $PINS O=n1553 I1=sub_0_root_sub_0_root_add_184/A[4]
+ I2=FE_OFN2052_N336 I3=n3923
XU1585 XOR3S $PINS O=n4205 I1=n1444 I2=N354 I3=n3724
XU1586 XNR3S $PINS O=n1551 I1=N355 I2=N1043 I3=n3771
XU1587 XNR3S $PINS O=n1554 I1=N696 I2=FE_OFN2054_N356 I3=n4010
XU1588 XNR3S $PINS O=n1552 I1=sub_0_root_sub_0_root_add_184/A[3]
+ I2=FE_OFN2051_N336 I3=n3974
XU1589 XNR3S $PINS O=n1550 I1=FE_OFN2054_N356 I2=N1042 I3=n3807
XU1590 AO112S $PINS O=N368 A1=n3993 B1=n3992 C1=forward_sum[5][0][9]
+ C2=FE_OFN1516_n1442
XU1591 OA22S $PINS O=n1555 A1=FE_OFN1921_n5509 A2=n3748 B1=FE_DBTN86_n985
+ B2=n3747
XU1592 OA22S $PINS O=n1548 A1=FE_OFN1921_n5509 A2=n3761 B1=FE_DBTN86_n985
+ B2=n3760
XU1593 OA22S $PINS O=n1556 A1=n5509 A2=n3649 B1=FE_OFN1450_n985 B2=n3648
XU1594 OA22S $PINS O=n1549 A1=n5509 A2=n3662 B1=FE_OFN1450_n985 B2=n3661
XU1595 XOR3S $PINS O=n1558 I1=N811 I2=N357 I3=add_0_root_add_183_2/carry[1]
XU1596 XOR3S $PINS O=n4253 I1=sub_0_root_sub_0_root_add_184/A[1] I2=N338
+ I3=n1500
XU1597 MUX2S $PINS O=n2848 S=FE_OFN2088_n1515
+ A=FE_OFN913_branch_metrics_4__3__7 B=FE_OFN2176_N1053
XU1598 MUX2S $PINS O=n2812 S=FE_OFN2089_n1515 A=branch_metrics[4][0][7]
+ B=FE_OFN2188_N707
XU1599 MUX2S $PINS O=n2800 S=FE_OFN2099_n1516 A=branch_metrics[3][3][7]
+ B=FE_OFN2176_N1053
XU1600 MUX2S $PINS O=n2764 S=FE_OFN2101_n1516 A=branch_metrics[3][0][7] B=N707
XU1601 MUX2S $PINS O=n2467 S=FE_OFN1935_n1525 A=backward_metrics[3][3][4]
+ B=n1461
XU1602 MUX2S $PINS O=n2468 S=FE_OFN1938_n1525 A=backward_metrics[3][3][3]
+ B=n1471
XU1603 MUX2S $PINS O=n2613 S=FE_OFN1767_n1523 A=backward_metrics[6][3][2]
+ B=n1460
XU1604 MUX2S $PINS O=n2565 S=FE_OFN1929_n1524 A=backward_metrics[5][3][2]
+ B=n1460
XU1605 MUX2S $PINS O=n2517 S=FE_OFN1996_n1531 A=backward_metrics[4][3][2]
+ B=n1460
XU1606 MUX2S $PINS O=n2469 S=FE_OFN1938_n1525 A=backward_metrics[3][3][2]
+ B=n1460
XU1607 MUX2S $PINS O=n2421 S=FE_OFN2010_n1532 A=backward_metrics[2][3][2]
+ B=n1460
XU1608 MUX2S $PINS O=n2540 S=FE_OFN1931_n1524
+ A=FE_OFN1222_backward_metrics_5__1__3 B=n1467
XU1609 MUX2S $PINS O=n2444 S=FE_OFN1937_n1525
+ A=FE_OFN1126_backward_metrics_3__1__3 B=n1467
XU1610 MUX2S $PINS O=n2553 S=FE_OFN1929_n1524
+ A=FE_OFN1235_backward_metrics_5__2__2 B=n1459
XU1611 MUX2S $PINS O=n2505 S=FE_OFN1996_n1531 A=backward_metrics[4][2][2]
+ B=n1459
XU1612 MUX2S $PINS O=n2409 S=FE_OFN2010_n1532 A=backward_metrics[2][2][2]
+ B=n1459
XU1613 MUX2S $PINS O=n2589 S=FE_OFN1771_n1523
+ A=FE_OFN1260_backward_metrics_6__1__2 B=n1458
XU1614 MUX2S $PINS O=n2541 S=FE_OFN1930_n1524 A=backward_metrics[5][1][2]
+ B=n1458
XU1615 MUX2S $PINS O=n2445 S=FE_OFN1940_n1525
+ A=FE_OFN1127_backward_metrics_3__1__2 B=n1458
XU1616 MUX2S $PINS O=n2397 S=FE_OFN2012_n1532 A=backward_metrics[2][1][2]
+ B=n1458
XU1617 MUX2S $PINS O=n2349 S=FE_OFN1951_n1526 A=backward_metrics[1][1][2]
+ B=n1458
XU1618 MUX2S $PINS O=n2361 S=FE_OFN1946_n1526 A=backward_metrics[1][2][2]
+ B=n1459
XU1619 MUX2S $PINS O=n2373 S=FE_OFN1950_n1526 A=backward_metrics[1][3][2]
+ B=n1460
XU1620 MUX2S $PINS O=n2420 S=FE_OFN2008_n1532
+ A=FE_OFN1102_backward_metrics_2__3__3 B=n1471
XU1621 MUX2S $PINS O=n2372 S=FE_OFN1950_n1526
+ A=FE_OFN1054_backward_metrics_1__3__3 B=n1471
XU1622 MUX2S $PINS O=n2419 S=FE_OFN2008_n1532 A=backward_metrics[2][3][4]
+ B=n1461
XU1623 MUX2S $PINS O=n2466 S=FE_OFN1935_n1525 A=backward_metrics[3][3][5]
+ B=n1474
XU1624 MUX2S $PINS O=n2418 S=FE_OFN2008_n1532 A=backward_metrics[2][3][5]
+ B=n1474
XU1625 MUX2S $PINS O=n2612 S=FE_OFN1764_n1523 A=backward_metrics[6][3][3]
+ B=n1471
XU1626 MUX2S $PINS O=n2600 S=FE_OFN1764_n1523 A=backward_metrics[6][2][3]
+ B=n1468
XU1627 MUX2S $PINS O=n2588 S=FE_OFN1770_n1523
+ A=FE_OFN1259_backward_metrics_6__1__3 B=n1467
XU1628 MUX2S $PINS O=n2601 S=FE_OFN1767_n1523 A=backward_metrics[6][2][2]
+ B=n1459
XU1629 MUX2S $PINS O=n2886 S=FE_OFN2078_n1514
+ A=FE_OFN950_branch_metrics_5__2__5 B=FE_OFN2167_N935
XU1630 MUX2S $PINS O=n2885 S=FE_OFN2078_n1514
+ A=FE_OFN949_branch_metrics_5__2__6 B=FE_OFN2168_N936
XU1631 MUX2S $PINS O=n2838 S=FE_OFN2089_n1515
+ A=FE_OFN903_branch_metrics_4__2__5 B=FE_OFN2167_N935
XU1632 MUX2S $PINS O=n2837 S=FE_OFN2089_n1515 A=branch_metrics[4][2][6]
+ B=FE_OFN2168_N936
XU1633 MUX2S $PINS O=n2790 S=FE_OFN2101_n1516 A=branch_metrics[3][2][5] B=N935
XU1634 MUX2S $PINS O=n2789 S=FE_OFN2101_n1516 A=branch_metrics[3][2][6] B=N936
XU1635 MUX2S $PINS O=n2742 S=FE_OFN2112_n1517 A=branch_metrics[2][2][5]
+ B=FE_OFN2167_N935
XU1636 MUX2S $PINS O=n2694 S=FE_OFN2118_n1518 A=branch_metrics[1][2][5]
+ B=FE_OFN2167_N935
XU1637 MUX2S $PINS O=n2874 S=FE_OFN2070_n1514
+ A=FE_OFN939_branch_metrics_5__1__5 B=FE_OFN2159_N820
XU1638 MUX2S $PINS O=n2826 S=FE_OFN2088_n1515 A=branch_metrics[4][1][5]
+ B=FE_OFN2159_N820
XU1639 MUX2S $PINS O=n2778 S=FE_OFN2098_n1516 A=branch_metrics[3][1][5]
+ B=FE_OFN2159_N820
XU1640 MUX2S $PINS O=n2777 S=FE_OFN2100_n1516
+ A=FE_OFN842_branch_metrics_3__1__6 B=FE_OFN2160_N821
XU1641 MUX2S $PINS O=n2730 S=FE_OFN2109_n1517 A=branch_metrics[2][1][5]
+ B=FE_OFN2159_N820
XU1642 MUX2S $PINS O=n2682 S=FE_OFN2115_n1518 A=branch_metrics[1][1][5]
+ B=FE_OFN2159_N820
XU1643 MUX2S $PINS O=n2946 S=FE_OFN2150_n4223 A=backward_sum[0][3][5]
+ B=FE_OFN2174_N1051
XU1644 MUX2S $PINS O=n2898 S=FE_OFN2070_n1514
+ A=FE_OFN962_branch_metrics_5__3__5 B=FE_OFN2174_N1051
XU1645 MUX2S $PINS O=n2897 S=FE_OFN2076_n1514 A=branch_metrics[5][3][6]
+ B=FE_OFN2175_N1052
XU1646 MUX2S $PINS O=n2862 S=FE_OFN2078_n1514
+ A=FE_OFN927_branch_metrics_5__0__5 B=FE_OFN2185_N705
XU1647 MUX2S $PINS O=n2861 S=FE_OFN2078_n1514
+ A=FE_OFN926_branch_metrics_5__0__6 B=FE_OFN2187_N706
XU1648 MUX2S $PINS O=n2850 S=FE_OFN2088_n1515 A=branch_metrics[4][3][5]
+ B=FE_OFN2174_N1051
XU1649 MUX2S $PINS O=n2849 S=FE_OFN2088_n1515
+ A=FE_OFN914_branch_metrics_4__3__6 B=FE_OFN2175_N1052
XU1650 MUX2S $PINS O=n2814 S=FE_OFN2089_n1515 A=branch_metrics[4][0][5]
+ B=FE_OFN2185_N705
XU1651 MUX2S $PINS O=n2813 S=FE_OFN2089_n1515 A=branch_metrics[4][0][6]
+ B=FE_OFN2187_N706
XU1652 MUX2S $PINS O=n2802 S=FE_OFN2098_n1516
+ A=FE_OFN867_branch_metrics_3__3__5 B=FE_OFN2174_N1051
XU1653 MUX2S $PINS O=n2801 S=FE_OFN2100_n1516 A=branch_metrics[3][3][6]
+ B=FE_OFN2175_N1052
XU1654 MUX2S $PINS O=n2766 S=FE_OFN2101_n1516 A=branch_metrics[3][0][5] B=N705
XU1655 MUX2S $PINS O=n2765 S=FE_OFN2101_n1516
+ A=FE_OFN830_branch_metrics_3__0__6 B=N706
XU1656 MUX2S $PINS O=n2754 S=FE_OFN2109_n1517 A=branch_metrics[2][3][5]
+ B=FE_OFN2174_N1051
XU1657 MUX2S $PINS O=n2753 S=FE_OFN2109_n1517 A=branch_metrics[2][3][6]
+ B=FE_OFN2175_N1052
XU1658 MUX2S $PINS O=n2718 S=FE_OFN2112_n1517 A=branch_metrics[2][0][5]
+ B=FE_OFN2185_N705
XU1659 MUX2S $PINS O=n2717 S=FE_OFN2112_n1517
+ A=FE_OFN782_branch_metrics_2__0__6 B=FE_OFN2187_N706
XU1660 MUX2S $PINS O=n2706 S=FE_OFN2115_n1518 A=branch_metrics[1][3][5]
+ B=FE_OFN2174_N1051
XU1661 MUX2S $PINS O=n2705 S=FE_OFN2115_n1518
+ A=FE_OFN770_branch_metrics_1__3__6 B=FE_OFN2175_N1052
XU1662 MUX2S $PINS O=n2670 S=FE_OFN2118_n1518 A=branch_metrics[1][0][5]
+ B=FE_OFN2185_N705
XU1663 MUX2S $PINS O=n2669 S=FE_OFN2118_n1518
+ A=FE_OFN734_branch_metrics_1__0__6 B=FE_OFN2187_N706
XU1664 MUX2S $PINS O=n2531 S=FE_OFN1930_n1524 A=backward_metrics[5][0][0]
+ B=n4415
XU1665 MUX2S $PINS O=n2483 S=FE_OFN2000_n1531 A=backward_metrics[4][0][0]
+ B=n4415
XU1666 MUX2S $PINS O=n2435 S=FE_OFN1940_n1525 A=backward_metrics[3][0][0]
+ B=n4415
XU1667 MUX2S $PINS O=n2339 S=FE_OFN1951_n1526 A=backward_metrics[1][0][0]
+ B=n4415
XU1668 MUX2S $PINS O=n2555 S=FE_OFN1929_n1524 A=backward_metrics[5][2][0]
+ B=n4426
XU1669 MUX2S $PINS O=n2507 S=FE_OFN1996_n1531 A=backward_metrics[4][2][0]
+ B=n4426
XU1670 MUX2S $PINS O=n2459 S=FE_OFN1938_n1525 A=backward_metrics[3][2][0]
+ B=n4426
XU1671 MUX2S $PINS O=n2363 S=FE_OFN1950_n1526 A=backward_metrics[1][2][0]
+ B=n4426
XU1672 MUX2S $PINS O=n2543 S=FE_OFN1930_n1524 A=backward_metrics[5][1][0]
+ B=n4425
XU1673 MUX2S $PINS O=n2495 S=FE_OFN2000_n1531 A=backward_metrics[4][1][0]
+ B=n4425
XU1674 MUX2S $PINS O=n2447 S=FE_OFN1940_n1525 A=backward_metrics[3][1][0]
+ B=n4425
XU1675 MUX2S $PINS O=n2351 S=FE_OFN1951_n1526 A=backward_metrics[1][1][0]
+ B=n4425
XU1676 MUX2S $PINS O=n2567 S=FE_OFN1929_n1524 A=backward_metrics[5][3][0]
+ B=n4428
XU1677 MUX2S $PINS O=n2519 S=FE_OFN1996_n1531
+ A=FE_OFN1201_backward_metrics_4__3__0 B=n4428
XU1678 MUX2S $PINS O=n2471 S=FE_OFN1938_n1525 A=backward_metrics[3][3][0]
+ B=n4428
XU1679 MUX2S $PINS O=n2375 S=FE_OFN1950_n1526 A=backward_metrics[1][3][0]
+ B=n4428
XU1680 MUX2S $PINS O=n2615 S=FE_OFN1767_n1523 A=backward_metrics[6][3][0]
+ B=n4428
XU1681 MUX2S $PINS O=n2387 S=FE_OFN2012_n1532 A=backward_metrics[2][0][0]
+ B=n4415
XU1682 MUX2S $PINS O=n2411 S=FE_OFN2010_n1532 A=backward_metrics[2][2][0]
+ B=n4426
XU1683 MUX2S $PINS O=n2591 S=FE_OFN1771_n1523 A=backward_metrics[6][1][0]
+ B=n4425
XU1684 MUX2S $PINS O=n2399 S=FE_OFN2012_n1532 A=backward_metrics[2][1][0]
+ B=n4425
XU1685 MUX2S $PINS O=n2423 S=FE_OFN2010_n1532 A=backward_metrics[2][3][0]
+ B=n4428
XU1686 MUX2S $PINS O=n2566 S=FE_OFN1929_n1524 A=backward_metrics[5][3][1]
+ B=n4429
XU1687 MUX2S $PINS O=n2518 S=FE_OFN1996_n1531 A=backward_metrics[4][3][1]
+ B=n4429
XU1688 MUX2S $PINS O=n2470 S=FE_OFN1938_n1525 A=backward_metrics[3][3][1]
+ B=n4429
XU1689 MUX2S $PINS O=n2422 S=FE_OFN2010_n1532 A=backward_metrics[2][3][1]
+ B=n4429
XU1690 MUX2S $PINS O=n2554 S=FE_OFN1929_n1524
+ A=FE_OFN1236_backward_metrics_5__2__1 B=n4430
XU1691 MUX2 $PINS O=n2506 S=FE_OFN1996_n1531
+ A=FE_OFN1188_backward_metrics_4__2__1 B=n4430
XU1692 MUX2S $PINS O=n2458 S=FE_OFN1938_n1525 A=backward_metrics[3][2][1]
+ B=n4430
XU1693 MUX2S $PINS O=n2410 S=FE_OFN2010_n1532 A=backward_metrics[2][2][1]
+ B=n4430
XU1694 MUX2S $PINS O=n2529 S=FE_OFN1930_n1524 A=backward_metrics[5][0][2]
+ B=n4413
XU1695 MUX2S $PINS O=n2481 S=FE_OFN2000_n1531
+ A=FE_OFN1163_backward_metrics_4__0__2 B=n4413
XU1696 MUX2S $PINS O=n2385 S=FE_OFN2012_n1532 A=backward_metrics[2][0][2]
+ B=n4413
XU1697 MUX2S $PINS O=n2542 S=FE_OFN1930_n1524 A=backward_metrics[5][1][1]
+ B=n4427
XU1698 MUX2S $PINS O=n2494 S=FE_OFN2000_n1531 A=backward_metrics[4][1][1]
+ B=n4427
XU1699 MUX2S $PINS O=n2446 S=FE_OFN1940_n1525 A=backward_metrics[3][1][1]
+ B=n4427
XU1700 MUX2S $PINS O=n2398 S=FE_OFN2012_n1532 A=backward_metrics[2][1][1]
+ B=n4427
XU1701 MUX2S $PINS O=n2350 S=FE_OFN1951_n1526 A=backward_metrics[1][1][1]
+ B=n4427
XU1702 MUX2S $PINS O=n2530 S=FE_OFN1930_n1524 A=backward_metrics[5][0][1]
+ B=n4414
XU1703 MUX2S $PINS O=n2482 S=FE_OFN2000_n1531 A=backward_metrics[4][0][1]
+ B=n4414
XU1704 MUX2S $PINS O=n2434 S=FE_OFN1940_n1525 A=backward_metrics[3][0][1]
+ B=n4414
XU1705 MUX2S $PINS O=n2386 S=FE_OFN2012_n1532 A=backward_metrics[2][0][1]
+ B=n4414
XU1706 MUX2S $PINS O=n2338 S=FE_OFN1951_n1526 A=backward_metrics[1][0][1]
+ B=n4414
XU1707 MUX2S $PINS O=n2337 S=FE_OFN1951_n1526
+ A=FE_OFN1019_backward_metrics_1__0__2 B=n4413
XU1708 MUX2S $PINS O=n2362 S=FE_OFN1950_n1526 A=backward_metrics[1][2][1]
+ B=n4430
XU1709 MUX2S $PINS O=n2374 S=FE_OFN1950_n1526
+ A=FE_OFN1056_backward_metrics_1__3__1 B=n4429
XU1710 MUX2S $PINS O=n2603 S=FE_OFN1767_n1523 A=backward_metrics[6][2][0]
+ B=n4426
XU1711 MUX2S $PINS O=n2579 S=FE_OFN1771_n1523
+ A=FE_OFN1250_backward_metrics_6__0__0 B=n4415
XU1712 MUX2S $PINS O=n2614 S=FE_OFN1767_n1523 A=backward_metrics[6][3][1]
+ B=n4429
XU1713 MUX2S $PINS O=n2602 S=FE_OFN1767_n1523 A=backward_metrics[6][2][1]
+ B=n4430
XU1714 MUX2S $PINS O=n2576 S=FE_OFN1770_n1523 A=backward_metrics[6][0][3]
+ B=n4412
XU1715 MUX2S $PINS O=n2577 S=FE_OFN1771_n1523 A=backward_metrics[6][0][2]
+ B=n4413
XU1716 MUX2S $PINS O=n2590 S=FE_OFN1771_n1523 A=backward_metrics[6][1][1]
+ B=n4427
XU1717 MUX2S $PINS O=n2578 S=FE_OFN1771_n1523 A=backward_metrics[6][0][1]
+ B=n4414
XU1718 ND2S $PINS O=n4013 I1=forward_sum[0][5][3] I2=FE_OFN1812_n5419
XU1719 MUX2S $PINS O=n2660 S=FE_OFN2127_n1519 A=forward_sum[0][5][3] B=n1551
XU1720 MUX2S $PINS O=n2327 S=FE_OFN1786_n1527 A=forward_metrics[6][3][0]
+ B=n4251
XU1721 MUX2S $PINS O=n2303 S=FE_OFN1787_n1527 A=forward_metrics[6][1][0]
+ B=n4238
XU1722 MUX2S $PINS O=n2291 S=FE_OFN1787_n1527 A=forward_metrics[6][0][0]
+ B=n4204
XU1723 MUX2S $PINS O=n2273 S=FE_OFN1959_n1528 A=forward_metrics[5][3][6]
+ B=n4245
XU1724 MUX2S $PINS O=n2225 S=FE_OFN2014_n1533 A=forward_metrics[4][3][6]
+ B=n4245
XU1725 MUX2S $PINS O=n2249 S=FE_OFN1959_n1528 A=forward_metrics[5][1][6]
+ B=n4232
XU1726 MUX2S $PINS O=n2201 S=FE_OFN2020_n1533 A=forward_metrics[4][1][6]
+ B=n4232
XU1727 MUX2S $PINS O=n2261 S=FE_OFN1959_n1528 A=forward_metrics[5][2][6]
+ B=n4215
XU1728 MUX2S $PINS O=n2213 S=FE_OFN2014_n1533 A=forward_metrics[4][2][6]
+ B=n4215
XU1729 MUX2S $PINS O=n2322 S=FE_OFN1781_n1527 A=forward_metrics[6][3][5]
+ B=n4246
XU1730 MUX2S $PINS O=n2274 S=FE_OFN1961_n1528 A=forward_metrics[5][3][5]
+ B=n4246
XU1731 MUX2S $PINS O=n2226 S=FE_OFN2021_n1533 A=forward_metrics[4][3][5]
+ B=n4246
XU1732 MUX2S $PINS O=n2178 S=FE_OFN1973_n1529 A=forward_metrics[3][3][5]
+ B=n4246
XU1733 MUX2S $PINS O=n2323 S=FE_OFN1783_n1527 A=forward_metrics[6][3][4]
+ B=n4247
XU1734 MUX2S $PINS O=n2275 S=FE_OFN1963_n1528 A=forward_metrics[5][3][4]
+ B=n4247
XU1735 MUX2S $PINS O=n2227 S=FE_OFN2022_n1533 A=forward_metrics[4][3][4]
+ B=n4247
XU1736 MUX2S $PINS O=n2179 S=FE_OFN1973_n1529 A=forward_metrics[3][3][4]
+ B=n4247
XU1737 MUX2S $PINS O=n2250 S=FE_OFN1962_n1528 A=forward_metrics[5][1][5]
+ B=n4233
XU1738 MUX2S $PINS O=n2202 S=FE_OFN2021_n1533 A=forward_metrics[4][1][5]
+ B=n4233
XU1739 MUX2S $PINS O=n2189 S=FE_OFN2020_n1533 A=forward_metrics[4][0][6]
+ B=n4198
XU1740 MUX2S $PINS O=n2262 S=FE_OFN1962_n1528 A=forward_metrics[5][2][5]
+ B=n4208
XU1741 MUX2S $PINS O=n2214 S=FE_OFN2021_n1533 A=forward_metrics[4][2][5]
+ B=n4208
XU1742 MUX2S $PINS O=n2299 S=FE_OFN1781_n1527 A=forward_metrics[6][1][4]
+ B=n4234
XU1743 MUX2S $PINS O=n2251 S=FE_OFN1961_n1528 A=forward_metrics[5][1][4]
+ B=n4234
XU1744 MUX2S $PINS O=n2203 S=FE_OFN2022_n1533 A=forward_metrics[4][1][4]
+ B=n4234
XU1745 MUX2S $PINS O=n2155 S=FE_OFN1973_n1529 A=forward_metrics[3][1][4]
+ B=n4234
XU1746 MUX2S $PINS O=n2311 S=FE_OFN1781_n1527 A=forward_metrics[6][2][4]
+ B=n4209
XU1747 MUX2S $PINS O=n2263 S=FE_OFN1961_n1528 A=forward_metrics[5][2][4]
+ B=n4209
XU1748 MUX2S $PINS O=n2215 S=FE_OFN2022_n1533 A=forward_metrics[4][2][4]
+ B=n4209
XU1749 MUX2S $PINS O=n2167 S=FE_OFN1973_n1529 A=forward_metrics[3][2][4]
+ B=n4209
XU1750 MUX2S $PINS O=n2324 S=FE_OFN1784_n1527 A=forward_metrics[6][3][3]
+ B=n4248
XU1751 MUX2S $PINS O=n2276 S=FE_OFN1963_n1528 A=forward_metrics[5][3][3]
+ B=n4248
XU1752 MUX2S $PINS O=n2228 S=FE_OFN2024_n1533 A=forward_metrics[4][3][3]
+ B=n4248
XU1753 MUX2S $PINS O=n2180 S=FE_OFN1975_n1529 A=forward_metrics[3][3][3]
+ B=n4248
XU1754 MUX2S $PINS O=n2132 S=FE_OFN2037_n1534 A=forward_metrics[2][3][3]
+ B=n4248
XU1755 MUX2S $PINS O=n2325 S=FE_OFN1785_n1527 A=forward_metrics[6][3][2]
+ B=n4249
XU1756 MUX2S $PINS O=n2277 S=FE_OFN1964_n1528 A=forward_metrics[5][3][2]
+ B=n4249
XU1757 MUX2S $PINS O=n2229 S=FE_OFN2023_n1533 A=forward_metrics[4][3][2]
+ B=n4249
XU1758 MUX2S $PINS O=n2181 S=FE_OFN1976_n1529 A=forward_metrics[3][3][2]
+ B=n4249
XU1759 MUX2S $PINS O=n2133 S=FE_OFN2038_n1534 A=forward_metrics[2][3][2]
+ B=n4249
XU1760 MUX2S $PINS O=n2300 S=FE_OFN1783_n1527 A=forward_metrics[6][1][3]
+ B=n4235
XU1761 MUX2S $PINS O=n2252 S=FE_OFN1963_n1528 A=forward_metrics[5][1][3]
+ B=n4235
XU1762 MUX2S $PINS O=n2204 S=FE_OFN2022_n1533 A=forward_metrics[4][1][3]
+ B=n4235
XU1763 MUX2S $PINS O=n2156 S=FE_OFN1975_n1529 A=forward_metrics[3][1][3]
+ B=n4235
XU1764 MUX2S $PINS O=n2190 S=FE_OFN2021_n1533 A=forward_metrics[4][0][5]
+ B=n4199
XU1765 MUX2S $PINS O=n2287 S=FE_OFN1781_n1527 A=forward_metrics[6][0][4]
+ B=n4200
XU1766 MUX2S $PINS O=n2239 S=FE_OFN1961_n1528 A=forward_metrics[5][0][4]
+ B=n4200
XU1767 MUX2S $PINS O=n2191 S=FE_OFN2021_n1533 A=forward_metrics[4][0][4]
+ B=n4200
XU1768 MUX2S $PINS O=n2143 S=FE_OFN1973_n1529 A=forward_metrics[3][0][4]
+ B=n4200
XU1769 MUX2S $PINS O=n2312 S=FE_OFN1784_n1527 A=forward_metrics[6][2][3]
+ B=n4210
XU1770 MUX2S $PINS O=n2264 S=FE_OFN1963_n1528 A=forward_metrics[5][2][3]
+ B=n4210
XU1771 MUX2S $PINS O=n2216 S=FE_OFN2024_n1533 A=forward_metrics[4][2][3]
+ B=n4210
XU1772 MUX2S $PINS O=n2168 S=FE_OFN1975_n1529 A=forward_metrics[3][2][3]
+ B=n4210
XU1773 MUX2S $PINS O=n2301 S=FE_OFN1783_n1527 A=forward_metrics[6][1][2]
+ B=n4236
XU1774 MUX2S $PINS O=n2253 S=FE_OFN1964_n1528 A=forward_metrics[5][1][2]
+ B=n4236
XU1775 MUX2S $PINS O=n2205 S=FE_OFN2023_n1533 A=forward_metrics[4][1][2]
+ B=n4236
XU1776 MUX2S $PINS O=n2157 S=FE_OFN1975_n1529 A=forward_metrics[3][1][2]
+ B=n4236
XU1777 MUX2S $PINS O=n2109 S=FE_OFN2035_n1534 A=forward_metrics[2][1][2]
+ B=n4236
XU1778 MUX2S $PINS O=n2313 S=FE_OFN1785_n1527 A=forward_metrics[6][2][2]
+ B=n4211
XU1779 MUX2S $PINS O=n2265 S=FE_OFN1964_n1528 A=forward_metrics[5][2][2]
+ B=n4211
XU1780 MUX2S $PINS O=n2217 S=FE_OFN2023_n1533 A=forward_metrics[4][2][2]
+ B=n4211
XU1781 MUX2S $PINS O=n2169 S=FE_OFN1976_n1529 A=forward_metrics[3][2][2]
+ B=n4211
XU1782 MUX2S $PINS O=n2121 S=FE_OFN2038_n1534 A=forward_metrics[2][2][2]
+ B=n4211
XU1783 MUX2S $PINS O=n2326 S=FE_OFN1786_n1527 A=forward_metrics[6][3][1]
+ B=n4250
XU1784 MUX2S $PINS O=n2278 S=FE_OFN1965_n1528 A=forward_metrics[5][3][1]
+ B=n4250
XU1785 MUX2S $PINS O=n2230 S=FE_OFN2026_n1533 A=forward_metrics[4][3][1]
+ B=n4250
XU1786 MUX2S $PINS O=n2182 S=FE_OFN1977_n1529 A=forward_metrics[3][3][1]
+ B=n4250
XU1787 MUX2S $PINS O=n2134 S=FE_OFN2039_n1534 A=forward_metrics[2][3][1]
+ B=n4250
XU1788 MUX2S $PINS O=n2086 S=FE_OFN1991_n1530 A=forward_metrics[1][3][1]
+ B=n4250
XU1789 MUX2S $PINS O=n2302 S=FE_OFN1787_n1527 A=forward_metrics[6][1][1]
+ B=n4237
XU1790 MUX2S $PINS O=n2254 S=FE_OFN1965_n1528 A=forward_metrics[5][1][1]
+ B=n4237
XU1791 MUX2S $PINS O=n2206 S=FE_OFN2026_n1533 A=forward_metrics[4][1][1]
+ B=n4237
XU1792 MUX2S $PINS O=n2158 S=FE_OFN1978_n1529 A=forward_metrics[3][1][1]
+ B=n4237
XU1793 MUX2S $PINS O=n2110 S=FE_OFN2040_n1534 A=forward_metrics[2][1][1]
+ B=n4237
XU1794 MUX2S $PINS O=n2288 S=FE_OFN1783_n1527 A=forward_metrics[6][0][3]
+ B=n4201
XU1795 MUX2S $PINS O=n2240 S=FE_OFN1963_n1528 A=forward_metrics[5][0][3]
+ B=n4201
XU1796 MUX2S $PINS O=n2192 S=FE_OFN2022_n1533 A=forward_metrics[4][0][3]
+ B=n4201
XU1797 MUX2S $PINS O=n2144 S=FE_OFN1975_n1529 A=forward_metrics[3][0][3]
+ B=n4201
XU1798 MUX2S $PINS O=n2289 S=FE_OFN1785_n1527 A=forward_metrics[6][0][2]
+ B=n4202
XU1799 MUX2S $PINS O=n2241 S=FE_OFN1964_n1528 A=forward_metrics[5][0][2]
+ B=n4202
XU1800 MUX2S $PINS O=n2193 S=FE_OFN2023_n1533 A=forward_metrics[4][0][2]
+ B=n4202
XU1801 MUX2S $PINS O=n2145 S=FE_OFN1976_n1529 A=forward_metrics[3][0][2]
+ B=n4202
XU1802 MUX2S $PINS O=n2097 S=FE_OFN2038_n1534 A=forward_metrics[2][0][2]
+ B=n4202
XU1803 MUX2S $PINS O=n2314 S=FE_OFN1786_n1527 A=forward_metrics[6][2][1]
+ B=n4212
XU1804 MUX2S $PINS O=n2266 S=FE_OFN1965_n1528 A=forward_metrics[5][2][1]
+ B=n4212
XU1805 MUX2S $PINS O=n2218 S=FE_OFN2027_n1533 A=forward_metrics[4][2][1]
+ B=n4212
XU1806 MUX2S $PINS O=n2170 S=FE_OFN1977_n1529 A=forward_metrics[3][2][1]
+ B=n4212
XU1807 MUX2S $PINS O=n2122 S=FE_OFN2039_n1534 A=forward_metrics[2][2][1]
+ B=n4212
XU1808 MUX2S $PINS O=n2074 S=FE_OFN1990_n1530 A=forward_metrics[1][2][1]
+ B=n4212
XU1809 MUX2S $PINS O=n2290 S=FE_OFN1785_n1527 A=forward_metrics[6][0][1]
+ B=n4203
XU1810 MUX2S $PINS O=n2242 S=FE_OFN1966_n1528 A=forward_metrics[5][0][1]
+ B=n4203
XU1811 MUX2S $PINS O=n2194 S=FE_OFN2027_n1533 A=forward_metrics[4][0][1]
+ B=n4203
XU1812 MUX2S $PINS O=n2146 S=FE_OFN1976_n1529 A=forward_metrics[3][0][1]
+ B=n4203
XU1813 MUX2S $PINS O=n2098 S=FE_OFN2038_n1534 A=forward_metrics[2][0][1]
+ B=n4203
XU1814 MUX2S $PINS O=n2050 S=FE_OFN1990_n1530 A=forward_metrics[1][0][1]
+ B=n4203
XU1815 MUX2S $PINS O=n2049 S=FE_OFN1991_n1530 A=forward_metrics[1][0][2]
+ B=n4202
XU1816 MUX2S $PINS O=n2096 S=FE_OFN2035_n1534 A=forward_metrics[2][0][3]
+ B=n4201
XU1817 MUX2S $PINS O=n2048 S=FE_OFN1986_n1530 A=forward_metrics[1][0][3]
+ B=n4201
XU1818 MUX2S $PINS O=n2062 S=FE_OFN1991_n1530 A=forward_metrics[1][1][1]
+ B=n4237
XU1819 MUX2S $PINS O=n2073 S=FE_OFN1991_n1530 A=forward_metrics[1][2][2]
+ B=n4211
XU1820 MUX2S $PINS O=n2061 S=FE_OFN1991_n1530 A=forward_metrics[1][1][2]
+ B=n4236
XU1821 MUX2S $PINS O=n2120 S=FE_OFN2037_n1534 A=forward_metrics[2][2][3]
+ B=n4210
XU1822 MUX2S $PINS O=n2072 S=FE_OFN1987_n1530 A=forward_metrics[1][2][3]
+ B=n4210
XU1823 MUX2S $PINS O=n2095 S=FE_OFN2036_n1534 A=forward_metrics[2][0][4]
+ B=n4200
XU1824 MUX2S $PINS O=n2047 S=FE_OFN1984_n1530 A=forward_metrics[1][0][4]
+ B=n4200
XU1825 MUX2S $PINS O=n2142 S=FE_OFN1971_n1529 A=forward_metrics[3][0][5]
+ B=n4199
XU1826 MUX2S $PINS O=n2094 S=FE_OFN2034_n1534 A=forward_metrics[2][0][5]
+ B=n4199
XU1827 MUX2S $PINS O=n2046 S=FE_OFN1984_n1530 A=forward_metrics[1][0][5]
+ B=n4199
XU1828 MUX2S $PINS O=n2108 S=FE_OFN2037_n1534 A=forward_metrics[2][1][3]
+ B=n4235
XU1829 MUX2S $PINS O=n2060 S=FE_OFN1987_n1530 A=forward_metrics[1][1][3]
+ B=n4235
XU1830 MUX2S $PINS O=n2085 S=FE_OFN1991_n1530 A=forward_metrics[1][3][2]
+ B=n4249
XU1831 MUX2S $PINS O=n2084 S=FE_OFN1987_n1530 A=forward_metrics[1][3][3]
+ B=n4248
XU1832 MUX2S $PINS O=n2119 S=FE_OFN2036_n1534 A=forward_metrics[2][2][4]
+ B=n4209
XU1833 MUX2S $PINS O=n2071 S=FE_OFN1986_n1530 A=forward_metrics[1][2][4]
+ B=n4209
XU1834 MUX2S $PINS O=n2107 S=FE_OFN2034_n1534 A=forward_metrics[2][1][4]
+ B=n4234
XU1835 MUX2S $PINS O=n2059 S=FE_OFN1986_n1530 A=forward_metrics[1][1][4]
+ B=n4234
XU1836 MUX2S $PINS O=n2166 S=FE_OFN1971_n1529 A=forward_metrics[3][2][5]
+ B=n4208
XU1837 MUX2S $PINS O=n2118 S=FE_OFN2034_n1534 A=forward_metrics[2][2][5]
+ B=n4208
XU1838 MUX2S $PINS O=n2070 S=FE_OFN1984_n1530 A=forward_metrics[1][2][5]
+ B=n4208
XU1839 MUX2S $PINS O=n2045 S=FE_OFN1985_n1530 A=forward_metrics[1][0][6]
+ B=n4198
XU1840 MUX2S $PINS O=n2154 S=FE_OFN1971_n1529 A=forward_metrics[3][1][5]
+ B=n4233
XU1841 MUX2S $PINS O=n2106 S=FE_OFN2034_n1534 A=forward_metrics[2][1][5]
+ B=n4233
XU1842 MUX2S $PINS O=n2058 S=FE_OFN1984_n1530 A=forward_metrics[1][1][5]
+ B=n4233
XU1843 MUX2S $PINS O=n2131 S=FE_OFN2035_n1534 A=forward_metrics[2][3][4]
+ B=n4247
XU1844 MUX2S $PINS O=n2083 S=FE_OFN1986_n1530 A=forward_metrics[1][3][4]
+ B=n4247
XU1845 MUX2S $PINS O=n2130 S=FE_OFN2034_n1534 A=forward_metrics[2][3][5]
+ B=n4246
XU1846 MUX2S $PINS O=n2082 S=FE_OFN1984_n1530 A=forward_metrics[1][3][5]
+ B=n4246
XU1847 MUX2S $PINS O=n2165 S=FE_OFN1971_n1529 A=forward_metrics[3][2][6]
+ B=n4215
XU1848 MUX2S $PINS O=n2153 S=FE_OFN1972_n1529 A=forward_metrics[3][1][6]
+ B=n4232
XU1849 MUX2S $PINS O=n2057 S=FE_OFN1985_n1530 A=forward_metrics[1][1][6]
+ B=n4232
XU1850 MUX2S $PINS O=n2177 S=FE_OFN1970_n1529 A=forward_metrics[3][3][6]
+ B=n4245
XU1851 MUX2S $PINS O=n2129 S=FE_OFN2031_n1534 A=forward_metrics[2][3][6]
+ B=n4245
XU1852 MUX2S $PINS O=n2081 S=FE_OFN1982_n1530 A=forward_metrics[1][3][6]
+ B=n4245
XU1853 MUX2S $PINS O=n2243 S=FE_OFN1966_n1528 A=forward_metrics[5][0][0]
+ B=n4204
XU1854 MUX2S $PINS O=n2195 S=FE_OFN2026_n1533 A=forward_metrics[4][0][0]
+ B=n4204
XU1855 MUX2S $PINS O=n2147 S=FE_OFN1978_n1529 A=forward_metrics[3][0][0]
+ B=n4204
XU1856 MUX2S $PINS O=n2099 S=FE_OFN2040_n1534 A=forward_metrics[2][0][0]
+ B=n4204
XU1857 MUX2S $PINS O=n2051 S=FE_OFN1990_n1530 A=forward_metrics[1][0][0]
+ B=n4204
XU1858 MUX2S $PINS O=n2255 S=FE_OFN1966_n1528 A=forward_metrics[5][1][0]
+ B=n4238
XU1859 MUX2S $PINS O=n2207 S=FE_OFN2027_n1533 A=forward_metrics[4][1][0]
+ B=n4238
XU1860 MUX2S $PINS O=n2159 S=FE_OFN1978_n1529 A=forward_metrics[3][1][0]
+ B=n4238
XU1861 MUX2S $PINS O=n2111 S=FE_OFN2040_n1534 A=forward_metrics[2][1][0]
+ B=n4238
XU1862 MUX2S $PINS O=n2063 S=FE_OFN1990_n1530 A=forward_metrics[1][1][0]
+ B=n4238
XU1863 MUX2S $PINS O=n2315 S=FE_OFN1786_n1527 A=forward_metrics[6][2][0]
+ B=n4213
XU1864 MUX2S $PINS O=n2267 S=FE_OFN1966_n1528 A=forward_metrics[5][2][0]
+ B=n4213
XU1865 MUX2S $PINS O=n2219 S=FE_OFN2026_n1533 A=forward_metrics[4][2][0]
+ B=n4213
XU1866 MUX2S $PINS O=n2171 S=FE_OFN1977_n1529 A=forward_metrics[3][2][0]
+ B=n4213
XU1867 MUX2S $PINS O=n2123 S=FE_OFN2040_n1534 A=forward_metrics[2][2][0]
+ B=n4213
XU1868 MUX2S $PINS O=n2075 S=FE_OFN1990_n1530 A=forward_metrics[1][2][0]
+ B=n4213
XU1869 MUX2S $PINS O=n2279 S=FE_OFN1966_n1528 A=forward_metrics[5][3][0]
+ B=n4251
XU1870 MUX2S $PINS O=n2231 S=FE_OFN2027_n1533 A=forward_metrics[4][3][0]
+ B=n4251
XU1871 MUX2S $PINS O=n2183 S=FE_OFN1977_n1529 A=forward_metrics[3][3][0]
+ B=n4251
XU1872 MUX2S $PINS O=n2135 S=FE_OFN2040_n1534 A=forward_metrics[2][3][0]
+ B=n4251
XU1873 MUX2S $PINS O=n2087 S=FE_OFN1990_n1530 A=forward_metrics[1][3][0]
+ B=n4251
XU1874 MUX2S $PINS O=n2948 S=FE_OFN2152_n4223 A=backward_sum[0][3][3]
+ B=FE_OFN2137_n1551
XU1875 MUX2S $PINS O=n2947 S=FE_OFN2150_n4223 A=backward_sum[0][3][4]
+ B=FE_OFN2156_n4239
XU1876 MUX2S $PINS O=n2935 S=FE_OFN2153_n4223 A=backward_sum[0][6][4] B=n1553
XU1877 MUX2S $PINS O=n2912 S=FE_OFN2153_n4223 A=backward_sum[0][4][3] B=n1557
XU1878 MUX2S $PINS O=n2911 S=FE_OFN2153_n4223 A=backward_sum[0][4][4]
+ B=FE_OFN2183_n4214
XU1879 MUX2S $PINS O=n2900 S=n1514 A=branch_metrics[5][3][3] B=FE_OFN2137_n1551
XU1880 MUX2S $PINS O=n2899 S=FE_OFN2070_n1514 A=branch_metrics[5][3][4]
+ B=FE_OFN2156_n4239
XU1881 MUX2S $PINS O=n2887 S=FE_OFN2074_n1514 A=branch_metrics[5][2][4] B=n1553
XU1882 MUX2S $PINS O=n2875 S=FE_OFN2070_n1514 A=branch_metrics[5][1][4]
+ B=FE_OFN2182_n4205
XU1883 MUX2S $PINS O=n2864 S=FE_OFN2074_n1514 A=branch_metrics[5][0][3]
+ B=FE_OFN2181_n1557
XU1884 MUX2S $PINS O=n2863 S=FE_OFN2074_n1514 A=branch_metrics[5][0][4] B=n4214
XU1885 MUX2S $PINS O=n2852 S=FE_OFN2079_n1515
+ A=FE_OFN917_branch_metrics_4__3__3 B=FE_OFN2137_n1551
XU1886 MUX2S $PINS O=n2851 S=FE_OFN2079_n1515 A=branch_metrics[4][3][4]
+ B=FE_OFN2156_n4239
XU1887 MUX2S $PINS O=n2839 S=FE_OFN2082_n1515 A=branch_metrics[4][2][4]
+ B=FE_OFN2139_n1553
XU1888 MUX2S $PINS O=n2827 S=FE_OFN2079_n1515 A=branch_metrics[4][1][4]
+ B=FE_OFN2182_n4205
XU1889 MUX2S $PINS O=n2816 S=FE_OFN2082_n1515
+ A=FE_OFN881_branch_metrics_4__0__3 B=FE_OFN2181_n1557
XU1890 MUX2S $PINS O=n2815 S=FE_OFN2082_n1515 A=branch_metrics[4][0][4]
+ B=FE_OFN2183_n4214
XU1891 MUX2S $PINS O=n2804 S=n1516 A=branch_metrics[3][3][3] B=FE_OFN2137_n1551
XU1892 MUX2S $PINS O=n2803 S=FE_OFN2098_n1516 A=branch_metrics[3][3][4]
+ B=FE_OFN2156_n4239
XU1893 MUX2S $PINS O=n2791 S=FE_OFN2097_n1516 A=branch_metrics[3][2][4] B=n1553
XU1894 MUX2S $PINS O=n2779 S=FE_OFN2098_n1516
+ A=FE_OFN844_branch_metrics_3__1__4 B=FE_OFN2182_n4205
XU1895 MUX2S $PINS O=n2768 S=FE_OFN2097_n1516
+ A=FE_OFN833_branch_metrics_3__0__3 B=FE_OFN2181_n1557
XU1896 MUX2S $PINS O=n2767 S=FE_OFN2097_n1516 A=branch_metrics[3][0][4] B=n4214
XU1897 MUX2S $PINS O=n2756 S=FE_OFN2102_n1517 A=branch_metrics[2][3][3]
+ B=FE_OFN2137_n1551
XU1898 MUX2S $PINS O=n2755 S=FE_OFN2102_n1517
+ A=FE_OFN820_branch_metrics_2__3__4 B=FE_OFN2156_n4239
XU1899 MUX2S $PINS O=n2743 S=FE_OFN2111_n1517 A=branch_metrics[2][2][4]
+ B=FE_OFN2139_n1553
XU1900 MUX2S $PINS O=n2731 S=FE_OFN2102_n1517 A=branch_metrics[2][1][4]
+ B=FE_OFN2182_n4205
XU1901 MUX2S $PINS O=n2720 S=FE_OFN2111_n1517
+ A=FE_OFN785_branch_metrics_2__0__3 B=FE_OFN2181_n1557
XU1902 MUX2S $PINS O=n2719 S=FE_OFN2111_n1517
+ A=FE_OFN784_branch_metrics_2__0__4 B=FE_OFN2183_n4214
XU1903 MUX2S $PINS O=n2708 S=FE_OFN2117_n1518
+ A=FE_OFN773_branch_metrics_1__3__3 B=FE_OFN2137_n1551
XU1904 MUX2S $PINS O=n2707 S=FE_OFN2117_n1518 A=branch_metrics[1][3][4]
+ B=FE_OFN2156_n4239
XU1905 MUX2S $PINS O=n2695 S=FE_OFN2122_n1518
+ A=FE_OFN760_branch_metrics_1__2__4 B=FE_OFN2139_n1553
XU1906 MUX2S $PINS O=n2683 S=FE_OFN2117_n1518 A=branch_metrics[1][1][4]
+ B=FE_OFN2182_n4205
XU1907 MUX2S $PINS O=n2672 S=FE_OFN2122_n1518 A=branch_metrics[1][0][3]
+ B=FE_OFN2181_n1557
XU1908 MUX2S $PINS O=n2671 S=FE_OFN2122_n1518 A=branch_metrics[1][0][4]
+ B=FE_OFN2183_n4214
XU1909 MUX2S $PINS O=n2624 S=FE_OFN2132_n1519 A=forward_sum[0][2][3]
+ B=FE_OFN2181_n1557
XU1910 ND3 $PINS O=N367 I1=n1450 I2=n3968 I3=n3967
XU1911 OA112S $PINS O=n1450 A1=n3964 B1=n5143 C1=FE_OFN1436_FE_DBTN72_n3966
+ C2=n3965
XU1912 ND2S $PINS O=n4153 I1=forward_sum[0][2][2] I2=FE_OFN1831_n5419
XU1913 ND2S $PINS O=n4190 I1=forward_sum[0][2][0] I2=FE_OFN3101_n5419
XU1914 ND2S $PINS O=n4025 I1=FE_OFN997_forward_sum_0__5__2 I2=FE_OFN1837_n5419
XU1915 ND2S $PINS O=n4219 I1=FE_OFN1009_forward_sum_0__6__0 I2=FE_OFN1813_n5419
XU1916 ND2S $PINS O=n4171 I1=forward_sum[0][1][0] I2=FE_OFN1832_n5419
XU1917 ND2S $PINS O=n4159 I1=forward_sum[0][1][1] I2=FE_OFN5577_n
XU1918 ND2S $PINS O=n4093 I1=FE_OFN999_forward_sum_0__5__0 I2=FE_OFN1813_n5419
XU1919 ND2S $PINS O=n4165 I1=forward_sum[0][2][1] I2=FE_OFN5577_n
XU1920 ND2S $PINS O=n4087 I1=forward_sum[0][6][1] I2=FE_OFN1813_n5419
XU1921 ND2S $PINS O=n4048 I1=forward_sum[0][6][2] I2=FE_OFN1837_n5419
XU1922 ND2S $PINS O=n4147 I1=FE_OFN5649_forward_sum_0__1__2 I2=FE_OFN1831_n5419
XU1923 ND2S $PINS O=n4141 I1=FE_OFN5659_forward_sum_0__2__3 I2=FE_OFN1827_n5419
XU1924 ND2S $PINS O=n4081 I1=FE_OFN998_forward_sum_0__5__1 I2=FE_OFN1813_n5419
XU1925 OA22S $PINS O=n1564 A1=n5509 A2=n3734 B1=FE_OFN1450_n985 B2=n3733
XU1926 ND3 $PINS O=n4257 I1=n1451 I2=n3957 I3=n3956
XU1927 OA112S $PINS O=n1451 A1=n3954 B1=n4946 C1=FE_OFN1436_FE_DBTN72_n3966
+ C2=n3955
XU1928 OA22S $PINS O=n1563 A1=n5509 A2=n3781 B1=FE_OFN1450_n985 B2=n3780
XU1929 MUX2S $PINS O=n2661 S=FE_OFN2130_n1519 A=FE_OFN997_forward_sum_0__5__2
+ B=n1550
XU1930 MUX2S $PINS O=n2649 S=FE_OFN2131_n1519 A=FE_OFN5649_forward_sum_0__1__2
+ B=FE_OFN515_FE_DBTN80_n9
XU1931 MUX2S $PINS O=n2662 S=FE_OFN2130_n1519 A=FE_OFN998_forward_sum_0__5__1
+ B=FE_OFN2063_FE_DBTN79_n10
XU1932 MUX2S $PINS O=n2950 S=FE_OFN2155_n4223 A=backward_sum[0][3][1]
+ B=FE_OFN2063_FE_DBTN79_n10
XU1933 MUX2S $PINS O=n2949 S=FE_OFN2154_n4223 A=backward_sum[0][3][2]
+ B=FE_OFN2136_n1550
XU1934 MUX2S $PINS O=n2937 S=FE_OFN2152_n4223 A=backward_sum[0][6][2]
+ B=FE_OFN515_FE_DBTN80_n9
XU1935 MUX2S $PINS O=n2936 S=FE_OFN2153_n4223 A=backward_sum[0][6][3] B=n1552
XU1936 MUX2S $PINS O=n2925 S=FE_OFN2154_n4223 A=backward_sum[0][1][2]
+ B=FE_OFN2143_n4207
XU1937 MUX2S $PINS O=n2924 S=FE_OFN2152_n4223 A=backward_sum[0][1][3]
+ B=FE_OFN2142_n4206
XU1938 MUX2S $PINS O=n2914 S=FE_OFN2155_n4223 A=backward_sum[0][4][1]
+ B=FE_DBTN78_n11
XU1939 MUX2S $PINS O=n2913 S=FE_OFN2152_n4223 A=backward_sum[0][4][2]
+ B=FE_OFN2140_n1554
XU1940 MUX2S $PINS O=n2902 S=FE_OFN2071_n1514 A=branch_metrics[5][3][1]
+ B=FE_DBTN79_n10
XU1941 MUX2S $PINS O=n2901 S=FE_OFN2071_n1514 A=branch_metrics[5][3][2]
+ B=FE_OFN2136_n1550
XU1942 MUX2S $PINS O=n2889 S=FE_OFN2074_n1514 A=branch_metrics[5][2][2]
+ B=FE_OFN515_FE_DBTN80_n9
XU1943 MUX2S $PINS O=n2888 S=FE_OFN2074_n1514
+ A=FE_OFN952_branch_metrics_5__2__3 B=FE_OFN2138_n1552
XU1944 MUX2S $PINS O=n2877 S=FE_OFN2071_n1514 A=branch_metrics[5][1][2]
+ B=FE_OFN2143_n4207
XU1945 MUX2S $PINS O=n2876 S=FE_OFN2070_n1514
+ A=FE_OFN941_branch_metrics_5__1__3 B=FE_OFN2142_n4206
XU1946 MUX2S $PINS O=n2866 S=FE_OFN2075_n1514 A=branch_metrics[5][0][1]
+ B=FE_OFN2064_FE_DBTN78_n11
XU1947 MUX2S $PINS O=n2865 S=FE_OFN2074_n1514 A=branch_metrics[5][0][2]
+ B=FE_OFN2140_n1554
XU1948 MUX2S $PINS O=n2854 S=FE_OFN2086_n1515
+ A=FE_OFN919_branch_metrics_4__3__1 B=FE_OFN2063_FE_DBTN79_n10
XU1949 MUX2S $PINS O=n2853 S=FE_OFN2081_n1515
+ A=FE_OFN918_branch_metrics_4__3__2 B=FE_OFN2136_n1550
XU1950 MUX2S $PINS O=n2841 S=FE_OFN2082_n1515 A=branch_metrics[4][2][2]
+ B=FE_OFN515_FE_DBTN80_n9
XU1951 MUX2S $PINS O=n2840 S=FE_OFN2082_n1515
+ A=FE_OFN905_branch_metrics_4__2__3 B=FE_OFN2138_n1552
XU1952 MUX2S $PINS O=n2829 S=FE_OFN2081_n1515
+ A=FE_OFN894_branch_metrics_4__1__2 B=FE_OFN2143_n4207
XU1953 MUX2S $PINS O=n2828 S=FE_OFN2079_n1515
+ A=FE_OFN893_branch_metrics_4__1__3 B=FE_OFN2142_n4206
XU1954 MUX2S $PINS O=n2818 S=FE_OFN2086_n1515 A=branch_metrics[4][0][1]
+ B=FE_DBTN78_n11
XU1955 MUX2S $PINS O=n2817 S=FE_OFN2082_n1515 A=branch_metrics[4][0][2]
+ B=FE_OFN2140_n1554
XU1956 MUX2S $PINS O=n2806 S=FE_OFN2092_n1516
+ A=FE_OFN871_branch_metrics_3__3__1 B=FE_DBTN79_n10
XU1957 MUX2S $PINS O=n2805 S=FE_OFN2092_n1516
+ A=FE_OFN870_branch_metrics_3__3__2 B=FE_OFN2136_n1550
XU1958 MUX2S $PINS O=n2793 S=FE_OFN2096_n1516 A=branch_metrics[3][2][2]
+ B=FE_DBTN80_n9
XU1959 MUX2S $PINS O=n2792 S=FE_OFN2097_n1516
+ A=FE_OFN857_branch_metrics_3__2__3 B=FE_OFN2138_n1552
XU1960 MUX2S $PINS O=n2781 S=FE_OFN2092_n1516 A=branch_metrics[3][1][2]
+ B=FE_OFN2143_n4207
XU1961 MUX2S $PINS O=n2780 S=n1516 A=FE_OFN845_branch_metrics_3__1__3
+ B=FE_OFN2142_n4206
XU1962 MUX2S $PINS O=n2770 S=FE_OFN2096_n1516 A=branch_metrics[3][0][1]
+ B=FE_OFN2064_FE_DBTN78_n11
XU1963 MUX2S $PINS O=n2769 S=FE_OFN2096_n1516 A=branch_metrics[3][0][2] B=n1554
XU1964 MUX2S $PINS O=n2758 S=FE_OFN2105_n1517
+ A=FE_OFN823_branch_metrics_2__3__1 B=FE_OFN2063_FE_DBTN79_n10
XU1965 MUX2S $PINS O=n2757 S=FE_OFN2105_n1517 A=branch_metrics[2][3][2]
+ B=FE_OFN2136_n1550
XU1966 MUX2S $PINS O=n2745 S=FE_OFN2110_n1517 A=branch_metrics[2][2][2]
+ B=FE_OFN515_FE_DBTN80_n9
XU1967 MUX2S $PINS O=n2744 S=FE_OFN2111_n1517 A=branch_metrics[2][2][3]
+ B=FE_OFN2138_n1552
XU1968 MUX2S $PINS O=n2733 S=FE_OFN2105_n1517 A=branch_metrics[2][1][2]
+ B=FE_OFN2143_n4207
XU1969 MUX2S $PINS O=n2732 S=FE_OFN2102_n1517 A=branch_metrics[2][1][3]
+ B=FE_OFN2142_n4206
XU1970 MUX2S $PINS O=n2722 S=FE_OFN2110_n1517 A=branch_metrics[2][0][1]
+ B=FE_OFN2064_FE_DBTN78_n11
XU1971 MUX2S $PINS O=n2721 S=FE_OFN2110_n1517
+ A=FE_OFN786_branch_metrics_2__0__2 B=FE_OFN2140_n1554
XU1972 MUX2S $PINS O=n2710 S=FE_OFN2120_n1518 A=branch_metrics[1][3][1]
+ B=FE_OFN2063_FE_DBTN79_n10
XU1973 MUX2S $PINS O=n2709 S=FE_OFN2120_n1518 A=branch_metrics[1][3][2]
+ B=FE_OFN2136_n1550
XU1974 MUX2S $PINS O=n2697 S=FE_OFN2121_n1518 A=branch_metrics[1][2][2]
+ B=FE_OFN515_FE_DBTN80_n9
XU1975 MUX2S $PINS O=n2696 S=FE_OFN2122_n1518 A=branch_metrics[1][2][3]
+ B=FE_OFN2138_n1552
XU1976 MUX2S $PINS O=n2685 S=FE_OFN2120_n1518 A=branch_metrics[1][1][2]
+ B=FE_OFN2143_n4207
XU1977 MUX2S $PINS O=n2684 S=FE_OFN2117_n1518 A=branch_metrics[1][1][3]
+ B=FE_OFN2142_n4206
XU1978 MUX2S $PINS O=n2674 S=FE_OFN2121_n1518
+ A=FE_OFN739_branch_metrics_1__0__1 B=FE_DBTN78_n11
XU1979 MUX2S $PINS O=n2673 S=FE_OFN2121_n1518 A=branch_metrics[1][0][2]
+ B=FE_OFN2140_n1554
XU1980 MUX2S $PINS O=n2637 S=FE_OFN2130_n1519 A=forward_sum[0][6][2] B=n4207
XU1981 MUX2S $PINS O=n2626 S=FE_OFN2131_n1519 A=forward_sum[0][2][1]
+ B=FE_OFN2064_FE_DBTN78_n11
XU1982 MUX2S $PINS O=n2625 S=FE_OFN2131_n1519 A=FE_OFN987_forward_sum_0__2__2
+ B=FE_OFN2140_n1554
XU1983 ND2S $PINS O=n1002 I1=FE_OFN1713_FE_DBTN71_n4217 I2=count[2]
XU1984 MUX2S $PINS O=n2951 S=FE_OFN2154_n4223 A=backward_sum[0][3][0]
+ B=FE_OFN2133_n1520
XU1985 MUX2S $PINS O=n2927 S=FE_OFN2154_n4223 A=backward_sum[0][1][0]
+ B=FE_OFN2134_n1521
XU1986 MUX2S $PINS O=n2915 S=FE_OFN2155_n4223 A=backward_sum[0][4][0]
+ B=FE_OFN2135_n1522
XU1987 MUX2S $PINS O=n2903 S=FE_OFN2071_n1514 A=branch_metrics[5][3][0] B=n1521
XU1988 MUX2S $PINS O=n2879 S=FE_OFN2071_n1514 A=n1434 B=n1521
XU1989 MUX2S $PINS O=n2867 S=FE_OFN2075_n1514 A=branch_metrics[5][0][0] B=n1522
XU1990 MUX2S $PINS O=n2855 S=FE_OFN2081_n1515
+ A=FE_OFN920_branch_metrics_4__3__0 B=FE_OFN2133_n1520
XU1991 MUX2S $PINS O=n2831 S=FE_OFN2081_n1515
+ A=FE_OFN896_branch_metrics_4__1__0 B=FE_OFN2134_n1521
XU1992 MUX2S $PINS O=n2819 S=FE_OFN2086_n1515 A=branch_metrics[4][0][0]
+ B=FE_OFN2135_n1522
XU1993 MUX2S $PINS O=n2807 S=FE_OFN2092_n1516 A=branch_metrics[3][3][0] B=n1521
XU1994 MUX2S $PINS O=n2783 S=FE_OFN2092_n1516 A=branch_metrics[3][1][0] B=n1521
XU1995 MUX2S $PINS O=n2771 S=FE_OFN2096_n1516 A=branch_metrics[3][0][0] B=n1522
XU1996 MUX2S $PINS O=n2759 S=FE_OFN2105_n1517 A=branch_metrics[2][3][0]
+ B=FE_OFN2133_n1520
XU1997 MUX2S $PINS O=n2735 S=FE_OFN2105_n1517
+ A=FE_OFN800_branch_metrics_2__1__0 B=FE_OFN2134_n1521
XU1998 MUX2S $PINS O=n2723 S=FE_OFN2110_n1517 A=branch_metrics[2][0][0]
+ B=FE_OFN2135_n1522
XU1999 MUX2S $PINS O=n2711 S=FE_OFN2120_n1518 A=branch_metrics[1][3][0]
+ B=FE_OFN2133_n1520
XU2000 MUX2S $PINS O=n2687 S=FE_OFN2120_n1518
+ A=FE_OFN752_branch_metrics_1__1__0 B=FE_OFN2134_n1521
XU2001 MUX2S $PINS O=n2675 S=FE_OFN2121_n1518 A=branch_metrics[1][0][0]
+ B=FE_OFN2135_n1522
XU2002 MUX2S $PINS O=n2663 S=FE_OFN2130_n1519 A=forward_sum[0][5][0]
+ B=FE_OFN2133_n1520
XU2003 MUX2S $PINS O=n2639 S=FE_OFN2130_n1519 A=forward_sum[0][6][0]
+ B=FE_OFN2134_n1521
XU2004 MUX2S $PINS O=n2627 S=FE_OFN2131_n1519 A=forward_sum[0][2][0]
+ B=FE_OFN2135_n1522
XU2005 MUX2S $PINS O=n2939 S=FE_OFN2155_n4223 A=backward_sum[0][6][0]
+ B=FE_OFN514_FE_DBTN81_n8
XU2006 MUX2S $PINS O=n2891 S=FE_OFN2075_n1514 A=branch_metrics[5][2][0]
+ B=FE_OFN514_FE_DBTN81_n8
XU2007 MUX2S $PINS O=n2843 S=FE_OFN2086_n1515 A=branch_metrics[4][2][0]
+ B=FE_OFN514_FE_DBTN81_n8
XU2008 MUX2S $PINS O=n2795 S=FE_OFN2096_n1516 A=branch_metrics[3][2][0]
+ B=FE_DBTN81_n8
XU2009 MUX2S $PINS O=n2747 S=FE_OFN2110_n1517 A=branch_metrics[2][2][0]
+ B=FE_OFN514_FE_DBTN81_n8
XU2010 MUX2S $PINS O=n2699 S=FE_OFN2121_n1518 A=branch_metrics[1][2][0]
+ B=FE_OFN514_FE_DBTN81_n8
XU2011 MUX2S $PINS O=n2651 S=FE_OFN2131_n1519 A=forward_sum[0][1][0]
+ B=FE_OFN514_FE_DBTN81_n8
XU2012 MUX2S $PINS O=n2650 S=FE_OFN2131_n1519 A=forward_sum[0][1][1]
+ B=FE_OFN2157_n4253
XU2013 MUX2S $PINS O=n2938 S=FE_OFN2155_n4223 A=backward_sum[0][6][1]
+ B=FE_OFN2157_n4253
XU2014 MUX2S $PINS O=n2926 S=FE_OFN2155_n4223 A=backward_sum[0][1][1]
+ B=FE_OFN2141_n1558
XU2015 MUX2S $PINS O=n2890 S=FE_OFN2075_n1514 A=branch_metrics[5][2][1]
+ B=FE_OFN2157_n4253
XU2016 MUX2S $PINS O=n2878 S=FE_OFN2075_n1514 A=branch_metrics[5][1][1] B=n1558
XU2017 MUX2S $PINS O=n2842 S=FE_OFN2086_n1515
+ A=FE_OFN907_branch_metrics_4__2__1 B=FE_OFN2157_n4253
XU2018 MUX2S $PINS O=n2830 S=FE_OFN2081_n1515
+ A=FE_OFN895_branch_metrics_4__1__1 B=FE_OFN2141_n1558
XU2019 MUX2S $PINS O=n2794 S=FE_OFN2096_n1516
+ A=FE_OFN859_branch_metrics_3__2__1 B=n4253
XU2020 MUX2S $PINS O=n2782 S=FE_OFN2092_n1516 A=branch_metrics[3][1][1] B=n1558
XU2021 MUX2S $PINS O=n2746 S=FE_OFN2110_n1517 A=branch_metrics[2][2][1]
+ B=FE_OFN2157_n4253
XU2022 MUX2S $PINS O=n2734 S=FE_OFN2105_n1517 A=branch_metrics[2][1][1]
+ B=FE_OFN2141_n1558
XU2023 MUX2S $PINS O=n2698 S=FE_OFN2121_n1518
+ A=FE_OFN763_branch_metrics_1__2__1 B=FE_OFN2157_n4253
XU2024 MUX2S $PINS O=n2686 S=FE_OFN2120_n1518 A=branch_metrics[1][1][1]
+ B=FE_OFN2141_n1558
XU2025 MUX2S $PINS O=n2638 S=FE_OFN2130_n1519 A=FE_OFN1008_forward_sum_0__6__1
+ B=FE_OFN2141_n1558
XU2026 OA12S $PINS O=n999 A1=n996 B1=FE_OFN5652_FE_OFN5518_count_0 B2=n998
XU2027 ND2S $PINS O=n1000 I1=FE_OFN5652_FE_OFN5518_count_0 I2=n5510
XU2275 INV1S $PINS O=n4846 I=n4906
XU2303 INV1S $PINS O=n5286 I=n5345
XU2439 INV1S $PINS O=n4902 I=n4921
XU2441 INV1S $PINS O=n5341 I=n5360
XU2443 INV1S $PINS O=n4895 I=n4925
XU2444 OR2B1S $PINS O=n4885 I1=n4929 B1=n4930
XU2445 OR2B1S $PINS O=n5324 I1=n5368 B1=n5369
XU2457 INV2 $PINS O=n5325 I=n5371
XU2459 INV2 $PINS O=n4886 I=n4932
XU2465 INV1S $PINS O=n4898 I=n4923
XU2468 INV1S $PINS O=n5312 I=n5369
XU2469 INV1S $PINS O=n4872 I=n4930
XU2475 INV1S $PINS O=n4990 I=n5106
XU2477 INV1S $PINS O=n4550 I=n4666
XU2515 INV1S $PINS O=n5346 I=n5349
XU2516 INV1S $PINS O=n4907 I=n4910
XU2529 INV1S $PINS O=n4903 I=n4919
XU2537 INV1S $PINS O=n4901 I=n4922
XU2539 INV1S $PINS O=n5284 I=n5355
XU2540 INV1S $PINS O=n4844 I=n4916
XU2754 INV1S $PINS O=n4651 I=n4629
XU2755 OA12 $PINS O=n4811 A1=n5754 B1=n4777 B2=n4871
XU2756 INV1S $PINS O=n4812 I=n4790
XU2757 OA12 $PINS O=n5090 A1=n5757 B1=n5056 B2=n5309
XU2758 INV1S $PINS O=n5091 I=n5069
XU2759 OA12 $PINS O=n5251 A1=n5756 B1=FE_RN_35_0 B2=n5311
XU2760 INV1S $PINS O=n5252 I=n5230
XU2761 INV1S $PINS O=n4891 I=n4885
XU2762 INV1S $PINS O=n5330 I=n5324
XU2763 INV1S $PINS O=n4662 I=n4852
XU2764 INV1S $PINS O=n5102 I=n5292
XU2766 INV1S $PINS O=n4655 I=n4860
XU2767 INV1S $PINS O=n5095 I=n5300
XU2768 INV1S $PINS O=n5256 I=n5298
XU2769 INV1S $PINS O=n5043 I=N604
XU2770 INV1S $PINS O=n5204 I=N580
XU2771 OR2B1S $PINS O=n5107 I1=n5109 B1=n5106
XU2772 OR2B1S $PINS O=n5268 I1=n5270 B1=n5267
XU2773 INV2 $PINS O=n4709 I=n4843
XU2775 INV1S $PINS O=n5438 I=n5307
XU2776 INV1S $PINS O=n5439 I=n5306
XU2777 INV1S $PINS O=n4826 I=n4829
XU2789 INV1S $PINS O=n4663 I=n4836
XU2792 INV1S $PINS O=n4991 I=n5114
XU2798 INV2 $PINS O=n5149 I=n5283
XU2799 INV1S $PINS O=n5323 I=n5373
XU2800 INV1S $PINS O=n4884 I=n4934
XU2801 INV1S $PINS O=n5086 I=n5309
XU2803 INV1S $PINS O=n5247 I=n5311
XU2824 INV1S $PINS O=n4807 I=n4871
XU2825 INV1S $PINS O=n5094 I=n5301
XU2827 INV1S $PINS O=n5255 I=n5299
XU2828 INV1S $PINS O=n5101 I=n5293
XU2830 INV1S $PINS O=n5262 I=n5291
XU2831 INV1S $PINS O=n5056 I=n5308
XU2832 INV1S $PINS O=n4616 I=n4868
XU2834 INV1S $PINS O=n4777 I=n4870
XU2836 INV1S $PINS O=n5288 I=n5354
XU2837 INV1S $PINS O=n4848 I=n4915
XU2843 INV1S $PINS O=n4914 I=n4849
XU2850 INV1S $PINS O=n5353 I=n5289
XU2863 INV1S $PINS O=n5483 I=n4259
XU2865 INV1S $PINS O=n5553 I=n5549
XU2866 INV1S $PINS O=n5603 I=n5599
XU2867 INV1S $PINS O=n5578 I=n5574
XU2868 INV1S $PINS O=n5628 I=n5624
XU2957 INV1S $PINS O=n4713 I=n4842
XU2958 INV2 $PINS O=n4715 I=n4831
XU2960 INV1S $PINS O=n4832 I=n4714
XU2963 INV1S $PINS O=n4644 I=n4936
XU2964 INV1S $PINS O=n4643 I=n4875
XU2967 INV1S $PINS O=n4805 I=n4878
XU2969 INV2 $PINS O=n5320 I=n5374
XU2970 INV2 $PINS O=n5321 I=n5372
XU2972 INV1S $PINS O=n4791 I=n4874
XU2973 INV1S $PINS O=n5070 I=n5316
XU2975 INV1S $PINS O=n5225 I=n5224
XU2976 INV1S $PINS O=n4779 I=n4778
XU2977 INV1S $PINS O=n5064 I=n5063
XU2978 INV1S $PINS O=n4624 I=n4623
XU2979 INV1S $PINS O=n5058 I=n5057
XU2980 INV1S $PINS O=n4785 I=n4784
XU2981 INV1S $PINS O=n4618 I=n4617
XU2982 INV1S $PINS O=n5219 I=n5218
XU2983 INV1S $PINS O=n5144 I=n5143
XU2984 INV2 $PINS O=n4947 I=n4946
XU2985 INV1S $PINS O=n4475 I=n4474
XU2986 INV1S $PINS O=n5045 I=n5044
XU2987 INV1S $PINS O=n5032 I=n5031
XU2988 INV1S $PINS O=n4457 I=n4456
XU2989 INV1S $PINS O=n4605 I=n4604
XU2990 INV1S $PINS O=n4611 I=n4610
XU2991 INV1S $PINS O=n4592 I=n4591
XU2992 INV1S $PINS O=n5212 I=n5211
XU2993 INV1S $PINS O=n4766 I=n4765
XU2994 INV1S $PINS O=n4753 I=n4752
XU2995 INV1S $PINS O=n4676 I=n4675
XU2996 INV1S $PINS O=n5122 I=n5121
XU2997 INV1S $PINS O=n4487 I=n4486
XU2998 INV1S $PINS O=n4463 I=n4462
XU2999 INV1S $PINS O=n4493 I=n4492
XU3000 INV1S $PINS O=n4451 I=n4450
XU3001 INV1S $PINS O=n4469 I=n4468
XU3002 INV1S $PINS O=n4481 I=n4480
XU3003 INV1S $PINS O=n5206 I=n5205
XU3004 INV1S $PINS O=n5193 I=n5192
XU3005 INV1S $PINS O=n4772 I=n4771
XU3006 INV1S $PINS O=n4957 I=n4956
XU3007 INV1S $PINS O=n4517 I=n4516
XU3008 INV1S $PINS O=n5116 I=n5115
XU3009 INV1S $PINS O=n4963 I=n4962
XU3011 INV1S $PINS O=n4523 I=n4522
XU3012 INV1S $PINS O=n4682 I=n4681
XU3013 INV1S $PINS O=n4511 I=n4510
XU3014 INV1S $PINS O=n5233 I=n5232
XU3015 INV1S $PINS O=n4793 I=n4792
XU3016 INV1S $PINS O=n5239 I=n5238
XU3017 INV1S $PINS O=n4799 I=n4798
XU3018 INV1S $PINS O=n5078 I=n5077
XU3019 INV1S $PINS O=n4638 I=n4637
XU3020 INV1S $PINS O=n5072 I=n5071
XU3021 INV1S $PINS O=n4632 I=n4631
XU3024 INV1S $PINS O=n5051 I=n5050
XU3025 INV1S $PINS O=n5038 I=n5037
XU3026 INV1S $PINS O=n4598 I=n4597
XU3027 INV1S $PINS O=n5199 I=n5198
XU3028 INV1S $PINS O=n5008 I=n5007
XU3029 INV1S $PINS O=n4741 I=n4740
XU3031 INV1S $PINS O=n5187 I=n5186
XU3033 INV1S $PINS O=n4969 I=n4968
XU3034 INV1S $PINS O=n4729 I=n4728
XU3035 INV1S $PINS O=n4574 I=n4573
XU3036 INV1S $PINS O=n4529 I=n4528
XU3037 INV1S $PINS O=n5175 I=n5174
XU3038 INV1S $PINS O=n4975 I=n4974
XU3039 INV1S $PINS O=n4717 I=n4716
XU3040 INV1S $PINS O=n4535 I=n4534
XU3041 INV1S $PINS O=n5163 I=n5162
XU3042 INV1S $PINS O=n5134 I=n5133
XU3043 INV1S $PINS O=n4688 I=n4687
XU3045 INV1S $PINS O=n4580 I=n4579
XU3046 INV1S $PINS O=n5181 I=n5180
XU3047 INV1S $PINS O=n5026 I=n5025
XU3048 INV1S $PINS O=n4759 I=n4758
XU3049 INV1S $PINS O=n4586 I=n4585
XU3050 INV1S $PINS O=n5169 I=n5168
XU3051 INV1S $PINS O=n4747 I=n4746
XU3052 INV1S $PINS O=n5128 I=n5127
XU3053 INV1S $PINS O=n5002 I=n5001
XU3054 INV1S $PINS O=n4996 I=n4995
XU3055 INV1S $PINS O=n4735 I=n4734
XU3056 INV1S $PINS O=n4562 I=n4561
XU3057 INV1S $PINS O=n4556 I=n4555
XU3058 INV1S $PINS O=n5157 I=n5156
XU3059 INV1S $PINS O=n4723 I=n4722
XU3060 INV1S $PINS O=n4694 I=n4693
XU3062 AO22 $PINS O=n1458 A1=FE_OFN2198_N2299 A2=N514 B1=N502
+ B2=FE_DBTN89_N2299
XU3063 AO22 $PINS O=n1459 A1=FE_OFN2199_n1454 A2=N538 B1=N526
+ B2=FE_OFN1429_FE_DBTN88_n1454
XU3064 AO22 $PINS O=n1460 A1=FE_DBTN87_n1455 A2=N562 B1=N550
+ B2=FE_OFN5512_n1455
XU3065 AO22 $PINS O=n1461 A1=FE_DBTN87_n1455 A2=N560 B1=N548
+ B2=FE_OFN5512_n1455
XU3066 AO22 $PINS O=n1462 A1=n1454 A2=N529 B1=FE_OFN2203_N517
+ B2=FE_OFN1425_n1454
XU3067 AO22 $PINS O=n1463 A1=n1455 A2=N553 B1=FE_OFN2200_N541
+ B2=FE_OFN1432_FE_DBTN87_n1455
XU3068 AO22 $PINS O=n1464 A1=FE_OFN2198_N2299 A2=N510 B1=N498
+ B2=FE_OFN1281_N2299
XU3069 AO22 $PINS O=n1465 A1=FE_OFN2199_n1454 A2=N534 B1=N522
+ B2=FE_DBTN88_n1454
XU3070 AO22 $PINS O=n1466 A1=FE_DBTN87_n1455 A2=N558 B1=N546
+ B2=FE_OFN1426_n1455
XU3071 AO22 $PINS O=n1467 A1=FE_OFN2198_N2299 A2=N513 B1=N501
+ B2=FE_DBTN89_N2299
XU3072 AO22 $PINS O=n1468 A1=FE_OFN2199_n1454 A2=N537 B1=N525
+ B2=FE_OFN1429_FE_DBTN88_n1454
XU3073 AO22 $PINS O=n1469 A1=FE_OFN2198_N2299 A2=N511 B1=N499
+ B2=FE_DBTN89_N2299
XU3074 AO22 $PINS O=n1470 A1=FE_OFN2199_n1454 A2=N535 B1=N523
+ B2=FE_OFN1429_FE_DBTN88_n1454
XU3075 AO22 $PINS O=n1471 A1=FE_DBTN87_n1455 A2=N561 B1=N549
+ B2=FE_OFN5512_n1455
XU3076 AO22 $PINS O=n1472 A1=FE_OFN2198_N2299 A2=FE_OFN2215_N509 B1=N497
+ B2=FE_OFN1281_N2299
XU3077 AO22 $PINS O=n1473 A1=FE_OFN2199_n1454 A2=N533 B1=N521
+ B2=FE_DBTN88_n1454
XU3078 AO22 $PINS O=n1474 A1=FE_DBTN87_n1455 A2=N559 B1=N547
+ B2=FE_OFN5512_n1455
XU3079 AO22 $PINS O=n1475 A1=FE_OFN1280_N2299 A2=FE_OFN2220_N508 B1=N496
+ B2=FE_OFN1281_N2299
XU3080 AO22 $PINS O=n1476 A1=n1454 A2=N532 B1=N520 B2=FE_DBTN88_n1454
XU3081 AO22 $PINS O=n1477 A1=FE_OFN1280_N2299 A2=N507 B1=N495
+ B2=FE_OFN1281_N2299
XU3082 AO22 $PINS O=n1478 A1=n1454 A2=N531 B1=N519 B2=FE_OFN1425_n1454
XU3083 AO22 $PINS O=n1479 A1=FE_DBTN87_n1455 A2=N557 B1=N545
+ B2=FE_OFN1426_n1455
XU3084 AO22 $PINS O=n1480 A1=n1455 A2=N556 B1=N544 B2=FE_OFN1426_n1455
XU3085 AO22 $PINS O=n1481 A1=n1454 A2=N530 B1=N518 B2=FE_OFN1425_n1454
XU3086 AO22 $PINS O=n1482 A1=n1455 A2=N555 B1=N543
+ B2=FE_OFN1432_FE_DBTN87_n1455
XU3087 AO22 $PINS O=n1483 A1=n1455 A2=FE_OFN2213_N554 B1=N542
+ B2=FE_OFN1432_FE_DBTN87_n1455
XU3088 AO22 $PINS O=n1484 A1=FE_OFN2198_N2299 A2=N512 B1=N500
+ B2=FE_DBTN89_N2299
XU3089 AO22 $PINS O=n1485 A1=FE_OFN2199_n1454 A2=N536 B1=N524
+ B2=FE_OFN1429_FE_DBTN88_n1454
XU3090 FA1S $PINS S=N698 CO=sub_1_root_sub_182_3/carry[5] A=N693
+ B=FE_DBTN95_N336 CI=sub_1_root_sub_182_3/carry[4]
XU3091 FA1S $PINS S=N697 CO=sub_1_root_sub_182_3/carry[4] A=N692
+ B=FE_DBTN95_N336 CI=sub_1_root_sub_182_3/carry[3]
XU3092 FA1S $PINS S=N936 CO=sub_0_root_sub_0_root_add_184/carry[7]
+ A=sub_0_root_sub_0_root_add_184/A[6] B=FE_OFN2061_FE_DBTN95_N336
+ CI=sub_0_root_sub_0_root_add_184/carry[6]
XU3093 FA1S $PINS S=N937 CO=sub_0_root_sub_0_root_add_184/carry[8]
+ A=sub_0_root_sub_0_root_add_184/A[7] B=FE_OFN2061_FE_DBTN95_N336
+ CI=sub_0_root_sub_0_root_add_184/carry[7]
XU3094 FA1S $PINS S=N938 CO=sub_0_root_sub_0_root_add_184/carry[9]
+ A=sub_0_root_sub_0_root_add_184/A[8] B=FE_OFN2061_FE_DBTN95_N336
+ CI=sub_0_root_sub_0_root_add_184/carry[8]
XU3095 FA1S $PINS S=N939 CO=sub_0_root_sub_0_root_add_184/carry[10]
+ A=sub_0_root_sub_0_root_add_184/A[9] B=FE_OFN2061_FE_DBTN95_N336
+ CI=sub_0_root_sub_0_root_add_184/carry[9]
XU3096 FA1S $PINS S=N940 CO=sub_0_root_sub_0_root_add_184/carry[11]
+ A=sub_0_root_sub_0_root_add_184/A[10] B=FE_OFN2061_FE_DBTN95_N336
+ CI=sub_0_root_sub_0_root_add_184/carry[10]
XU3099 INV1S $PINS O=n3638 I=sub_0_root_sub_0_root_add_184/A[4]
XU3101 AO13S $PINS O=n1486 A1=n5664 B1=n5665 B2=n5676 B3=N512
XU3102 OAI22S $PINS O=n1487 A1=N497 A2=n5682 B1=n5681 B2=n5667
XU3104 AO13S $PINS O=n1488 A1=n5698 B1=n5699 B2=n5710 B3=N536
XU3105 OAI22S $PINS O=n1489 A1=N521 A2=n5716 B1=n5715 B2=n5701
XU3107 AO13S $PINS O=n1490 A1=n5732 B1=n5733 B2=n5744 B3=N560
XU3108 OAI22S $PINS O=n1491 A1=N545 A2=n5750 B1=n5749 B2=n5735
XU3110 AO13S $PINS O=n1492 A1=n5641 B1=n5642 B2=n5454 B3=N488
XU3111 OAI22S $PINS O=n1493 A1=N473 A2=n5457 B1=n5456 B2=n5644
XU3112 MAOI1 $PINS O=n5662 A1=N514 A2=n1494 B1=N501 B2=n5679
XU3113 AN2 $PINS O=n1494 I1=n5660 I2=n5675
XU3114 MAOI1 $PINS O=n5696 A1=N538 A2=n1495 B1=N525 B2=n5713
XU3115 AN2 $PINS O=n1495 I1=n5694 I2=n5709
XU3116 MAOI1 $PINS O=n5730 A1=N562 A2=n1496 B1=N549 B2=n5747
XU3117 AN2 $PINS O=n1496 I1=n5728 I2=n5743
XU3118 INV1S $PINS O=n5684 I=N507
XU3119 INV1S $PINS O=n5718 I=N531
XU3120 INV1S $PINS O=n5752 I=N555
XU3122 INV1S $PINS O=n5717 I=N532
XU3123 INV1S $PINS O=n5751 I=N556
XU3124 INV1S $PINS O=n5459 I=n4432
XU3126 INV1S $PINS O=n5719 I=N530
XU3128 INV1S $PINS O=n5747 I=N561
XU3129 INV1S $PINS O=n5679 I=N513
XU3130 INV1S $PINS O=n5713 I=N537
XU3132 INV1S $PINS O=n5716 I=N533
XU3133 INV1S $PINS O=n5750 I=N557
XU3135 INV1S $PINS O=n5457 I=n4436
XU3138 NR2 $PINS O=n1498 I1=n5511 I2=N810
XU3139 NR2 $PINS O=n1499 I1=n5511 I2=N694
XU3140 NR2 $PINS O=n1500 I1=n5512 I2=sub_0_root_sub_0_root_add_184/A[0]
XU3147 INV1S $PINS O=n5496 I=n4262
XU3148 INV1S $PINS O=n5493 I=n4286
XU3149 INV1S $PINS O=n5492 I=n4274
XU3150 INV1S $PINS O=n5481 I=n4298
XU3151 INV1S $PINS O=n5448 I=n4444
XU3152 INV1S $PINS O=n5446 I=n4445
XU3153 INV1S $PINS O=n5447 I=n4446
XU3154 INV1S $PINS O=n5443 I=n4447
XU3155 INV1S $PINS O=n5445 I=n4448
XU3156 INV1S $PINS O=n5444 I=n4449
XU3157 INV1S $PINS O=n5450 I=n4438
XU3158 INV1S $PINS O=n5451 I=n4439
XU3159 INV1S $PINS O=n3961 I=forward_sum[2][1][10]
XU3160 MAOI1 $PINS O=n5594 A1=N431 A2=n1504 B1=N418 B2=n5479
XU3161 AN2 $PINS O=n1504 I1=n5593 I2=n5482
XU3162 MAOI1 $PINS O=n5564 A1=N411 A2=n1505 B1=N398 B2=n5503
XU3163 AN2 $PINS O=n1505 I1=n5562 I2=n5488
XU3164 MAOI1 $PINS O=n5639 A1=N490 A2=n1506 B1=N477 B2=n5453
XU3165 AN2 $PINS O=n1506 I1=n5637 I2=n5452
XU3166 MAOI1 $PINS O=n5539 A1=N387 A2=n1507 B1=N374 B2=n5498
XU3167 AN2 $PINS O=n1507 I1=n5537 I2=n5495
XU3168 MAOI1 $PINS O=n5589 A1=N435 A2=n1508 B1=N422 B2=n5502
XU3169 AN2 $PINS O=n1508 I1=n5587 I2=n5489
XU3170 MAOI1 $PINS O=n5614 A1=N459 A2=n1509 B1=N446 B2=n5507
XU3171 AN2 $PINS O=n1509 I1=n5612 I2=n5476
XU3172 MAOI1 $PINS O=n5544 A1=N383 A2=n1510 B1=N370 B2=n5490
XU3173 AN2 $PINS O=n1510 I1=n5543 I2=n5491
XU3174 MAOI1 $PINS O=n5569 A1=N407 A2=n1511 B1=N394 B2=n5478
XU3175 AN2 $PINS O=n1511 I1=n5568 I2=n5480
XU3176 MAOI1 $PINS O=n5619 A1=N455 A2=n1512 B1=N442 B2=n5467
XU3177 AN2 $PINS O=n1512 I1=n5618 I2=n5468
XU3178 INV1S $PINS O=n5675 I=N502
XU3179 INV1S $PINS O=n5709 I=N526
XU3180 INV1S $PINS O=n5743 I=N550
XU3181 INV1S $PINS O=n5676 I=N500
XU3182 INV1S $PINS O=n5710 I=N524
XU3183 INV1S $PINS O=n5744 I=N548
XU3184 INV1S $PINS O=n5680 I=N511
XU3185 INV1S $PINS O=n5714 I=N535
XU3186 INV1S $PINS O=n5748 I=N559
XU3187 INV1S $PINS O=n5452 I=n4441
XU3188 INV1S $PINS O=n5458 I=n4434
XU3189 INV1S $PINS O=n5745 I=N546
XU3190 INV1S $PINS O=n5677 I=N498
XU3191 INV1S $PINS O=n5711 I=N522
XU3192 INV1S $PINS O=n5455 I=n4442
XU3193 INV1S $PINS O=n5449 I=n4437
XU3194 INV1S $PINS O=n5463 I=n4293
XU3195 INV1S $PINS O=n5453 I=n4440
XU3196 INV1S $PINS O=n5462 I=n4269
XU3199 INV1S $PINS O=n5472 I=n4283
XU3200 INV1S $PINS O=n5470 I=n4271
XU3201 INV1S $PINS O=n5464 I=n4295
XU3202 INV1S $PINS O=n5486 I=n4256
XU3203 INV1S $PINS O=n5474 I=n4280
XU3204 INV1S $PINS O=n5473 I=n4268
XU3205 INV1S $PINS O=n5465 I=n4292
XU3206 INV1S $PINS O=n5495 I=n4265
XU3207 INV1S $PINS O=n5489 I=n4289
XU3208 INV1S $PINS O=n5488 I=n4277
XU3209 INV1S $PINS O=n5476 I=n4301
XU3210 INV1S $PINS O=n5499 I=n4266
XU3211 INV1S $PINS O=n5504 I=n4290
XU3212 INV1S $PINS O=n5505 I=n4278
XU3213 INV1S $PINS O=n5508 I=n4302
XU3214 INV1S $PINS O=n5497 I=n4263
XU3215 INV1S $PINS O=n5500 I=n4287
XU3216 INV1S $PINS O=n5501 I=n4275
XU3217 INV1S $PINS O=n5506 I=n4299
XU3218 INV1S $PINS O=n5681 I=N510
XU3219 INV1S $PINS O=n5715 I=N534
XU3220 INV1S $PINS O=n5749 I=N558
XU3221 INV1S $PINS O=n5491 I=n4261
XU3222 INV1S $PINS O=n5482 I=n4285
XU3223 INV1S $PINS O=n5480 I=n4273
XU3224 INV1S $PINS O=n5468 I=n4297
XU3225 INV1S $PINS O=n5498 I=n4264
XU3226 INV1S $PINS O=n5490 I=n4260
XU3227 INV1S $PINS O=n5502 I=n4288
XU3228 INV1S $PINS O=n5479 I=n4284
XU3229 INV1S $PINS O=n5503 I=n4276
XU3230 INV1S $PINS O=n5478 I=n4272
XU3231 INV1S $PINS O=n5507 I=n4300
XU3232 INV1S $PINS O=n5467 I=n4296
XU3233 INV1S $PINS O=n5456 I=N486
XU3234 INV1S $PINS O=n3988 I=forward_sum[3][0][9]
XU3235 INV1S $PINS O=n3881 I=forward_sum[2][5][7]
XU3236 INV1S $PINS O=n3855 I=forward_sum[2][3][7]
XU3237 INV1S $PINS O=n3690 I=forward_sum[2][7][7]
XU3238 INV1S $PINS O=n3887 I=forward_sum[2][4][7]
XU3239 INV1S $PINS O=n3817 I=forward_sum[2][5][9]
XU3240 INV1S $PINS O=n3860 I=forward_sum[2][2][7]
XU3241 INV1S $PINS O=n3789 I=forward_sum[2][3][9]
XU3242 INV1S $PINS O=n3695 I=forward_sum[2][6][7]
XU3243 INV1S $PINS O=n3670 I=forward_sum[2][7][9]
XU3244 INV1S $PINS O=n3965 I=forward_sum[5][0][10]
XU3245 INV1S $PINS O=n3823 I=forward_sum[2][4][9]
XU3246 INV1S $PINS O=n3794 I=forward_sum[2][2][9]
XU3247 INV1S $PINS O=n3675 I=forward_sum[2][6][9]
XU3248 INV1S $PINS O=n3985 I=forward_sum[2][1][9]
XU3249 INV1S $PINS O=n3991 I=forward_sum[2][0][9]
XU3250 INV1S $PINS O=n3780 I=forward_sum[1][4][10]
XU3251 INV1S $PINS O=n3760 I=forward_sum[1][2][10]
XU3252 INV1S $PINS O=n3661 I=forward_sum[1][6][10]
XU3253 INV1S $PINS O=n3775 I=forward_sum[2][5][10]
XU3254 INV1S $PINS O=n3755 I=forward_sum[2][3][10]
XU3255 INV1S $PINS O=n3656 I=forward_sum[2][7][10]
XU3256 INV1S $PINS O=n3776 I=forward_sum[3][5][10]
XU3257 INV1S $PINS O=n3756 I=forward_sum[3][3][10]
XU3258 INV1S $PINS O=n3657 I=forward_sum[3][7][10]
XU3259 INV1S $PINS O=n3783 I=forward_sum[3][4][10]
XU3260 INV1S $PINS O=n3762 I=forward_sum[3][2][10]
XU3261 INV1S $PINS O=n3663 I=forward_sum[3][6][10]
XU3262 INV1S $PINS O=n3763 I=forward_sum[5][2][10]
XU3263 INV1S $PINS O=n3664 I=forward_sum[5][6][10]
XU3264 AN2 $PINS O=n1514 I1=FE_OFN2057_n982 I2=n1559
XU3265 AN2 $PINS O=n1515 I1=FE_OFN2057_n982 I2=FE_OFN1852_n5509
XU3266 AN2 $PINS O=n1516 I1=n982 I2=n1560
XU3267 AN2 $PINS O=n1517 I1=FE_OFN2057_n982 I2=FE_OFN1676_FE_DBTN85_n987
XU3268 AN2 $PINS O=n1518 I1=FE_OFN2057_n982 I2=FE_OFN5520_n
XU3269 AN2 $PINS O=n1519 I1=FE_OFN2057_n982 I2=FE_OFN1803_n5419
XU3270 INV1S $PINS O=n5454 I=n4443
XU3271 INV1S $PINS O=n5487 I=n4258
XU3272 INV1S $PINS O=n5477 I=n4282
XU3273 INV1S $PINS O=n5475 I=n4270
XU3274 INV1S $PINS O=n5466 I=n4294
XU3275 INV1S $PINS O=n5494 I=n4267
XU3276 INV1S $PINS O=n5485 I=n4291
XU3277 INV1S $PINS O=n5484 I=n4279
XU3278 INV1S $PINS O=n5471 I=n4303
XU3279 INV1S $PINS O=n4154 I=forward_sum[2][0][2]
XU3280 INV1S $PINS O=n4148 I=forward_sum[2][1][2]
XU3281 INV1S $PINS O=n3958 I=forward_sum[3][1][10]
XU3282 INV1S $PINS O=n4014 I=forward_sum[2][5][3]
XU3283 INV1S $PINS O=n3996 I=forward_sum[2][3][3]
XU3284 INV1S $PINS O=n3799 I=forward_sum[2][7][3]
XU3285 INV1S $PINS O=n4106 I=forward_sum[2][0][6]
XU3286 INV1S $PINS O=n4100 I=forward_sum[2][1][6]
XU3287 INV1S $PINS O=n3933 I=forward_sum[2][5][5]
XU3288 INV1S $PINS O=n3915 I=forward_sum[2][3][5]
XU3289 INV1S $PINS O=n3710 I=forward_sum[2][7][5]
XU3290 INV1S $PINS O=n4130 I=forward_sum[2][0][4]
XU3291 INV1S $PINS O=n4032 I=forward_sum[2][1][8]
XU3292 INV1S $PINS O=n3939 I=forward_sum[2][4][5]
XU3293 INV1S $PINS O=n4020 I=forward_sum[2][4][3]
XU3294 INV1S $PINS O=n3920 I=forward_sum[2][2][5]
XU3295 INV1S $PINS O=n4001 I=forward_sum[2][2][3]
XU3296 INV1S $PINS O=n3715 I=forward_sum[2][6][5]
XU3297 INV1S $PINS O=n3804 I=forward_sum[2][6][3]
XU3298 INV1S $PINS O=n4124 I=forward_sum[2][1][4]
XU3299 INV1S $PINS O=n4038 I=forward_sum[2][0][8]
XU3300 INV1S $PINS O=n4136 I=forward_sum[2][1][3]
XU3301 INV1S $PINS O=n4142 I=forward_sum[2][0][3]
XU3302 INV1S $PINS O=n4055 I=forward_sum[2][1][7]
XU3303 INV1S $PINS O=n4049 I=forward_sum[2][4][2]
XU3304 INV1S $PINS O=n3910 I=forward_sum[2][4][6]
XU3305 INV1S $PINS O=n4043 I=forward_sum[2][2][2]
XU3306 INV1S $PINS O=n3897 I=forward_sum[2][2][6]
XU3307 INV1S $PINS O=n3838 I=forward_sum[2][6][2]
XU3308 INV1S $PINS O=n3705 I=forward_sum[2][6][6]
XU3309 INV1S $PINS O=n4112 I=forward_sum[2][1][5]
XU3310 INV1S $PINS O=n4026 I=forward_sum[2][5][2]
XU3311 INV1S $PINS O=n3904 I=forward_sum[2][5][6]
XU3312 INV1S $PINS O=n4007 I=forward_sum[2][3][2]
XU3313 INV1S $PINS O=n3892 I=forward_sum[2][3][6]
XU3314 INV1S $PINS O=n3810 I=forward_sum[2][7][2]
XU3315 INV1S $PINS O=n3700 I=forward_sum[2][7][6]
XU3316 INV1S $PINS O=n4118 I=forward_sum[2][0][5]
XU3317 INV1S $PINS O=n4061 I=forward_sum[2][0][7]
XU3318 INV1S $PINS O=n3979 I=forward_sum[2][4][4]
XU3319 INV1S $PINS O=n3844 I=forward_sum[2][5][8]
XU3320 INV1S $PINS O=n3971 I=forward_sum[2][2][4]
XU3321 INV1S $PINS O=n3828 I=forward_sum[2][3][8]
XU3322 INV1S $PINS O=n3768 I=forward_sum[2][6][4]
XU3323 INV1S $PINS O=n3680 I=forward_sum[2][7][8]
XU3324 INV1S $PINS O=n3945 I=forward_sum[2][5][4]
XU3325 INV1S $PINS O=n3850 I=forward_sum[2][4][8]
XU3326 INV1S $PINS O=n3926 I=forward_sum[2][3][4]
XU3327 INV1S $PINS O=n3833 I=forward_sum[2][2][8]
XU3328 INV1S $PINS O=n3721 I=forward_sum[2][7][4]
XU3329 INV1S $PINS O=n3685 I=forward_sum[2][6][8]
XU3330 INV1S $PINS O=n3781 I=forward_sum[4][4][10]
XU3331 INV1S $PINS O=n3761 I=forward_sum[4][2][10]
XU3332 INV1S $PINS O=n3662 I=forward_sum[4][6][10]
XU3333 INV1S $PINS O=n3784 I=forward_sum[5][4][10]
XU3336 XNR2HS $PINS O=n1521 I1=n5511 I2=N810
XU3337 XNR2HS $PINS O=n1522 I1=n5511 I2=N694
XU3338 AN2 $PINS O=n1523 I1=n1559 I2=n4316
XU3339 AN2 $PINS O=n1524 I1=FE_OFN1852_n5509 I2=n4316
XU3340 AN2 $PINS O=n1525 I1=FE_OFN1676_FE_DBTN85_n987 I2=n4316
XU3341 AN2 $PINS O=n1526 I1=FE_OFN1803_n5419 I2=n4316
XU3342 AN2 $PINS O=n1527 I1=n1559 I2=n3900
XU3343 AN2 $PINS O=n1528 I1=FE_OFN1852_n5509 I2=n3900
XU3344 AN2 $PINS O=n1529 I1=FE_OFN1676_FE_DBTN85_n987 I2=n3900
XU3345 AN2 $PINS O=n1530 I1=FE_OFN1803_n5419 I2=n3900
XU3346 INV1S $PINS O=n4160 I=forward_sum[2][1][1]
XU3347 INV1S $PINS O=n4082 I=forward_sum[2][5][1]
XU3348 INV1S $PINS O=n4066 I=forward_sum[2][3][1]
XU3349 INV1S $PINS O=n3865 I=forward_sum[2][7][1]
XU3350 INV1S $PINS O=n4166 I=forward_sum[2][0][1]
XU3351 INV1S $PINS O=n4088 I=forward_sum[2][4][1]
XU3352 INV1S $PINS O=n4071 I=forward_sum[2][2][1]
XU3353 INV1S $PINS O=n3870 I=forward_sum[2][6][1]
XU3357 AN2 $PINS O=n1531 I1=n1560 I2=n4316
XU3358 AN2 $PINS O=n1532 I1=FE_OFN5520_n I2=n4316
XU3359 AN2 $PINS O=n1533 I1=n1560 I2=n3900
XU3360 AN2 $PINS O=n1534 I1=FE_OFN5520_n I2=n3900
XU3361 AN2 $PINS O=n1537 I1=FE_OFN1461_n987 I2=n5377
XU3362 AN2 $PINS O=n1538 I1=FE_OFN1588_FE_DBTN86_n985 I2=n5377
XU3363 AN2 $PINS O=n1539 I1=n5419 I2=n5377
XU3374 MOAI1S $PINS O=n3923 A1=FE_OFN2051_N336 A2=n3637 B1=n3974 B2=n1540
XU3375 MOAI1S $PINS O=n3974 A1=N337 A2=n3636 B1=n4004 B2=n1541
XU3376 MOAI1S $PINS O=n3771 A1=FE_OFN2054_N356 A2=n3628 B1=n3807 B2=n1542
XU3377 MOAI1S $PINS O=n3975 A1=FE_OFN2054_N356 A2=n3632 B1=n4010 B2=n1543
XU3378 INV1S $PINS O=n3627 I=N1041
XU3379 INV1S $PINS O=n3631 I=N695
XU3380 INV1S $PINS O=n3635 I=sub_0_root_sub_0_root_add_184/A[1]
XU3381 XOR3 $PINS O=N826 I1=N347 I2=FE_OFN2065_n1444
+ I3=add_0_root_add_183_2/carry[11]
XU3382 MOAI1 $PINS O=n3718 A1=N355 A2=n3629 B1=n3771 B2=n1544
XU3383 MOAI1S $PINS O=n3929 A1=FE_OFN2053_N355 A2=n3633 B1=n3975 B2=n1545
XU3384 AO22 $PINS O=n1546 A1=FE_OFN1280_N2299 A2=N505 B1=FE_OFN2207_N493
+ B2=FE_OFN1428_FE_DBTN89_N2299
XU3385 AO22 $PINS O=n1547 A1=FE_OFN1280_N2299 A2=FE_OFN2209_N506 B1=N494
+ B2=FE_OFN1428_FE_DBTN89_N2299
XU3386 FA1S $PINS S=N1044 CO=add_1_root_sub_185_2/carry[5] A=N693
+ B=FE_OFN2051_N336 CI=add_1_root_sub_185_2/carry[4]
XU3387 FA1S $PINS S=N1051 CO=sub_0_root_sub_185_2/carry[6]
+ A=FE_OFN2062_FE_DBTN83_n3 B=n5519 CI=sub_0_root_sub_185_2/carry[5]
XU3388 INV1S $PINS O=n5519 I=N353
XU3389 FA1 $PINS S=N705 CO=sub_0_root_sub_182_3/carry[6] A=FE_DBTN84_n2 B=n5519
+ CI=sub_0_root_sub_182_3/carry[5]
XU3390 FA1S $PINS S=N1052 CO=sub_0_root_sub_185_2/carry[7]
+ A=FE_OFN2062_FE_DBTN83_n3 B=n5520 CI=sub_0_root_sub_185_2/carry[6]
XU3391 INV1S $PINS O=n5520 I=N352
XU3392 FA1S $PINS S=N706 CO=sub_0_root_sub_182_3/carry[7] A=FE_DBTN84_n2
+ B=n5520 CI=sub_0_root_sub_182_3/carry[6]
XU3393 FA1 $PINS S=N1053 CO=sub_0_root_sub_185_2/carry[8] A=FE_DBTN83_n3
+ B=n5521 CI=sub_0_root_sub_185_2/carry[7]
XU3394 INV1S $PINS O=n5521 I=N351
XU3395 FA1 $PINS S=N707 CO=sub_0_root_sub_182_3/carry[8]
+ A=FE_OFN2158_FE_DBTN84_n2 B=n5521 CI=sub_0_root_sub_182_3/carry[7]
XU3396 FA1S $PINS S=N1054 CO=sub_0_root_sub_185_2/carry[9] A=FE_DBTN83_n3
+ B=n5522 CI=sub_0_root_sub_185_2/carry[8]
XU3397 INV1S $PINS O=n5522 I=N350
XU3398 FA1S $PINS S=N708 CO=sub_0_root_sub_182_3/carry[9]
+ A=FE_OFN2158_FE_DBTN84_n2 B=n5522 CI=sub_0_root_sub_182_3/carry[8]
XU3399 FA1S $PINS S=N1055 CO=sub_0_root_sub_185_2/carry[10] A=FE_DBTN83_n3
+ B=n5523 CI=sub_0_root_sub_185_2/carry[9]
XU3400 INV1S $PINS O=n5523 I=N349
XU3401 FA1S $PINS S=N709 CO=sub_0_root_sub_182_3/carry[10]
+ A=FE_OFN2158_FE_DBTN84_n2 B=n5523 CI=sub_0_root_sub_182_3/carry[9]
XU3402 FA1S $PINS S=N1056 CO=sub_0_root_sub_185_2/carry[11] A=FE_DBTN83_n3
+ B=n5524 CI=sub_0_root_sub_185_2/carry[10]
XU3403 INV1S $PINS O=n5524 I=N348
XU3404 FA1S $PINS S=N710 CO=sub_0_root_sub_182_3/carry[11]
+ A=FE_OFN2158_FE_DBTN84_n2 B=n5524 CI=sub_0_root_sub_182_3/carry[10]
XU3405 INV1S $PINS O=n5528 I=N325
XU3407 FA1S $PINS S=N1043 CO=add_1_root_sub_185_2/carry[4] A=N692 B=N336
+ CI=add_1_root_sub_185_2/carry[3]
XU3408 FA1S $PINS S=N1041 CO=add_1_root_sub_185_2/carry[2] A=N690 B=N338
+ CI=add_1_root_add_183_2/carry[1]
XU3409 FA1S $PINS S=N695 CO=sub_1_root_sub_182_3/carry[2] A=N690 B=n5513
+ CI=sub_1_root_sub_182_3/carry[1]
XU3410 INV1S $PINS O=n5513 I=N338
XU3411 FA1S $PINS S=N1042 CO=add_1_root_sub_185_2/carry[3] A=N691 B=N337
+ CI=add_1_root_sub_185_2/carry[2]
XU3412 FA1 $PINS S=N696 CO=sub_1_root_sub_182_3/carry[3] A=N691 B=n5514
+ CI=sub_1_root_sub_182_3/carry[2]
XU3413 INV1S $PINS O=n5514 I=N337
XU3414 FA1S $PINS S=N935 CO=sub_0_root_sub_0_root_add_184/carry[6]
+ A=sub_0_root_sub_0_root_add_184/A[5] B=FE_DBTN95_N336
+ CI=sub_0_root_sub_0_root_add_184/carry[5]
XU3415 INV1S $PINS O=n3640 I=n3923
XU3416 FA1 $PINS S=sub_0_root_sub_0_root_add_184/A[2]
+ CO=add_1_root_sub_0_root_add_184/carry[3] A=FE_OFN2054_N356 B=N326
+ CI=add_1_root_sub_0_root_add_184/carry[2]
XU3417 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[3]
+ CO=add_1_root_sub_0_root_add_184/carry[4] A=FE_OFN2053_N355 B=FE_OFN2049_N325
+ CI=add_1_root_sub_0_root_add_184/carry[3]
XU3418 FA1 $PINS S=sub_0_root_sub_0_root_add_184/A[1]
+ CO=add_1_root_sub_0_root_add_184/carry[2] A=N357 B=FE_OFN2205_N327
+ CI=add_1_root_sub_0_root_add_184/carry[1]
XU3419 FA1 $PINS S=sub_0_root_sub_0_root_add_184/A[4]
+ CO=add_1_root_sub_0_root_add_184/carry[5] A=N354 B=FE_OFN2049_N325
+ CI=add_1_root_sub_0_root_add_184/carry[4]
XU3420 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[5]
+ CO=add_1_root_sub_0_root_add_184/carry[6] A=N353 B=FE_OFN2049_N325
+ CI=add_1_root_sub_0_root_add_184/carry[5]
XU3421 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[6]
+ CO=add_1_root_sub_0_root_add_184/carry[7] A=N352 B=FE_OFN2050_N325
+ CI=add_1_root_sub_0_root_add_184/carry[6]
XU3422 FA1S $PINS S=N820 CO=add_0_root_add_183_2/carry[6] A=N353 B=n1444
+ CI=add_0_root_add_183_2/carry[5]
XU3423 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[7]
+ CO=add_1_root_sub_0_root_add_184/carry[8] A=N351 B=FE_OFN2050_N325
+ CI=add_1_root_sub_0_root_add_184/carry[7]
XU3424 FA1S $PINS S=N821 CO=add_0_root_add_183_2/carry[7] A=N352
+ B=FE_OFN2065_n1444 CI=add_0_root_add_183_2/carry[6]
XU3425 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[8]
+ CO=add_1_root_sub_0_root_add_184/carry[9] A=N350 B=FE_OFN2050_N325
+ CI=add_1_root_sub_0_root_add_184/carry[8]
XU3426 FA1S $PINS S=N822 CO=add_0_root_add_183_2/carry[8] A=N351
+ B=FE_OFN2065_n1444 CI=add_0_root_add_183_2/carry[7]
XU3427 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[9]
+ CO=add_1_root_sub_0_root_add_184/carry[10] A=N349 B=FE_OFN2050_N325
+ CI=add_1_root_sub_0_root_add_184/carry[9]
XU3428 FA1S $PINS S=N823 CO=add_0_root_add_183_2/carry[9] A=N350
+ B=FE_OFN2065_n1444 CI=add_0_root_add_183_2/carry[8]
XU3429 FA1S $PINS S=sub_0_root_sub_0_root_add_184/A[10]
+ CO=add_1_root_sub_0_root_add_184/carry[11] A=N348 B=FE_OFN2050_N325
+ CI=add_1_root_sub_0_root_add_184/carry[10]
XU3430 FA1S $PINS S=N824 CO=add_0_root_add_183_2/carry[10] A=N349
+ B=FE_OFN2065_n1444 CI=add_0_root_add_183_2/carry[9]
XU3431 FA1S $PINS S=N825 CO=add_0_root_add_183_2/carry[11] A=N348
+ B=FE_OFN2065_n1444 CI=add_0_root_add_183_2/carry[10]
XU3432 FA1S $PINS S=N811 CO=add_1_root_add_183_2/carry[2] A=FE_OFN2205_N327
+ B=N338 CI=add_1_root_add_183_2/carry[1]
XU3433 FA1S $PINS S=N812 CO=add_1_root_add_183_2/carry[3] A=N326 B=N337
+ CI=add_1_root_add_183_2/carry[2]
XU3436 INV1S $PINS O=n5527 I=N326
XU3437 FA1S $PINS S=N813 CO=add_1_root_add_183_2/carry[4] A=FE_OFN2049_N325
+ B=N336 CI=add_1_root_add_183_2/carry[3]
XU3438 INV1S $PINS O=n5511 I=N358
XU3439 INV2CK $PINS O=n5442 I=n4433
XU3441 ND3 $PINS O=N391 I1=n1548 I2=n3765 I3=n3764
XU3442 ND3 $PINS O=N439 I1=n1549 I2=n3666 I3=n3665
XU3443 INV1S $PINS O=n3730 I=forward_sum[5][5][11]
XU3444 INV1S $PINS O=n3744 I=forward_sum[5][3][11]
XU3445 INV1S $PINS O=n3645 I=forward_sum[5][7][11]
XU3446 INV1S $PINS O=n4023 I=forward_sum[3][5][2]
XU3447 INV1S $PINS O=n4005 I=forward_sum[3][3][2]
XU3448 INV1S $PINS O=n3808 I=forward_sum[3][7][2]
XU3449 INV1S $PINS O=n4145 I=forward_sum[3][1][2]
XU3450 INV1S $PINS O=n3820 I=forward_sum[3][4][9]
XU3451 INV1S $PINS O=n3792 I=forward_sum[3][2][9]
XU3452 INV1S $PINS O=n3673 I=forward_sum[3][6][9]
XU3453 ND3 $PINS O=n4269 I1=n1555 I2=n3753 I3=n3752
XU3454 ND3 $PINS O=n4293 I1=n1556 I2=n3654 I3=n3653
XU3455 INV1S $PINS O=n3901 I=forward_sum[3][5][6]
XU3456 INV1S $PINS O=n3890 I=forward_sum[3][3][6]
XU3457 INV1S $PINS O=n3698 I=forward_sum[3][7][6]
XU3458 INV1S $PINS O=n4097 I=forward_sum[3][1][6]
XU3459 INV1S $PINS O=n3777 I=forward_sum[5][5][10]
XU3460 INV1S $PINS O=n3757 I=forward_sum[5][3][10]
XU3461 INV1S $PINS O=n3658 I=forward_sum[5][7][10]
XU3462 INV1S $PINS O=n3942 I=forward_sum[3][5][4]
XU3463 INV1S $PINS O=n3924 I=forward_sum[3][3][4]
XU3464 INV1S $PINS O=n3719 I=forward_sum[3][7][4]
XU3465 INV1S $PINS O=n4121 I=forward_sum[3][1][4]
XU3466 INV1S $PINS O=n3999 I=forward_sum[3][2][3]
XU3467 INV1S $PINS O=n3858 I=forward_sum[3][2][7]
XU3468 INV1S $PINS O=n3802 I=forward_sum[3][6][3]
XU3469 INV1S $PINS O=n3693 I=forward_sum[3][6][7]
XU3470 INV1S $PINS O=n4139 I=forward_sum[3][0][3]
XU3471 INV1S $PINS O=n4058 I=forward_sum[3][0][7]
XU3472 INV1S $PINS O=n4017 I=forward_sum[3][4][3]
XU3473 INV1S $PINS O=n3884 I=forward_sum[3][4][7]
XU3474 INV1S $PINS O=n4157 I=forward_sum[3][1][1]
XU3475 INV1S $PINS O=n4079 I=forward_sum[3][5][1]
XU3476 INV1S $PINS O=n4064 I=forward_sum[3][3][1]
XU3477 INV1S $PINS O=n3863 I=forward_sum[3][7][1]
XU3478 INV1S $PINS O=n4133 I=forward_sum[3][1][3]
XU3479 INV1S $PINS O=n4052 I=forward_sum[3][1][7]
XU3480 INV1S $PINS O=n4109 I=forward_sum[3][1][5]
XU3481 INV1S $PINS O=n3982 I=forward_sum[3][1][9]
XU3482 INV1S $PINS O=n4011 I=forward_sum[3][5][3]
XU3483 INV1S $PINS O=n3878 I=forward_sum[3][5][7]
XU3484 INV1S $PINS O=n3994 I=forward_sum[3][3][3]
XU3485 INV1S $PINS O=n3853 I=forward_sum[3][3][7]
XU3486 INV1S $PINS O=n3797 I=forward_sum[3][7][3]
XU3487 INV1S $PINS O=n3688 I=forward_sum[3][7][7]
XU3488 INV1S $PINS O=n3930 I=forward_sum[3][5][5]
XU3489 INV1S $PINS O=n3913 I=forward_sum[3][3][5]
XU3490 INV1S $PINS O=n3708 I=forward_sum[3][7][5]
XU3491 INV1S $PINS O=n3814 I=forward_sum[3][5][9]
XU3492 INV1S $PINS O=n3787 I=forward_sum[3][3][9]
XU3493 INV1S $PINS O=n3668 I=forward_sum[3][7][9]
XU3494 INV1S $PINS O=n4046 I=forward_sum[3][4][2]
XU3495 INV1S $PINS O=n4151 I=forward_sum[3][0][2]
XU3496 INV1S $PINS O=n4103 I=forward_sum[3][0][6]
XU3497 INV1S $PINS O=n3907 I=forward_sum[3][4][6]
XU3498 INV1S $PINS O=n4041 I=forward_sum[3][2][2]
XU3499 INV1S $PINS O=n3895 I=forward_sum[3][2][6]
XU3500 INV1S $PINS O=n3836 I=forward_sum[3][6][2]
XU3501 INV1S $PINS O=n3703 I=forward_sum[3][6][6]
XU3502 INV1S $PINS O=n4169 I=forward_sum[3][1][0]
XU3503 INV1S $PINS O=n4091 I=forward_sum[3][5][0]
XU3504 INV1S $PINS O=n4074 I=forward_sum[3][3][0]
XU3505 INV1S $PINS O=n3873 I=forward_sum[3][7][0]
XU3506 INV1S $PINS O=n5518 I=N354
XU3507 INV1S $PINS O=n5469 I=n4281
XU3508 INV1S $PINS O=n5461 I=n4257
XU3509 INV1S $PINS O=n3948 I=forward_sum[3][1][11]
XU3510 INV1S $PINS O=n3955 I=forward_sum[5][0][11]
XU3511 INV1S $PINS O=n3951 I=forward_sum[2][1][11]
XU3512 INV1S $PINS O=n3733 I=forward_sum[1][4][11]
XU3513 INV1S $PINS O=n3747 I=forward_sum[1][2][11]
XU3514 INV1S $PINS O=n3648 I=forward_sum[1][6][11]
XU3515 INV1S $PINS O=n3734 I=forward_sum[4][4][11]
XU3516 INV1S $PINS O=n3748 I=forward_sum[4][2][11]
XU3517 INV1S $PINS O=n3649 I=forward_sum[4][6][11]
XU3518 INV1S $PINS O=n3727 I=forward_sum[2][5][11]
XU3519 INV1S $PINS O=n3741 I=forward_sum[2][3][11]
XU3520 INV1S $PINS O=n3642 I=forward_sum[2][7][11]
XU3521 INV1S $PINS O=n3736 I=forward_sum[3][4][11]
XU3522 INV1S $PINS O=n3750 I=forward_sum[3][2][11]
XU3523 INV1S $PINS O=n3651 I=forward_sum[3][6][11]
XU3524 INV1S $PINS O=n3729 I=forward_sum[3][5][11]
XU3525 INV1S $PINS O=n3743 I=forward_sum[3][3][11]
XU3526 INV1S $PINS O=n3644 I=forward_sum[3][7][11]
XU3527 INV1S $PINS O=n3751 I=forward_sum[5][2][11]
XU3528 INV1S $PINS O=n3652 I=forward_sum[5][6][11]
XU3529 INV1S $PINS O=n3737 I=forward_sum[5][4][11]
XU3530 INV1S $PINS O=n3735 I=forward_sum[6][4][11]
XU3531 INV1S $PINS O=n3749 I=forward_sum[6][2][11]
XU3532 INV1S $PINS O=n3650 I=forward_sum[6][6][11]
XU3533 INV1S $PINS O=n3728 I=forward_sum[6][5][11]
XU3534 INV1S $PINS O=n3742 I=forward_sum[6][3][11]
XU3535 INV1S $PINS O=n3643 I=forward_sum[6][7][11]
XU3536 INV1S $PINS O=n4163 I=forward_sum[3][0][1]
XU3537 INV1S $PINS O=n4127 I=forward_sum[3][0][4]
XU3538 INV1S $PINS O=n4085 I=forward_sum[3][4][1]
XU3539 INV1S $PINS O=n4069 I=forward_sum[3][2][1]
XU3540 INV1S $PINS O=n4029 I=forward_sum[3][1][8]
XU3541 INV1S $PINS O=n3936 I=forward_sum[3][4][5]
XU3542 INV1S $PINS O=n3918 I=forward_sum[3][2][5]
XU3543 INV1S $PINS O=n4035 I=forward_sum[3][0][8]
XU3544 INV1S $PINS O=n4115 I=forward_sum[3][0][5]
XU3545 INV1S $PINS O=n3976 I=forward_sum[3][4][4]
XU3546 INV1S $PINS O=n3969 I=forward_sum[3][2][4]
XU3547 INV1S $PINS O=n3713 I=forward_sum[3][6][5]
XU3548 INV1S $PINS O=n3868 I=forward_sum[3][6][1]
XU3549 INV1S $PINS O=n3847 I=forward_sum[3][4][8]
XU3550 INV1S $PINS O=n3831 I=forward_sum[3][2][8]
XU3551 INV1S $PINS O=n3683 I=forward_sum[3][6][8]
XU3552 INV1S $PINS O=n3841 I=forward_sum[3][5][8]
XU3553 INV1S $PINS O=n3826 I=forward_sum[3][3][8]
XU3554 INV1S $PINS O=n3678 I=forward_sum[3][7][8]
XU3555 INV1S $PINS O=n3766 I=forward_sum[3][6][4]
XU3556 INV1S $PINS O=n4175 I=forward_sum[3][0][0]
XU3557 INV1S $PINS O=n4183 I=forward_sum[3][4][0]
XU3558 INV1S $PINS O=n4188 I=forward_sum[3][2][0]
XU3559 INV1S $PINS O=n4216 I=forward_sum[3][6][0]
XU3560 AN2 $PINS O=n997 I1=n998 I2=n996
XU3561 INV1S $PINS O=n4223 I=n4182
XU3562 OAI22S $PINS O=n3095 A1=n982 A2=n1004 B1=n5516 B2=n1003
XU3563 AN2 $PINS O=n1559 I1=n1442 I2=n5510
XU3564 INV1S $PINS O=n4177 I=forward_sum[2][0][0]
XU3565 INV1S $PINS O=n4185 I=forward_sum[2][4][0]
XU3566 INV1S $PINS O=n4191 I=forward_sum[2][2][0]
XU3567 INV1S $PINS O=n4220 I=forward_sum[2][6][0]
XU3568 INV1S $PINS O=n4172 I=forward_sum[2][1][0]
XU3569 INV1S $PINS O=n4094 I=forward_sum[2][5][0]
XU3570 INV1S $PINS O=n4076 I=forward_sum[2][3][0]
XU3571 INV1S $PINS O=n3875 I=forward_sum[2][7][0]
XU3572 OAI222S $PINS O=n3094 A1=n1001 A2=n5902 B1=n1002 B2=n925 C1=n1003
+ C2=n5517
XU3573 AOI13HS $PINS O=n1005 A1=n1002 B1=n980 B2=n870 B3=n1006
XU3574 OAI22S $PINS O=n3096 A1=n1005 A2=n5761 B1=n1002 B2=n980
XU3575 INV1S $PINS O=n5377 I=n870
XU3576 INV1S $PINS O=n4316 I=n980
XU3577 INV1S $PINS O=n3900 I=n925
XU3578 ND3 $PINS O=n996 I1=n980 I2=n870 I3=n1006
XU3579 AN2 $PINS O=n1560 I1=FE_OFN1731_FE_DBTN71_n4217 I2=n3667
XU3580 NR2 $PINS O=done_nxt I1=n1002 I2=n870
XU3581 AN2 $PINS O=n1006 I1=n925 I2=n1004
XU3582 AN2 $PINS O=n1003 I1=n1005 I2=n925
XU3583 NR2 $PINS O=n995 I1=n5902 I2=n1001
XU3584 ND3 $PINS O=n1001 I1=n5516 I2=n5761 I3=n5517
XU3585 XNR2HS $PINS O=forward_sum[0][1][11] I1=branch_metrics[0][2][11]
+ I2=branch_metrics[0][2][10]
XU3586 INV1S $PINS O=forward_sum[0][1][10] I=branch_metrics[0][2][10]
XU3587 INV1S $PINS O=forward_sum[0][2][10] I=forward_sum[0][0][10]
XU3588 INV1S $PINS O=forward_sum[0][6][10] I=forward_sum[0][4][10]
XU3589 XNR2HS $PINS O=forward_sum[0][5][11] I1=branch_metrics[0][3][11]
+ I2=branch_metrics[0][3][10]
XU3590 INV1S $PINS O=forward_sum[0][5][10] I=branch_metrics[0][3][10]
XU3591 ND3P $PINS O=N689 I1=n1632 I2=n1633 I3=n1634
XU3592 AOI22S $PINS O=n1633 A1=sys[6][0] A2=FE_OFN1374_n1441 B1=sys[5][0]
+ B2=FE_OFN1501_n1442
XU3593 AOI22S $PINS O=n1632 A1=sys[4][0] A2=FE_OFN1879_n5509 B1=sys[3][0]
+ B2=FE_OFN1712_FE_DBTN71_n4217
XU3594 ND3 $PINS O=N338 I1=n1623 I2=n1624 I3=n1625
XU3595 AOI22S $PINS O=n1624 A1=enc[6][1] A2=FE_OFN5572_n1441 B1=enc[5][1]
+ B2=FE_OFN1532_n1442
XU3596 AOI22S $PINS O=n1623 A1=enc[4][1] A2=FE_OFN1858_n5509 B1=enc[3][1]
+ B2=FE_OFN1717_FE_DBTN71_n4217
XU3597 ND3 $PINS O=N337 I1=n1626 I2=n1627 I3=n1628
XU3598 AOI22S $PINS O=n1627 A1=enc[6][2] A2=FE_OFN5572_n1441 B1=enc[5][2]
+ B2=FE_OFN1532_n1442
XU3599 AOI22S $PINS O=n1626 A1=enc[4][2] A2=FE_OFN1858_n5509 B1=enc[3][2]
+ B2=FE_OFN1717_FE_DBTN71_n4217
XU3601 AOI22S $PINS O=n1588 A1=ext[6][1] A2=FE_OFN1374_n1441 B1=ext[5][1]
+ B2=FE_OFN1501_n1442
XU3602 AOI22S $PINS O=n1587 A1=ext[4][1] A2=FE_OFN1869_n5509 B1=ext[3][1]
+ B2=FE_OFN1712_FE_DBTN71_n4217
XU3603 AOI22S $PINS O=n1641 A1=sys[4][3] A2=FE_OFN5567_n B1=sys[3][3]
+ B2=FE_OFN1707_FE_DBTN71_n4217
XU3604 ND3 $PINS O=N339 I1=n1620 I2=n1621 I3=n1622
XU3605 AOI22S $PINS O=n1621 A1=enc[6][0] A2=FE_OFN5572_n1441 B1=enc[5][0]
+ B2=FE_OFN1532_n1442
XU3606 AOI22S $PINS O=n1620 A1=enc[4][0] A2=FE_OFN1858_n5509 B1=enc[3][0]
+ B2=FE_OFN1717_FE_DBTN71_n4217
XU3608 AOI22S $PINS O=n1585 A1=ext[6][0] A2=FE_OFN1374_n1441 B1=ext[5][0]
+ B2=FE_OFN1501_n1442
XU3609 AOI22S $PINS O=n1584 A1=ext[4][0] A2=FE_OFN1869_n5509 B1=ext[3][0]
+ B2=FE_OFN1712_FE_DBTN71_n4217
XU3610 ND3 $PINS O=N327 I1=n1635 I2=n1636 I3=n1637
XU3611 AOI22S $PINS O=n1636 A1=sys[6][1] A2=FE_OFN1374_n1441 B1=sys[5][1]
+ B2=FE_OFN1501_n1442
XU3612 AOI22S $PINS O=n1635 A1=sys[4][1] A2=FE_OFN1879_n5509 B1=sys[3][1]
+ B2=FE_OFN1712_FE_DBTN71_n4217
XU3613 ND3 $PINS O=N326 I1=n1638 I2=n1639 I3=n1640
XU3614 AOI22S $PINS O=n1639 A1=sys[6][2] A2=FE_OFN1374_n1441 B1=sys[5][2]
+ B2=FE_OFN1501_n1442
XU3615 AOI22S $PINS O=n1638 A1=sys[4][2] A2=FE_OFN1869_n5509 B1=sys[3][2]
+ B2=FE_OFN1712_FE_DBTN71_n4217
XU3616 ND3 $PINS O=N325 I1=n1641 I2=n1642 I3=n1643
XU3617 AOI22S $PINS O=n1642 A1=sys[6][3] A2=FE_OFN1374_n1441 B1=sys[5][3]
+ B2=FE_OFN1501_n1442
XU3618 ND3 $PINS O=N355 I1=n1593 I2=n1594 I3=n1595
XU3619 AOI22S $PINS O=n1594 A1=ext[6][3] A2=FE_OFN1368_n1441 B1=ext[5][3]
+ B2=FE_OFN1495_n1442
XU3620 AOI22S $PINS O=n1593 A1=ext[4][3] A2=FE_OFN5567_n B1=ext[3][3]
+ B2=FE_OFN1707_FE_DBTN71_n4217
XU3621 ND3 $PINS O=N354 I1=n1596 I2=n1597 I3=n1598
XU3622 AOI22S $PINS O=n1597 A1=ext[6][4] A2=FE_OFN1368_n1441 B1=ext[5][4]
+ B2=FE_OFN1495_n1442
XU3623 AOI22S $PINS O=n1596 A1=ext[4][4] A2=FE_OFN5567_n B1=ext[3][4]
+ B2=FE_OFN1707_FE_DBTN71_n4217
XU3624 ND3 $PINS O=N356 I1=n1590 I2=n1591 I3=n1592
XU3625 AOI22S $PINS O=n1591 A1=ext[6][2] A2=FE_OFN1368_n1441 B1=ext[5][2]
+ B2=FE_OFN1495_n1442
XU3626 AOI22S $PINS O=n1590 A1=ext[4][2] A2=FE_OFN1869_n5509 B1=ext[3][2]
+ B2=FE_OFN1712_FE_DBTN71_n4217
XU3627 AOI22S $PINS O=n1629 A1=enc[4][3] A2=FE_OFN1858_n5509 B1=enc[3][3]
+ B2=FE_OFN1717_FE_DBTN71_n4217
XU3628 ND3 $PINS O=N336 I1=n1629 I2=n1630 I3=n1631
XU3629 AOI22S $PINS O=n1630 A1=enc[6][3] A2=FE_OFN5572_n1441 B1=enc[5][3]
+ B2=FE_OFN1491_n1442
XU3630 AN2 $PINS O=n1561 I1=backward_sum[0][1][3] I2=FE_OFN1829_n5419
XU3631 AN2 $PINS O=n1562 I1=backward_sum[0][3][3] I2=FE_OFN1829_n5419
XU3632 INV1S $PINS O=n5884 I=sys[2][1]
XU3633 INV1S $PINS O=n5773 I=enc[2][0]
XU3634 INV1S $PINS O=n5885 I=sys[2][0]
XU3635 INV1S $PINS O=n5880 I=sys[1][1]
XU3636 INV1S $PINS O=n5769 I=enc[1][0]
XU3637 INV1S $PINS O=n5881 I=sys[1][0]
XU3638 INV1S $PINS O=n5765 I=enc[0][0]
XU3639 INV1S $PINS O=n5877 I=sys[0][0]
XU3640 ND3 $PINS O=N415 I1=n1563 I2=n3786 I3=n3785
XU3641 ND3 $PINS O=n4281 I1=n1564 I2=n3739 I3=n3738
XU3642 ND3 $PINS O=N353 I1=n1599 I2=n1600 I3=n1601
XU3643 AOI22S $PINS O=n1600 A1=ext[6][5] A2=FE_OFN1368_n1441 B1=ext[5][5]
+ B2=FE_OFN1495_n1442
XU3644 AOI22S $PINS O=n1599 A1=ext[4][5] A2=FE_OFN5567_n B1=ext[3][5]
+ B2=FE_OFN1707_FE_DBTN71_n4217
XU3645 ND3 $PINS O=N352 I1=n1602 I2=n1603 I3=n1604
XU3646 AOI22S $PINS O=n1603 A1=ext[6][6] A2=FE_OFN5572_n1441 B1=ext[5][6]
+ B2=FE_OFN1491_n1442
XU3647 AOI22S $PINS O=n1602 A1=ext[4][6] A2=FE_OFN1859_n5509 B1=ext[3][6]
+ B2=FE_OFN1707_FE_DBTN71_n4217
XU3648 ND3 $PINS O=N351 I1=n1605 I2=n1606 I3=n1607
XU3649 AOI22S $PINS O=n1606 A1=ext[6][7] A2=FE_OFN1366_n1441 B1=ext[5][7]
+ B2=FE_OFN1486_n1442
XU3650 AOI22S $PINS O=n1605 A1=ext[4][7] A2=FE_OFN1859_n5509 B1=ext[3][7]
+ B2=FE_OFN1722_FE_DBTN71_n4217
XU3651 ND3 $PINS O=N350 I1=n1608 I2=n1609 I3=n1610
XU3652 AOI22S $PINS O=n1609 A1=ext[6][8] A2=n1441 B1=ext[5][8]
+ B2=FE_OFN1486_n1442
XU3653 AOI22S $PINS O=n1608 A1=ext[4][8] A2=FE_OFN1859_n5509 B1=ext[3][8]
+ B2=FE_OFN1722_FE_DBTN71_n4217
XU3654 AN2 $PINS O=n1565 I1=backward_sum[0][4][2] I2=FE_OFN1824_n5419
XU3655 AN2 $PINS O=n1566 I1=backward_sum[0][4][5]
+ I2=FE_OFN5612_FE_OFN1828_n5419
XU3656 AN2 $PINS O=n1567 I1=backward_sum[0][4][4] I2=FE_OFN1821_n5419
XU3657 AN2 $PINS O=n1568 I1=backward_sum[0][4][3] I2=FE_OFN1821_n5419
XU3658 AN2 $PINS O=n1569 I1=backward_sum[0][3][1] I2=FE_OFN1842_n5419
XU3659 AN2 $PINS O=n1570 I1=backward_sum[0][3][0] I2=FE_OFN5569_n
XU3660 AN2 $PINS O=n1571 I1=backward_sum[0][1][1] I2=FE_OFN1842_n5419
XU3661 AN2 $PINS O=n1572 I1=backward_sum[0][1][0] I2=FE_OFN5569_n
XU3662 AN2 $PINS O=n1573 I1=backward_sum[0][4][6] I2=FE_OFN1820_n5419
XU3663 AN2 $PINS O=n1574 I1=backward_sum[0][1][5] I2=FE_OFN1804_n5419
XU3664 AN2 $PINS O=n1575 I1=backward_sum[0][1][7] I2=FE_OFN1811_n5419
XU3665 AN2 $PINS O=n1576 I1=backward_sum[0][1][2] I2=FE_OFN1837_n5419
XU3666 AN2 $PINS O=n1577 I1=backward_sum[0][1][9] I2=FE_OFN1794_n5419
XU3667 AN2 $PINS O=n1578 I1=backward_sum[0][1][8] I2=FE_OFN1810_n5419
XU3668 AN2 $PINS O=n1579 I1=backward_sum[0][4][7] I2=FE_OFN1817_n5419
XU3669 AN2 $PINS O=n1580 I1=backward_sum[0][4][9] I2=FE_OFN1808_n5419
XU3670 AN2 $PINS O=n1581 I1=backward_sum[0][4][8] I2=FE_OFN1793_n5419
XU3671 AN2 $PINS O=n1582 I1=backward_sum[0][1][6] I2=FE_OFN1804_n5419
XU3672 AN2 $PINS O=n1583 I1=backward_sum[0][1][4] I2=FE_OFN1829_n5419
XU3673 AN2 $PINS O=n1644 I1=backward_sum[0][6][3] I2=FE_OFN5526_n
XU3674 AN2 $PINS O=n1645 I1=backward_sum[0][6][2] I2=FE_OFN1824_n5419
XU3675 AN2 $PINS O=n1646 I1=backward_sum[0][6][6] I2=FE_OFN1820_n5419
XU3676 AN2 $PINS O=n1647 I1=backward_sum[0][3][5] I2=FE_OFN1804_n5419
XU3677 AN2 $PINS O=n1648 I1=backward_sum[0][3][2] I2=FE_OFN1837_n5419
XU3678 AN2 $PINS O=n1649 I1=backward_sum[0][3][7] I2=FE_OFN1811_n5419
XU3679 AN2 $PINS O=n1650 I1=backward_sum[0][3][6] I2=FE_OFN1804_n5419
XU3680 AN2 $PINS O=n1651 I1=backward_sum[0][6][5]
+ I2=FE_OFN5612_FE_OFN1828_n5419
XU3681 AN2 $PINS O=n1652 I1=backward_sum[0][6][4] I2=FE_OFN1821_n5419
XU3682 AN2 $PINS O=n1653 I1=backward_sum[0][6][8] I2=FE_OFN1793_n5419
XU3683 AN2 $PINS O=n1654 I1=backward_sum[0][3][9] I2=FE_OFN1794_n5419
XU3684 AN2 $PINS O=n1655 I1=backward_sum[0][3][8] I2=FE_OFN1810_n5419
XU3685 AN2 $PINS O=n1656 I1=backward_sum[0][6][7] I2=FE_OFN1793_n5419
XU3686 AN2 $PINS O=n1657 I1=backward_sum[0][3][4] I2=FE_OFN1829_n5419
XU3687 AN2 $PINS O=n1658 I1=backward_sum[0][6][9] I2=FE_OFN1808_n5419
XU3688 XNR2HS $PINS O=n4332 I1=branch_metrics[6][1][11]
+ I2=FE_OFN968_branch_metrics_6__1__10
XU3689 INV1S $PINS O=n5772 I=enc[2][1]
XU3690 INV1S $PINS O=n5883 I=sys[2][2]
XU3691 INV1S $PINS O=n5771 I=enc[2][2]
XU3692 INV1S $PINS O=n5824 I=ext[2][1]
XU3693 INV1S $PINS O=n5825 I=ext[2][0]
XU3694 INV1S $PINS O=n5823 I=ext[2][2]
XU3695 INV1S $PINS O=n5822 I=ext[2][3]
XU3696 INV1S $PINS O=n5770 I=enc[2][3]
XU3697 INV1S $PINS O=n5882 I=sys[2][3]
XU3698 XNR2HS $PINS O=n5386 I1=branch_metrics[6][3][11]
+ I2=branch_metrics[6][3][10]
XU3699 INV1S $PINS O=n5768 I=enc[1][1]
XU3700 INV1S $PINS O=n5879 I=sys[1][2]
XU3701 INV1S $PINS O=n5767 I=enc[1][2]
XU3702 INV1S $PINS O=n5812 I=ext[1][1]
XU3703 INV1S $PINS O=n5813 I=ext[1][0]
XU3704 INV1S $PINS O=n5811 I=ext[1][2]
XU3705 INV1S $PINS O=n5810 I=ext[1][3]
XU3706 INV1S $PINS O=n5766 I=enc[1][3]
XU3707 INV1S $PINS O=n5878 I=sys[1][3]
XU3708 INV1S $PINS O=n5876 I=sys[0][1]
XU3709 INV1S $PINS O=n5764 I=enc[0][1]
XU3710 INV1S $PINS O=n5875 I=sys[0][2]
XU3711 INV1S $PINS O=n5763 I=enc[0][2]
XU3712 INV1S $PINS O=n5800 I=ext[0][1]
XU3713 INV1S $PINS O=n5801 I=ext[0][0]
XU3714 INV1S $PINS O=n5799 I=ext[0][2]
XU3715 INV1S $PINS O=n5798 I=ext[0][3]
XU3716 INV1S $PINS O=n5762 I=enc[0][3]
XU3717 INV1S $PINS O=n5874 I=sys[0][3]
XU3718 AN2B1S $PINS O=n1659 I1=FE_OFN1800_n5419
+ B1=FE_OFN968_branch_metrics_6__1__10
XU3719 AN2B1S $PINS O=n1660 I1=FE_OFN1800_n5419
+ B1=FE_OFN969_branch_metrics_6__3__10
XU3720 ND3 $PINS O=N349 I1=n1611 I2=n1612 I3=n1613
XU3721 AOI22S $PINS O=n1612 A1=ext[6][9] A2=FE_OFN1361_n1441 B1=ext[5][9]
+ B2=FE_OFN1482_n1442
XU3722 AOI22S $PINS O=n1611 A1=ext[4][9] A2=FE_OFN1852_n5509 B1=ext[3][9]
+ B2=FE_OFN1722_FE_DBTN71_n4217
XU3723 ND3 $PINS O=N348 I1=n1614 I2=n1615 I3=n1616
XU3724 AOI22S $PINS O=n1615 A1=ext[6][10] A2=FE_OFN1361_n1441 B1=ext[5][10]
+ B2=FE_OFN1482_n1442
XU3725 AOI22S $PINS O=n1614 A1=ext[4][10] A2=FE_OFN1847_n5509 B1=ext[3][10]
+ B2=FE_OFN1709_FE_DBTN71_n4217
XU3726 ND3 $PINS O=N347 I1=n1617 I2=n1618 I3=n1619
XU3727 AOI22S $PINS O=n1618 A1=ext[6][11] A2=FE_OFN1361_n1441 B1=ext[5][11]
+ B2=FE_OFN1482_n1442
XU3728 AOI22S $PINS O=n1617 A1=ext[4][11] A2=FE_OFN1847_n5509 B1=ext[3][11]
+ B2=FE_OFN1718_FE_DBTN71_n4217
XU3729 AN2 $PINS O=n1661 I1=backward_sum[0][6][0] I2=FE_OFN1842_n5419
XU3730 AN2 $PINS O=n1662 I1=backward_sum[0][4][0] I2=FE_OFN1842_n5419
XU3731 AN2 $PINS O=n1663 I1=backward_sum[0][6][1] I2=FE_OFN1842_n5419
XU3732 AN2 $PINS O=n1664 I1=backward_sum[0][4][1] I2=FE_OFN1842_n5419
XU3733 INV1S $PINS O=n5821 I=ext[2][4]
XU3734 INV1S $PINS O=n5820 I=ext[2][5]
XU3735 INV1S $PINS O=n5819 I=ext[2][6]
XU3736 INV1S $PINS O=n5809 I=ext[1][4]
XU3737 INV1S $PINS O=n5808 I=ext[1][5]
XU3738 INV1S $PINS O=n5807 I=ext[1][6]
XU3739 INV1S $PINS O=n5797 I=ext[0][4]
XU3740 INV1S $PINS O=n5796 I=ext[0][5]
XU3741 INV1S $PINS O=n5795 I=ext[0][6]
XU3742 XNR2HS $PINS O=n5397 I1=backward_sum[0][0][11] I2=backward_sum[0][0][10]
XU3743 XNR2HS $PINS O=n5417 I1=backward_sum[0][2][11] I2=backward_sum[0][2][10]
XU3744 MXL2HS $PINS OB=n3097 S=FE_OFN5652_FE_OFN5518_count_0 A=n998 B=n996
XU3745 INV1S $PINS O=n5398 I=backward_sum[0][0][10]
XU3746 INV1S $PINS O=n5418 I=backward_sum[0][2][10]
XU3747 INV1S $PINS O=n5818 I=ext[2][7]
XU3748 INV1S $PINS O=n5817 I=ext[2][8]
XU3749 INV1S $PINS O=n5816 I=ext[2][9]
XU3750 INV1S $PINS O=n5806 I=ext[1][7]
XU3751 INV1S $PINS O=n5805 I=ext[1][8]
XU3752 INV1S $PINS O=n5804 I=ext[1][9]
XU3753 INV1S $PINS O=n5794 I=ext[0][7]
XU3754 INV1S $PINS O=n5793 I=ext[0][8]
XU3755 INV1S $PINS O=n5792 I=ext[0][9]
XU3756 INV1S $PINS O=n5761 I=state[2]
XU3757 ND3 $PINS O=n980 I1=state[1] I2=n5761 I3=state[0]
XU3758 INV1S $PINS O=n5516 I=state[1]
XU3759 ND3 $PINS O=n925 I1=n5517 I2=n5761 I3=state[1]
XU3760 INV1S $PINS O=n5517 I=state[0]
XU3761 ND3 $PINS O=n1004 I1=n5516 I2=n5761 I3=state[0]
XU3762 INV1S $PINS O=n5815 I=ext[2][10]
XU3763 INV1S $PINS O=n5814 I=ext[2][11]
XU3764 INV1S $PINS O=n5803 I=ext[1][10]
XU3765 INV1S $PINS O=n5802 I=ext[1][11]
XU3766 INV1S $PINS O=n5791 I=ext[0][10]
XU3767 INV1S $PINS O=n5790 I=ext[0][11]
XU3782 MOAI1S $PINS O=n2972 A1=FE_OFN1343_n995 A2=n5894 B1=sys_i[7]
+ B2=FE_OFN1343_n995
XU3783 INV1S $PINS O=n5894 I=sys[5][3]
XU3786 MOAI1S $PINS O=n2970 A1=FE_OFN1327_n995 A2=n5892 B1=sys_i[9]
+ B2=FE_OFN1327_n995
XU3787 INV1S $PINS O=n5892 I=sys[4][1]
XU3788 MOAI1S $PINS O=n2969 A1=FE_OFN1323_n995 A2=n5891 B1=sys_i[10]
+ B2=FE_OFN1317_n995
XU3789 INV1S $PINS O=n5891 I=sys[4][2]
XU3790 MOAI1S $PINS O=n2968 A1=FE_OFN1314_n995 A2=n5890 B1=sys_i[11]
+ B2=FE_OFN1314_n995
XU3791 INV1S $PINS O=n5890 I=sys[4][3]
XU3792 MOAI1S $PINS O=n2967 A1=FE_OFN1327_n995 A2=n5889 B1=sys_i[12]
+ B2=FE_OFN1327_n995
XU3793 INV1S $PINS O=n5889 I=sys[3][0]
XU3794 MOAI1S $PINS O=n2966 A1=FE_OFN1323_n995 A2=n5888 B1=sys_i[13]
+ B2=FE_OFN1323_n995
XU3795 INV1S $PINS O=n5888 I=sys[3][1]
XU3796 MOAI1S $PINS O=n2965 A1=FE_OFN1323_n995 A2=n5887 B1=sys_i[14]
+ B2=FE_OFN1323_n995
XU3797 INV1S $PINS O=n5887 I=sys[3][2]
XU3798 MOAI1S $PINS O=n2964 A1=FE_OFN1311_n995 A2=n5886 B1=sys_i[15]
+ B2=FE_OFN1306_n995
XU3799 INV1S $PINS O=n5886 I=sys[3][3]
XU3800 MOAI1S $PINS O=n2963 A1=FE_OFN1354_n995 A2=n5885 B1=sys_i[16]
+ B2=FE_OFN1354_n995
XU3801 MOAI1S $PINS O=n2962 A1=FE_OFN1351_n995 A2=n5884 B1=sys_i[17]
+ B2=FE_OFN1351_n995
XU3802 MOAI1S $PINS O=n2961 A1=FE_OFN1347_n995 A2=n5883 B1=sys_i[18]
+ B2=FE_OFN1347_n995
XU3803 MOAI1S $PINS O=n2960 A1=FE_OFN1344_n995 A2=n5882 B1=sys_i[19]
+ B2=FE_OFN1344_n995
XU3804 MOAI1S $PINS O=n2959 A1=FE_OFN1350_n995 A2=n5881 B1=sys_i[20]
+ B2=FE_OFN1350_n995
XU3805 MOAI1S $PINS O=n2958 A1=FE_OFN1350_n995 A2=n5880 B1=sys_i[21]
+ B2=FE_OFN1350_n995
XU3806 MOAI1S $PINS O=n2957 A1=FE_OFN1349_n995 A2=n5879 B1=sys_i[22]
+ B2=FE_OFN1349_n995
XU3807 MOAI1S $PINS O=n2956 A1=FE_OFN1344_n995 A2=n5878 B1=sys_i[23]
+ B2=FE_OFN1344_n995
XU3808 MOAI1S $PINS O=n2955 A1=FE_OFN1353_n995 A2=n5877 B1=sys_i[24]
+ B2=FE_OFN1353_n995
XU3809 MOAI1S $PINS O=n2954 A1=FE_OFN1351_n995 A2=n5876 B1=sys_i[25]
+ B2=FE_OFN1351_n995
XU3810 MOAI1S $PINS O=n2953 A1=FE_OFN1347_n995 A2=n5875 B1=sys_i[26]
+ B2=FE_OFN1347_n995
XU3811 INV1S $PINS O=n5873 I=ext[6][0]
XU3815 INV1S $PINS O=n5869 I=ext[6][4]
XU3818 INV1S $PINS O=n5866 I=ext[6][7]
XU3819 INV1S $PINS O=n5864 I=ext[6][9]
XU3822 INV1S $PINS O=n5860 I=ext[5][1]
XU3823 INV1S $PINS O=n5859 I=ext[5][2]
XU3825 INV1S $PINS O=n5857 I=ext[5][4]
XU3827 INV1S $PINS O=n5855 I=ext[5][6]
XU3829 INV1S $PINS O=n5853 I=ext[5][8]
XU3837 MOAI1S $PINS O=n3037 A1=FE_OFN1317_n995 A2=n5847 B1=ext_i[26]
+ B2=FE_OFN1317_n995
XU3838 INV1S $PINS O=n5847 I=ext[4][2]
XU3845 MOAI1S $PINS O=n3033 A1=FE_OFN1296_n995 A2=n5843 B1=ext_i[30]
+ B2=FE_OFN1296_n995
XU3846 INV1S $PINS O=n5843 I=ext[4][6]
XU3855 MOAI1S $PINS O=n3028 A1=FE_OFN1294_n995 A2=n5838 B1=ext_i[35]
+ B2=FE_OFN1297_n995
XU3856 INV1S $PINS O=n5838 I=ext[4][11]
XU3857 MOAI1S $PINS O=n3027 A1=FE_OFN1335_n995 A2=n5837 B1=ext_i[36]
+ B2=FE_OFN1335_n995
XU3858 INV1S $PINS O=n5837 I=ext[3][0]
XU3861 MOAI1S $PINS O=n3025 A1=FE_OFN1317_n995 A2=n5835 B1=ext_i[38]
+ B2=FE_OFN1317_n995
XU3862 INV1S $PINS O=n5835 I=ext[3][2]
XU3867 MOAI1S $PINS O=n3022 A1=FE_OFN1300_n995 A2=n5832 B1=ext_i[41]
+ B2=FE_OFN1300_n995
XU3868 INV1S $PINS O=n5832 I=ext[3][5]
XU3869 MOAI1S $PINS O=n3021 A1=FE_OFN1296_n995 A2=n5831 B1=ext_i[42]
+ B2=FE_OFN1296_n995
XU3870 INV1S $PINS O=n5831 I=ext[3][6]
XU3879 MOAI1S $PINS O=n3016 A1=FE_OFN1290_n995 A2=n5826 B1=ext_i[47]
+ B2=FE_OFN1294_n995
XU3880 INV1S $PINS O=n5826 I=ext[3][11]
XU3881 MOAI1S $PINS O=n3015 A1=FE_OFN1345_n995 A2=n5825 B1=ext_i[48]
+ B2=FE_OFN1345_n995
XU3882 MOAI1S $PINS O=n3014 A1=FE_OFN1353_n995 A2=n5824 B1=ext_i[49]
+ B2=FE_OFN1353_n995
XU3883 MOAI1S $PINS O=n3013 A1=FE_OFN1342_n995 A2=n5823 B1=ext_i[50]
+ B2=FE_OFN1342_n995
XU3884 MOAI1S $PINS O=n3012 A1=FE_OFN1342_n995 A2=n5822 B1=ext_i[51]
+ B2=FE_OFN1342_n995
XU3885 MOAI1S $PINS O=n3011 A1=FE_OFN1338_n995 A2=n5821 B1=ext_i[52]
+ B2=FE_OFN1338_n995
XU3886 MOAI1S $PINS O=n3010 A1=FE_OFN1333_n995 A2=n5820 B1=ext_i[53]
+ B2=FE_OFN1333_n995
XU3887 MOAI1S $PINS O=n3009 A1=FE_OFN1329_n995 A2=n5819 B1=ext_i[54]
+ B2=FE_OFN1329_n995
XU3888 MOAI1S $PINS O=n3008 A1=FE_OFN1320_n995 A2=n5818 B1=ext_i[55]
+ B2=FE_OFN1320_n995
XU3889 MOAI1S $PINS O=n3007 A1=FE_OFN1319_n995 A2=n5817 B1=ext_i[56]
+ B2=FE_OFN1320_n995
XU3890 MOAI1S $PINS O=n3006 A1=FE_OFN1312_n995 A2=n5816 B1=ext_i[57]
+ B2=FE_OFN1308_n995
XU3891 MOAI1S $PINS O=n3005 A1=FE_OFN1302_n995 A2=n5815 B1=ext_i[58]
+ B2=FE_OFN1308_n995
XU3892 MOAI1S $PINS O=n3004 A1=FE_OFN1307_n995 A2=n5814 B1=ext_i[59]
+ B2=FE_OFN1307_n995
XU3893 MOAI1S $PINS O=n3003 A1=FE_OFN1349_n995 A2=n5813 B1=ext_i[60]
+ B2=FE_OFN1349_n995
XU3894 MOAI1S $PINS O=n2998 A1=FE_OFN1325_n995 A2=n5808 B1=ext_i[65]
+ B2=FE_OFN1325_n995
XU3895 MOAI1S $PINS O=n2996 A1=FE_OFN1319_n995 A2=n5806 B1=ext_i[67]
+ B2=FE_OFN1319_n995
XU3896 MOAI1S $PINS O=n2995 A1=FE_OFN1319_n995 A2=n5805 B1=ext_i[68]
+ B2=FE_OFN1319_n995
XU3897 MOAI1S $PINS O=n2994 A1=FE_OFN1312_n995 A2=n5804 B1=ext_i[69]
+ B2=FE_OFN1312_n995
XU3898 MOAI1S $PINS O=n2993 A1=FE_OFN1297_n995 A2=n5803 B1=ext_i[70]
+ B2=FE_OFN1297_n995
XU3899 MOAI1S $PINS O=n2992 A1=FE_OFN1297_n995 A2=n5802 B1=ext_i[71]
+ B2=FE_OFN1302_n995
XU3900 MOAI1S $PINS O=n2991 A1=FE_OFN1345_n995 A2=n5801 B1=ext_i[72]
+ B2=FE_OFN1345_n995
XU3901 MOAI1S $PINS O=n2990 A1=FE_OFN1353_n995 A2=n5800 B1=ext_i[73]
+ B2=FE_OFN1353_n995
XU3902 MOAI1S $PINS O=n2989 A1=FE_OFN1345_n995 A2=n5799 B1=ext_i[74]
+ B2=FE_OFN1345_n995
XU3903 MOAI1S $PINS O=n2988 A1=FE_OFN1338_n995 A2=n5798 B1=ext_i[75]
+ B2=FE_OFN1342_n995
XU3904 MOAI1S $PINS O=n2987 A1=FE_OFN1333_n995 A2=n5797 B1=ext_i[76]
+ B2=FE_OFN1333_n995
XU3905 MOAI1S $PINS O=n2986 A1=FE_OFN1329_n995 A2=n5796 B1=ext_i[77]
+ B2=FE_OFN1329_n995
XU3906 MOAI1S $PINS O=n2985 A1=FE_OFN1325_n995 A2=n5795 B1=ext_i[78]
+ B2=FE_OFN1329_n995
XU3907 MOAI1S $PINS O=n2984 A1=FE_OFN1320_n995 A2=n5794 B1=ext_i[79]
+ B2=FE_OFN1320_n995
XU3908 MOAI1S $PINS O=n2983 A1=FE_OFN1312_n995 A2=n5793 B1=ext_i[80]
+ B2=FE_OFN1312_n995
XU3909 MOAI1S $PINS O=n2982 A1=FE_OFN1308_n995 A2=n5792 B1=ext_i[81]
+ B2=FE_OFN1308_n995
XU3910 MOAI1S $PINS O=n2981 A1=FE_OFN1307_n995 A2=n5791 B1=ext_i[82]
+ B2=FE_OFN1307_n995
XU3911 MOAI1S $PINS O=n2980 A1=FE_OFN1307_n995 A2=n5790 B1=ext_i[83]
+ B2=FE_OFN1307_n995
XU3928 MOAI1S $PINS O=n3085 A1=FE_OFN1313_n995 A2=n5781 B1=enc_i[8]
+ B2=FE_OFN1309_n995
XU3929 INV1S $PINS O=n5781 I=enc[4][0]
XU3932 MOAI1S $PINS O=n3083 A1=FE_OFN1295_n995 A2=n5779 B1=enc_i[10]
+ B2=FE_OFN1295_n995
XU3933 INV1S $PINS O=n5779 I=enc[4][2]
XU3934 MOAI1S $PINS O=n3082 A1=FE_OFN1292_n995 A2=n5778 B1=enc_i[11]
+ B2=FE_OFN1292_n995
XU3935 INV1S $PINS O=n5778 I=enc[4][3]
XU3940 MOAI1S $PINS O=n3079 A1=FE_OFN1304_n995 A2=n5775 B1=enc_i[14]
+ B2=FE_OFN1304_n995
XU3941 INV1S $PINS O=n5775 I=enc[3][2]
XU3944 MOAI1S $PINS O=n3077 A1=FE_OFN1324_n995 A2=n5773 B1=enc_i[16]
+ B2=FE_OFN1324_n995
XU3945 MOAI1S $PINS O=n3076 A1=FE_OFN1324_n995 A2=n5772 B1=enc_i[17]
+ B2=FE_OFN1324_n995
XU3946 MOAI1S $PINS O=n3075 A1=FE_OFN1318_n995 A2=n5771 B1=enc_i[18]
+ B2=FE_OFN1318_n995
XU3947 MOAI1S $PINS O=n3074 A1=FE_OFN1326_n995 A2=n5770 B1=enc_i[19]
+ B2=FE_OFN1326_n995
XU3948 MOAI1S $PINS O=n3073 A1=FE_OFN1330_n995 A2=n5769 B1=enc_i[20]
+ B2=FE_OFN1330_n995
XU3949 MOAI1S $PINS O=n3072 A1=FE_OFN1330_n995 A2=n5768 B1=enc_i[21]
+ B2=FE_OFN1330_n995
XU3950 MOAI1S $PINS O=n3071 A1=FE_OFN1330_n995 A2=n5767 B1=enc_i[22]
+ B2=FE_OFN1326_n995
XU3951 MOAI1S $PINS O=n3070 A1=FE_OFN1326_n995 A2=n5766 B1=enc_i[23]
+ B2=FE_OFN1326_n995
XU3952 MOAI1S $PINS O=n3069 A1=FE_OFN1339_n995 A2=n5765 B1=enc_i[24]
+ B2=FE_OFN1339_n995
XU3953 MOAI1S $PINS O=n3068 A1=FE_OFN1339_n995 A2=n5764 B1=enc_i[25]
+ B2=FE_OFN1339_n995
XU3954 MOAI1S $PINS O=n3067 A1=FE_OFN1334_n995 A2=n5763 B1=enc_i[26]
+ B2=FE_OFN1334_n995
XU3955 MOAI1S $PINS O=n3066 A1=FE_OFN1334_n995 A2=n5762 B1=enc_i[27]
+ B2=FE_OFN1334_n995
XU3956 MOAI1S $PINS O=n2952 A1=FE_OFN1341_n995 A2=n5874 B1=sys_i[27]
+ B2=FE_OFN1341_n995
XU3957 MOAI1S $PINS O=n3002 A1=FE_OFN1354_n995 A2=n5812 B1=ext_i[61]
+ B2=FE_OFN1354_n995
XU3958 MOAI1S $PINS O=n3001 A1=FE_OFN1349_n995 A2=n5811 B1=ext_i[62]
+ B2=FE_OFN1349_n995
XU3959 MOAI1S $PINS O=n3000 A1=FE_OFN1341_n995 A2=n5810 B1=ext_i[63]
+ B2=FE_OFN1341_n995
XU3960 MOAI1S $PINS O=n2999 A1=FE_OFN1338_n995 A2=n5809 B1=ext_i[64]
+ B2=FE_OFN1341_n995
XU3961 MOAI1S $PINS O=n2997 A1=FE_OFN1325_n995 A2=n5807 B1=ext_i[66]
+ B2=FE_OFN1325_n995
XU3964 INV1S $PINS O=n5902 I=read_en_i
XU3965 AN2 $PINS O=n3626 I1=FE_OFN2055_N357 I2=n3627
XU3966 OAI22S $PINS O=n3807 A1=N357 A2=n3627 B1=n3626 B2=n1498
XU3967 MAO222 $PINS O=sub_0_root_sub_185_2/carry[5] A1=n5518 B1=n3718 C1=N1044
XU3968 AN2 $PINS O=n3630 I1=FE_OFN2055_N357 I2=n3631
XU3969 OAI22S $PINS O=n4010 A1=FE_OFN2055_N357 A2=n3631 B1=n3630 B2=n1499
XU3970 MAO222 $PINS O=sub_0_root_sub_182_3/carry[5] A1=n5518 B1=n3929 C1=N698
XU3971 MAO222 $PINS O=n3772 A1=N356 B1=n3813 C1=N812
XU3972 MAO222 $PINS O=n3724 A1=FE_OFN2053_N355 B1=n3772 C1=N813
XU3973 MAO222 $PINS O=add_0_root_add_183_2/carry[5] A1=N354 B1=n3724 C1=n1444
XU3974 AN2 $PINS O=n3634 I1=N338 I2=n3635
XU3975 OAI22S $PINS O=n4004 A1=N338 A2=n3635 B1=n3634 B2=n1500
XU3976 AN2 $PINS O=n3639 I1=FE_OFN2052_N336 I2=n3638
XU3977 OAI22S $PINS O=sub_0_root_sub_0_root_add_184/carry[5] A1=n3640 A2=n3639
+ B1=FE_OFN2052_N336 B2=n3638
XU3978 OAI22S $PINS O=n3065 A1=n999 A2=n5510 B1=n1000 B2=n998
XU3979 ND2 $PINS O=n4217 I1=FE_OFN5518_count_0 I2=count[1]
XU3980 OAI22S $PINS O=n3064 A1=n998 A2=n4217 B1=n997 B2=n3667
XU3981 MUX2 $PINS O=n2618 S=FE_OFN2126_n1519 A=forward_sum[0][2][9]
+ B=FE_OFN2190_N709
XU3982 MUX2 $PINS O=n2640 S=FE_OFN2126_n1519 A=branch_metrics[0][2][11]
+ B=FE_OFN2173_N941
XU3983 MUX2 $PINS O=n2641 S=FE_OFN2126_n1519 A=branch_metrics[0][2][10]
+ B=FE_OFN2172_N940
XU3984 MUX2 $PINS O=n2652 S=FE_OFN2124_n1519 A=branch_metrics[0][3][11]
+ B=FE_OFN2180_N1057
XU3985 MUX2 $PINS O=n2653 S=FE_OFN2124_n1519 A=branch_metrics[0][3][10]
+ B=FE_OFN2179_N1056
XU3986 ND2 $PINS O=n3726 I1=forward_sum[0][5][11] I2=FE_OFN1795_n5419
XU3987 AOI22S $PINS O=n3641 A1=forward_sum[1][7][11]
+ A2=FE_OFN1591_FE_DBTN86_n985 B1=forward_sum[4][7][11] B2=FE_OFN1844_n5509
XU3988 OA112 $PINS O=n3647 A1=n3726 B1=n3641 C1=FE_OFN1456_n987 C2=n3642
XU3989 OA222 $PINS O=n3646 A1=FE_DBTN72_n3966 A2=n3645 B1=FE_OFN1569_n4217
+ B2=n3644 C1=FE_OFN1433_FE_DBTN75_n1441 C2=n3643
XU3990 ND2 $PINS O=N450 I1=n3647 I2=n3646
XU3991 XOR2HS $PINS O=forward_sum[0][6][11] I1=forward_sum[0][6][10]
+ I2=forward_sum[0][4][11]
XU3992 AOI22S $PINS O=n3654 A1=forward_sum[0][6][11] A2=FE_OFN1792_n5419
+ B1=forward_sum[2][6][11] B2=FE_OFN1682_FE_DBTN85_n987
XU3993 OA222 $PINS O=n3653 A1=FE_DBTN72_n3966 A2=n3652 B1=FE_OFN1569_n4217
+ B2=n3651 C1=FE_OFN1433_FE_DBTN75_n1441 C2=n3650
XU3994 MUX2 $PINS O=n4252 S=FE_DBTN91_n1503 A=N450 B=n4293
XU3995 MUX2 $PINS O=n2076 S=FE_OFN1979_n1530 A=forward_metrics[1][3][11]
+ B=n4252
XU3996 ND2 $PINS O=n3774 I1=FE_OFN1792_n5419 I2=forward_sum[0][5][10]
XU3997 AOI22S $PINS O=n3655 A1=forward_sum[1][7][10]
+ A2=FE_OFN1594_FE_DBTN86_n985 B1=forward_sum[4][7][10] B2=FE_OFN1844_n5509
XU3998 OA112 $PINS O=n3660 A1=n3774 B1=n3655 C1=FE_OFN1456_n987 C2=n3656
XU3999 OA222 $PINS O=n3659 A1=FE_OFN1435_FE_DBTN72_n3966 A2=n3658
+ B1=FE_OFN1568_n4217 B2=n3657 C1=FE_OFN1433_FE_DBTN75_n1441 C2=n4980
XU4000 ND2 $PINS O=n4295 I1=n3660 I2=n3659
XU4001 AOI22S $PINS O=n3666 A1=FE_OFN1792_n5419 A2=forward_sum[0][6][10]
+ B1=forward_sum[2][6][10] B2=FE_OFN1682_FE_DBTN85_n987
XU4002 OA222 $PINS O=n3665 A1=FE_DBTN72_n3966 A2=n3664 B1=FE_OFN1569_n4217
+ B2=n3663 C1=FE_DBTN75_n1441 C2=n4544
XU4003 MUX2 $PINS O=n4241 S=FE_DBTN91_n1503 A=n4295 B=N439
XU4004 MUX2 $PINS O=n2077 S=FE_OFN1979_n1530 A=forward_metrics[1][3][10]
+ B=n4241
XU4005 MUX2 $PINS O=n2654 S=n1519 A=forward_sum[0][5][9] B=N1055
XU4006 MUX2 $PINS O=n2220 S=FE_OFN2013_n1533 A=forward_metrics[4][3][11]
+ B=n4252
XU4007 MUX2 $PINS O=n2221 S=FE_OFN2013_n1533 A=forward_metrics[4][3][10]
+ B=n4241
XU4008 ND2 $PINS O=n4956 I1=LLR_sum[6][3][9] I2=FE_OFN1370_n1441
XU4009 OAI12HS $PINS O=n3672 A1=n4956 B1=FE_OFN1571_n4217 B2=n3668
XU4010 ND2 $PINS O=n3816 I1=FE_OFN990_forward_sum_0__5__9 I2=FE_OFN1806_n5419
XU4011 AOI22S $PINS O=n3669 A1=forward_sum[1][7][9]
+ A2=FE_OFN1590_FE_DBTN86_n985 B1=forward_sum[4][7][9] B2=FE_OFN5511_n
XU4012 OAI112HS $PINS O=n3671 A1=n3816 B1=n3669 C1=FE_OFN1458_n987 C2=n3670
XU4013 AO112 $PINS O=n4292 A1=n3672 B1=n3671 C1=forward_sum[5][7][9]
+ C2=FE_OFN1490_n1442
XU4014 ND2 $PINS O=n4522 I1=LLR_sum[6][6][9] I2=FE_OFN1370_n1441
XU4015 OAI12HS $PINS O=n3677 A1=n4522 B1=FE_OFN1737_FE_DBTN71_n4217 B2=n3673
XU4016 ND2 $PINS O=n3822 I1=FE_OFN1000_forward_sum_0__6__9 I2=FE_OFN1806_n5419
XU4017 AOI22S $PINS O=n3674 A1=forward_sum[1][6][9]
+ A2=FE_OFN1590_FE_DBTN86_n985 B1=forward_sum[4][6][9] B2=FE_OFN1851_n5509
XU4018 OAI112HS $PINS O=n3676 A1=n3822 B1=n3674 C1=FE_OFN1458_n987 C2=n3675
XU4019 AO112 $PINS O=N440 A1=n3677 B1=n3676 C1=forward_sum[5][6][9]
+ C2=FE_OFN1490_n1442
XU4020 MUX2 $PINS O=n4242 S=FE_OFN508_FE_DBTN91_n1503 A=n4292 B=N440
XU4021 MUX2 $PINS O=n2222 S=FE_OFN2013_n1533 A=forward_metrics[4][3][9] B=n4242
XU4022 MUX2 $PINS O=n2655 S=FE_OFN2123_n1519 A=forward_sum[0][5][8] B=N1054
XU4023 MUX2 $PINS O=n2172 S=FE_OFN1969_n1529 A=forward_metrics[3][3][11]
+ B=n4252
XU4024 MUX2 $PINS O=n2173 S=FE_OFN1969_n1529 A=forward_metrics[3][3][10]
+ B=n4241
XU4025 MUX2 $PINS O=n2174 S=n1529 A=forward_metrics[3][3][9] B=n4242
XU4026 ND2 $PINS O=n4974 I1=LLR_sum[6][3][8] I2=FE_OFN1377_n1441
XU4027 OAI12HS $PINS O=n3682 A1=n4974 B1=FE_OFN1571_n4217 B2=n3678
XU4028 ND2 $PINS O=n3843 I1=FE_OFN991_forward_sum_0__5__8 I2=FE_OFN1798_n5419
XU4029 AOI22S $PINS O=n3679 A1=forward_sum[1][7][8] A2=FE_OFN1454_n985
+ B1=forward_sum[4][7][8] B2=FE_OFN1861_n5509
XU4030 OAI112HS $PINS O=n3681 A1=n3843 B1=n3679 C1=FE_OFN1462_n987 C2=n3680
XU4031 AO112 $PINS O=n4294 A1=n3682 B1=n3681 C1=forward_sum[5][7][8]
+ C2=FE_OFN1492_n1442
XU4032 ND2 $PINS O=n4528 I1=LLR_sum[6][6][8] I2=FE_OFN1377_n1441
XU4033 OAI12HS $PINS O=n3687 A1=n4528 B1=FE_OFN1571_n4217 B2=n3683
XU4034 ND2 $PINS O=n3849 I1=FE_OFN1001_forward_sum_0__6__8 I2=FE_OFN1797_n5419
XU4035 AOI22S $PINS O=n3684 A1=forward_sum[1][6][8] A2=FE_OFN1454_n985
+ B1=forward_sum[4][6][8] B2=FE_OFN1862_n5509
XU4036 OAI112HS $PINS O=n3686 A1=n3849 B1=n3684 C1=FE_OFN1462_n987 C2=n3685
XU4037 AO112 $PINS O=N441 A1=n3687 B1=n3686 C1=forward_sum[5][6][8]
+ C2=FE_OFN1492_n1442
XU4038 MUX2 $PINS O=n4243 S=FE_OFN508_FE_DBTN91_n1503 A=n4294 B=N441
XU4039 MUX2 $PINS O=n2175 S=FE_OFN1968_n1529 A=forward_metrics[3][3][8] B=n4243
XU4040 MUX2 $PINS O=n2656 S=FE_OFN2125_n1519 A=forward_sum[0][5][7] B=N1053
XU4041 MUX2 $PINS O=n2316 S=FE_OFN1775_n1527 A=forward_metrics[6][3][11]
+ B=n4252
XU4042 MUX2 $PINS O=n2317 S=FE_OFN1773_n1527 A=forward_metrics[6][3][10]
+ B=n4241
XU4043 MUX2 $PINS O=n2318 S=FE_OFN1773_n1527 A=forward_metrics[6][3][9] B=n4242
XU4044 MUX2 $PINS O=n2319 S=FE_OFN1774_n1527 A=forward_metrics[6][3][8] B=n4243
XU4045 ND2 $PINS O=n4995 I1=LLR_sum[6][3][7] I2=FE_OFN1395_n1441
XU4046 OAI12HS $PINS O=n3692 A1=n4995 B1=FE_OFN1576_n4217 B2=n3688
XU4047 ND2 $PINS O=n3880 I1=FE_OFN992_forward_sum_0__5__7 I2=FE_OFN1799_n5419
XU4048 AOI22S $PINS O=n3689 A1=forward_sum[1][7][7] A2=FE_OFN5521_n
+ B1=forward_sum[4][7][7] B2=FE_OFN1861_n5509
XU4049 OAI112HS $PINS O=n3691 A1=n3880 B1=n3689 C1=FE_OFN1462_n987 C2=n3690
XU4050 AO112 $PINS O=n4296 A1=n3692 B1=n3691 C1=forward_sum[5][7][7]
+ C2=FE_OFN1498_n1442
XU4051 ND2 $PINS O=n4561 I1=LLR_sum[6][6][7] I2=FE_OFN1395_n1441
XU4052 OAI12HS $PINS O=n3697 A1=n4561 B1=FE_OFN1576_n4217 B2=n3693
XU4053 ND2 $PINS O=n3886 I1=FE_OFN1002_forward_sum_0__6__7 I2=FE_OFN1799_n5419
XU4054 AOI22S $PINS O=n3694 A1=forward_sum[1][6][7]
+ A2=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985 B1=forward_sum[4][6][7]
+ B2=FE_OFN1882_n5509
XU4055 OAI112HS $PINS O=n3696 A1=n3886 B1=n3694 C1=FE_OFN1471_n987 C2=n3695
XU4056 AO112 $PINS O=N442 A1=n3697 B1=n3696 C1=forward_sum[5][6][7]
+ C2=FE_OFN1513_n1442
XU4057 MUX2 $PINS O=n4244 S=FE_OFN508_FE_DBTN91_n1503 A=n4296 B=N442
XU4058 MUX2 $PINS O=n2320 S=FE_OFN1777_n1527 A=forward_metrics[6][3][7] B=n4244
XU4059 MUX2 $PINS O=n2657 S=FE_OFN2125_n1519 A=FE_OFN993_forward_sum_0__5__6
+ B=N1052
XU4060 MUX2 $PINS O=n2268 S=FE_OFN1954_n1528 A=forward_metrics[5][3][11]
+ B=n4252
XU4061 MUX2 $PINS O=n2269 S=FE_OFN1954_n1528 A=forward_metrics[5][3][10]
+ B=n4241
XU4062 MUX2 $PINS O=n2270 S=n1528 A=forward_metrics[5][3][9] B=n4242
XU4063 MUX2 $PINS O=n2271 S=FE_OFN1953_n1528 A=forward_metrics[5][3][8] B=n4243
XU4064 MUX2 $PINS O=n2272 S=FE_OFN1958_n1528 A=forward_metrics[5][3][7] B=n4244
XU4065 ND2 $PINS O=n5013 I1=LLR_sum[6][3][6] I2=FE_OFN1396_n1441
XU4066 OAI12HS $PINS O=n3702 A1=FE_OFN2223_n5013 B1=FE_OFN1578_n4217 B2=n3698
XU4067 ND2 $PINS O=n3903 I1=FE_OFN993_forward_sum_0__5__6 I2=FE_OFN1799_n5419
XU4068 AOI22S $PINS O=n3699 A1=forward_sum[1][7][6]
+ A2=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985 B1=forward_sum[4][7][6]
+ B2=FE_OFN5615_FE_OFN1882_n5509
XU4069 OAI112HS $PINS O=n3701 A1=n3903 B1=n3699 C1=FE_OFN1476_n987 C2=n3700
XU4070 AO112 $PINS O=N455 A1=n3702 B1=n3701 C1=forward_sum[5][7][6]
+ C2=FE_OFN1513_n1442
XU4071 ND2S $PINS O=n4567 I1=LLR_sum[6][6][6] I2=FE_OFN1404_n1441
XU4072 OAI12HS $PINS O=n3707 A1=FE_OFN2219_n4567 B1=FE_OFN1576_n4217 B2=n3703
XU4073 ND2 $PINS O=n3909 I1=FE_OFN1003_forward_sum_0__6__6 I2=FE_OFN1799_n5419
XU4074 AOI22S $PINS O=n3704 A1=forward_sum[1][6][6]
+ A2=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985 B1=forward_sum[4][6][6]
+ B2=FE_OFN5615_FE_OFN1882_n5509
XU4075 OAI112HS $PINS O=n3706 A1=n3909 B1=n3704 C1=FE_OFN1471_n987 C2=n3705
XU4076 AO112 $PINS O=n4297 A1=n3707 B1=n3706 C1=forward_sum[5][6][6]
+ C2=FE_OFN1513_n1442
XU4077 MUX2 $PINS O=n4245 S=FE_OFN508_FE_DBTN91_n1503 A=N455 B=n4297
XU4078 MUX2 $PINS O=n2658 S=FE_OFN2125_n1519 A=forward_sum[0][5][5] B=N1051
XU4079 MUX2 $PINS O=n2634 S=FE_OFN2127_n1519 A=forward_sum[0][6][5] B=N820
XU4080 MUX2 $PINS O=n2079 S=FE_OFN1980_n1530 A=forward_metrics[1][3][8] B=n4243
XU4081 MUX2 $PINS O=n2080 S=FE_OFN1982_n1530 A=forward_metrics[1][3][7] B=n4244
XU4082 ND2S $PINS O=n5019 I1=LLR_sum[6][3][5] I2=FE_OFN5540_n
XU4083 OAI12HS $PINS O=n3712 A1=FE_OFN2216_n5019 B1=FE_OFN1578_n4217 B2=n3708
XU4084 ND2 $PINS O=n3932 I1=FE_OFN994_forward_sum_0__5__5 I2=FE_OFN1818_n5419
XU4085 AOI22S $PINS O=n3709 A1=forward_sum[1][7][5] A2=FE_OFN5550_n
+ B1=forward_sum[4][7][5] B2=FE_OFN1884_n5509
XU4086 OAI112HS $PINS O=n3711 A1=n3932 B1=n3709 C1=FE_OFN1476_n987 C2=n3710
XU4087 AO112 $PINS O=n4302 A1=n3712 B1=n3711 C1=forward_sum[5][7][5]
+ C2=FE_OFN5545_n
XU4088 ND2 $PINS O=n4585 I1=LLR_sum[6][6][5] I2=FE_OFN5540_n
XU4089 OAI12HS $PINS O=n3717 A1=n4585 B1=FE_OFN1578_n4217 B2=n3713
XU4090 ND2 $PINS O=n3938 I1=FE_OFN1004_forward_sum_0__6__5 I2=FE_OFN1818_n5419
XU4091 AOI22S $PINS O=n3714 A1=forward_sum[1][6][5] A2=FE_OFN5550_n
+ B1=forward_sum[4][6][5] B2=FE_OFN1884_n5509
XU4092 OAI112HS $PINS O=n3716 A1=n3938 B1=n3714 C1=FE_OFN1476_n987 C2=n3715
XU4093 AO112 $PINS O=N444 A1=n3717 B1=n3716 C1=forward_sum[5][6][5]
+ C2=FE_OFN5544_n
XU4094 MUX2 $PINS O=n4246 S=FE_OFN509_FE_DBTN91_n1503 A=n4302 B=N444
XU4095 XOR3 $PINS O=n4239 I1=N1044 I2=n5518 I3=n3718
XU4096 MUX2 $PINS O=n2659 S=FE_OFN2127_n1519 A=forward_sum[0][5][4] B=n4239
XU4097 ND2 $PINS O=n5037 I1=LLR_sum[6][3][4] I2=FE_OFN1398_n1441
XU4098 OAI12HS $PINS O=n3723 A1=n5037 B1=FE_OFN1578_n4217 B2=n3719
XU4099 ND2 $PINS O=n3944 I1=FE_OFN995_forward_sum_0__5__4 I2=FE_OFN1829_n5419
XU4100 AOI22S $PINS O=n3720 A1=forward_sum[1][7][4]
+ A2=FE_OFN1602_FE_DBTN86_n985 B1=forward_sum[4][7][4] B2=FE_OFN1872_n5509
XU4101 OAI112HS $PINS O=n3722 A1=n3944 B1=n3720 C1=FE_OFN1476_n987 C2=n3721
XU4102 AO112 $PINS O=N457 A1=n3723 B1=n3722 C1=forward_sum[5][7][4]
+ C2=FE_OFN1522_n1442
XU4103 MUX2 $PINS O=n2635 S=FE_OFN2127_n1519 A=forward_sum[0][6][4] B=n4205
XU4104 AOI22S $PINS O=n3725 A1=forward_sum[1][5][11]
+ A2=FE_OFN1594_FE_DBTN86_n985 B1=forward_sum[4][5][11] B2=FE_OFN1854_n5509
XU4105 OA112 $PINS O=n3732 A1=n3726 B1=n3725 C1=FE_OFN1456_n987 C2=n3727
XU4106 OA222 $PINS O=n3731 A1=FE_OFN1435_FE_DBTN72_n3966 A2=n3730
+ B1=FE_OFN1568_n4217 B2=n3729 C1=FE_OFN1434_FE_DBTN75_n1441 C2=n3728
XU4107 ND2 $PINS O=N426 I1=n3732 I2=n3731
XU4108 AOI22S $PINS O=n3739 A1=forward_sum[0][4][11] A2=FE_OFN1800_n5419
+ B1=forward_sum[2][4][11] B2=FE_OFN5665_n
XU4109 OA222 $PINS O=n3738 A1=FE_OFN1435_FE_DBTN72_n3966 A2=n3737
+ B1=FE_OFN1568_n4217 B2=n3736 C1=FE_OFN1434_FE_DBTN75_n1441 C2=n3735
XU4110 MUX2 $PINS O=n4240 S=FE_DBTN92_n1501 A=N426 B=n4281
XU4111 MUX2 $PINS O=n2064 S=FE_OFN1981_n1530 A=forward_metrics[1][2][11]
+ B=n4240
XU4112 ND2 $PINS O=n3950 I1=forward_sum[0][1][11] I2=FE_OFN1814_n5419
XU4113 AOI22S $PINS O=n3740 A1=forward_sum[1][3][11]
+ A2=FE_OFN5587_FE_OFN1620_FE_DBTN86_n985 B1=forward_sum[4][3][11]
+ B2=FE_OFN1877_n5509
XU4114 OA112 $PINS O=n3746 A1=n3950 B1=n3740 C1=FE_OFN1463_n987 C2=n3741
XU4115 OA222 $PINS O=n3745 A1=FE_OFN1436_FE_DBTN72_n3966 A2=n3744
+ B1=FE_OFN1574_n4217 B2=n3743 C1=FE_OFN1434_FE_DBTN75_n1441 C2=n3742
XU4116 ND2 $PINS O=N402 I1=n3746 I2=n3745
XU4117 XOR2HS $PINS O=forward_sum[0][2][11] I1=forward_sum[0][2][10]
+ I2=forward_sum[0][0][11]
XU4118 AOI22S $PINS O=n3753 A1=forward_sum[0][2][11] A2=FE_OFN1814_n5419
+ B1=forward_sum[2][2][11] B2=FE_OFN1703_FE_DBTN85_n987
XU4119 OA222 $PINS O=n3752 A1=FE_OFN1436_FE_DBTN72_n3966 A2=n3751
+ B1=FE_OFN1574_n4217 B2=n3750 C1=FE_OFN1434_FE_DBTN75_n1441 C2=n3749
XU4120 MUX2 $PINS O=n4254 S=FE_DBTN93_n1502 A=N402 B=n4269
XU4121 MUX2 $PINS O=n2052 S=FE_OFN1981_n1530 A=forward_metrics[1][1][11]
+ B=n4254
XU4122 ND2 $PINS O=n3960 I1=FE_OFN1814_n5419 I2=forward_sum[0][1][10]
XU4123 AOI22S $PINS O=n3754 A1=forward_sum[1][3][10]
+ A2=FE_OFN5587_FE_OFN1620_FE_DBTN86_n985 B1=forward_sum[4][3][10]
+ B2=FE_OFN1877_n5509
XU4124 OA112 $PINS O=n3759 A1=n3960 B1=n3754 C1=FE_OFN1463_n987 C2=n3755
XU4125 OA222 $PINS O=n3758 A1=FE_OFN1436_FE_DBTN72_n3966 A2=n3757
+ B1=FE_OFN1574_n4217 B2=n3756 C1=FE_OFN1434_FE_DBTN75_n1441 C2=n4540
XU4126 ND2 $PINS O=n4271 I1=n3759 I2=n3758
XU4127 AOI22S $PINS O=n3765 A1=FE_OFN1814_n5419 A2=forward_sum[0][2][10]
+ B1=forward_sum[2][2][10] B2=FE_OFN1703_FE_DBTN85_n987
XU4128 OA222 $PINS O=n3764 A1=FE_OFN1436_FE_DBTN72_n3966 A2=n3763
+ B1=FE_OFN1574_n4217 B2=n3762 C1=FE_OFN1434_FE_DBTN75_n1441 C2=n4984
XU4129 MUX2 $PINS O=n4228 S=FE_DBTN93_n1502 A=n4271 B=N391
XU4130 MUX2 $PINS O=n2053 S=FE_OFN1981_n1530 A=forward_metrics[1][1][10]
+ B=n4228
XU4131 MUX2 $PINS O=n2642 S=FE_OFN2126_n1519 A=FE_OFN970_forward_sum_0__1__9
+ B=FE_OFN2171_N939
XU4132 MUX2 $PINS O=n2224 S=FE_OFN2014_n1533 A=forward_metrics[4][3][7] B=n4244
XU4133 ND2 $PINS O=n4591 I1=LLR_sum[6][6][4] I2=FE_OFN1398_n1441
XU4134 OAI12HS $PINS O=n3770 A1=n4591 B1=FE_OFN1578_n4217 B2=n3766
XU4135 ND2 $PINS O=n3978 I1=FE_OFN1005_forward_sum_0__6__4 I2=FE_OFN1829_n5419
XU4136 AOI22S $PINS O=n3767 A1=forward_sum[1][6][4] A2=FE_OFN5550_n
+ B1=forward_sum[4][6][4] B2=FE_OFN1872_n5509
XU4137 OAI112HS $PINS O=n3769 A1=n3978 B1=n3767 C1=FE_OFN1476_n987 C2=n3768
XU4138 AO112 $PINS O=n4303 A1=n3770 B1=n3769 C1=forward_sum[5][6][4]
+ C2=FE_OFN1522_n1442
XU4139 MUX2 $PINS O=n4247 S=FE_OFN509_FE_DBTN91_n1503 A=N457 B=n4303
XU4140 MUX2 $PINS O=n2636 S=FE_OFN2127_n1519 A=forward_sum[0][6][3] B=n4206
XU4141 MUX2 $PINS O=n2208 S=FE_OFN2015_n1533 A=forward_metrics[4][2][11]
+ B=n4240
XU4142 AOI22S $PINS O=n3773 A1=forward_sum[1][5][10]
+ A2=FE_OFN1594_FE_DBTN86_n985 B1=forward_sum[4][5][10] B2=FE_OFN1854_n5509
XU4143 OA112 $PINS O=n3779 A1=n3774 B1=n3773 C1=FE_OFN1456_n987 C2=n3775
XU4144 OA222 $PINS O=n3778 A1=FE_OFN1435_FE_DBTN72_n3966 A2=n3777
+ B1=FE_OFN1568_n4217 B2=n3776 C1=FE_OFN1433_FE_DBTN75_n1441 C2=n5139
XU4145 ND2 $PINS O=n4283 I1=n3779 I2=n3778
XU4146 AOI22S $PINS O=n3786 A1=FE_OFN1795_n5419 A2=forward_sum[0][4][10]
+ B1=forward_sum[2][4][10] B2=FE_OFN5664_n
XU4147 OA222 $PINS O=n3785 A1=FE_OFN1435_FE_DBTN72_n3966 A2=n3784
+ B1=FE_OFN1568_n4217 B2=n3783 C1=FE_OFN1433_FE_DBTN75_n1441 C2=n4705
XU4148 MUX2 $PINS O=n4227 S=FE_DBTN92_n1501 A=n4283 B=N415
XU4149 MUX2 $PINS O=n2209 S=FE_OFN2015_n1533 A=forward_metrics[4][2][10]
+ B=n4227
XU4150 MUX2 $PINS O=n2196 S=FE_OFN2015_n1533 A=forward_metrics[4][1][11]
+ B=n4254
XU4151 MUX2 $PINS O=n2197 S=FE_OFN2015_n1533 A=forward_metrics[4][1][10]
+ B=n4228
XU4152 ND2 $PINS O=n4516 I1=LLR_sum[6][7][9] I2=FE_OFN1376_n1441
XU4153 OAI12HS $PINS O=n3791 A1=n4516 B1=FE_OFN1570_n4217 B2=n3787
XU4154 ND2 $PINS O=n3984 I1=FE_OFN970_forward_sum_0__1__9 I2=FE_OFN1815_n5419
XU4155 AOI22S $PINS O=n3788 A1=forward_sum[1][3][9]
+ A2=FE_OFN1609_FE_DBTN86_n985 B1=forward_sum[4][3][9] B2=FE_OFN1885_n5509
XU4156 OAI112HS $PINS O=n3790 A1=n3984 B1=n3788 C1=FE_OFN1467_n987 C2=n3789
XU4157 AO112 $PINS O=n4268 A1=n3791 B1=n3790 C1=forward_sum[5][3][9]
+ C2=FE_OFN1516_n1442
XU4158 ND2 $PINS O=n4962 I1=LLR_sum[6][2][9] I2=FE_OFN1376_n1441
XU4159 OAI12HS $PINS O=n3796 A1=n4962 B1=FE_OFN1570_n4217 B2=n3792
XU4160 ND2 $PINS O=n3990 I1=forward_sum[0][2][9] I2=FE_OFN1815_n5419
XU4161 AOI22S $PINS O=n3793 A1=forward_sum[1][2][9]
+ A2=FE_OFN5586_FE_OFN1620_FE_DBTN86_n985 B1=forward_sum[4][2][9]
+ B2=FE_OFN1878_n5509
XU4162 OAI112HS $PINS O=n3795 A1=n3990 B1=n3793 C1=FE_OFN1467_n987 C2=n3794
XU4163 AO112 $PINS O=N392 A1=n3796 B1=n3795 C1=forward_sum[5][2][9]
+ C2=FE_OFN1508_n1442
XU4164 MUX2 $PINS O=n4229 S=FE_OFN504_FE_DBTN93_n1502 A=n4268 B=N392
XU4165 MUX2 $PINS O=n2198 S=n1533 A=forward_metrics[4][1][9] B=n4229
XU4166 MUX2 $PINS O=n2643 S=FE_OFN2129_n1519 A=forward_sum[0][1][8]
+ B=FE_OFN2170_N938
XU4167 ND2 $PINS O=n4492 I1=LLR_sum[6][3][3] I2=FE_OFN1386_n1441
XU4168 OAI12HS $PINS O=n3801 A1=n4492 B1=FE_OFN1564_n4217 B2=n3797
XU4169 AOI22S $PINS O=n3798 A1=forward_sum[1][7][3]
+ A2=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985 B1=forward_sum[4][7][3]
+ B2=FE_OFN1888_n5509
XU4170 OAI112HS $PINS O=n3800 A1=n4013 B1=n3798 C1=FE_OFN1464_n987 C2=n3799
XU4171 AO112 $PINS O=n4300 A1=n3801 B1=n3800 C1=forward_sum[5][7][3]
+ C2=FE_OFN1503_n1442
XU4172 ND2 $PINS O=n4462 I1=LLR_sum[6][6][3] I2=FE_OFN1386_n1441
XU4173 OAI12HS $PINS O=n3806 A1=n4462 B1=FE_OFN1564_n4217 B2=n3802
XU4174 ND2 $PINS O=n4019 I1=FE_OFN1006_forward_sum_0__6__3 I2=FE_OFN1812_n5419
XU4175 AOI22S $PINS O=n3803 A1=forward_sum[1][6][3]
+ A2=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985 B1=forward_sum[4][6][3]
+ B2=FE_OFN1888_n5509
XU4176 OAI112HS $PINS O=n3805 A1=n4019 B1=n3803 C1=FE_OFN1464_n987 C2=n3804
XU4177 AO112 $PINS O=N446 A1=n3806 B1=n3805 C1=forward_sum[5][6][3]
+ C2=FE_OFN1503_n1442
XU4178 MUX2 $PINS O=n4248 S=FE_OFN509_FE_DBTN91_n1503 A=n4300 B=N446
XU4179 ND2 $PINS O=n5050 I1=LLR_sum[6][3][2] I2=FE_OFN5581_FE_OFN1388_n1441
XU4180 OAI12HS $PINS O=n3812 A1=n5050 B1=FE_OFN1567_n4217 B2=n3808
XU4181 AOI22S $PINS O=n3809 A1=forward_sum[1][7][2] A2=FE_OFN5668_n
+ B1=forward_sum[4][7][2] B2=FE_OFN5607_FE_OFN1897_n5509
XU4182 OAI112HS $PINS O=n3811 A1=n4025 B1=n3809 C1=FE_DBTN85_n987 C2=n3810
XU4183 AO112 $PINS O=N459 A1=n3812 B1=n3811 C1=forward_sum[5][7][2]
+ C2=FE_OFN1519_n1442
XU4184 XOR3 $PINS O=n4207 I1=N812 I2=N356 I3=n3813
XU4185 MUX2 $PINS O=n2160 S=FE_OFN1969_n1529 A=forward_metrics[3][2][11]
+ B=n4240
XU4186 MUX2 $PINS O=n2161 S=FE_OFN1969_n1529 A=forward_metrics[3][2][10]
+ B=n4227
XU4187 ND2 $PINS O=n5115 I1=LLR_sum[6][1][9] I2=FE_OFN1376_n1441
XU4188 OAI12HS $PINS O=n3819 A1=n5115 B1=FE_OFN1570_n4217 B2=n3814
XU4189 AOI22S $PINS O=n3815 A1=forward_sum[1][5][9]
+ A2=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985 B1=forward_sum[4][5][9]
+ B2=FE_OFN1856_n5509
XU4190 OAI112HS $PINS O=n3818 A1=n3816 B1=n3815 C1=FE_OFN1458_n987 C2=n3817
XU4191 AO112 $PINS O=n4280 A1=n3819 B1=n3818 C1=forward_sum[5][5][9]
+ C2=FE_OFN1494_n1442
XU4192 ND2 $PINS O=n4681 I1=LLR_sum[6][4][9] I2=FE_OFN1376_n1441
XU4193 OAI12HS $PINS O=n3825 A1=n4681 B1=FE_OFN1570_n4217 B2=n3820
XU4194 AOI22S $PINS O=n3821 A1=forward_sum[1][4][9]
+ A2=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985 B1=forward_sum[4][4][9]
+ B2=FE_OFN1856_n5509
XU4195 OAI112HS $PINS O=n3824 A1=n3822 B1=n3821 C1=FE_OFN1463_n987 C2=n3823
XU4196 AO112 $PINS O=N416 A1=n3825 B1=n3824 C1=forward_sum[5][4][9]
+ C2=FE_OFN1494_n1442
XU4197 MUX2 $PINS O=n4226 S=FE_OFN506_FE_DBTN92_n1501 A=n4280 B=N416
XU4198 MUX2 $PINS O=n2162 S=n1529 A=forward_metrics[3][2][9] B=n4226
XU4199 MUX2 $PINS O=n2148 S=FE_OFN1967_n1529 A=forward_metrics[3][1][11]
+ B=n4254
XU4200 MUX2 $PINS O=n2149 S=FE_OFN1967_n1529 A=forward_metrics[3][1][10]
+ B=n4228
XU4201 MUX2 $PINS O=n2150 S=n1529 A=forward_metrics[3][1][9] B=n4229
XU4202 ND2 $PINS O=n4534 I1=LLR_sum[6][7][8] I2=FE_OFN1409_n1441
XU4203 OAI12HS $PINS O=n3830 A1=n4534 B1=FE_OFN1575_n4217 B2=n3826
XU4204 ND2 $PINS O=n4031 I1=FE_OFN971_forward_sum_0__1__8 I2=FE_OFN1816_n5419
XU4205 AOI22S $PINS O=n3827 A1=forward_sum[1][3][8]
+ A2=FE_OFN1604_FE_DBTN86_n985 B1=forward_sum[4][3][8] B2=FE_OFN1895_n5509
XU4206 OAI112HS $PINS O=n3829 A1=n4031 B1=n3827 C1=FE_OFN1472_n987 C2=n3828
XU4207 AO112 $PINS O=n4270 A1=n3830 B1=n3829 C1=forward_sum[5][3][8]
+ C2=FE_OFN1529_n1442
XU4208 ND2 $PINS O=n4968 I1=LLR_sum[6][2][8] I2=FE_OFN1409_n1441
XU4209 OAI12HS $PINS O=n3835 A1=n4968 B1=FE_OFN1575_n4217 B2=n3831
XU4210 ND2 $PINS O=n4037 I1=FE_OFN981_forward_sum_0__2__8 I2=FE_OFN1816_n5419
XU4211 AOI22S $PINS O=n3832 A1=forward_sum[1][2][8]
+ A2=FE_OFN1618_FE_DBTN86_n985 B1=forward_sum[4][2][8] B2=FE_OFN1886_n5509
XU4212 OAI112HS $PINS O=n3834 A1=n4037 B1=n3832 C1=FE_OFN1467_n987 C2=n3833
XU4213 AO112 $PINS O=N393 A1=n3835 B1=n3834 C1=forward_sum[5][2][8]
+ C2=FE_OFN1529_n1442
XU4214 MUX2 $PINS O=n4230 S=FE_OFN504_FE_DBTN93_n1502 A=n4270 B=N393
XU4215 MUX2 $PINS O=n2151 S=FE_OFN1968_n1529 A=forward_metrics[3][1][8] B=n4230
XU4216 MUX2 $PINS O=n2644 S=FE_OFN2129_n1519 A=forward_sum[0][1][7]
+ B=FE_OFN2169_N937
XU4217 ND2 $PINS O=n4604 I1=LLR_sum[6][6][2] I2=FE_OFN5581_FE_OFN1388_n1441
XU4218 OAI12HS $PINS O=n3840 A1=n4604 B1=FE_OFN1567_n4217 B2=n3836
XU4219 AOI22S $PINS O=n3837 A1=forward_sum[1][6][2] A2=FE_OFN5668_n
+ B1=forward_sum[4][6][2] B2=FE_OFN5607_FE_OFN1897_n5509
XU4220 OAI112HS $PINS O=n3839 A1=n4048 B1=n3837 C1=FE_OFN1465_n987 C2=n3838
XU4221 AO112 $PINS O=n4301 A1=n3840 B1=n3839 C1=forward_sum[5][6][2]
+ C2=FE_OFN1519_n1442
XU4222 MUX2 $PINS O=n4249 S=FE_OFN509_FE_DBTN91_n1503 A=N459 B=n4301
XU4223 MUX2 $PINS O=n2304 S=FE_OFN1775_n1527 A=forward_metrics[6][2][11]
+ B=n4240
XU4224 MUX2 $PINS O=n2305 S=FE_OFN1775_n1527 A=forward_metrics[6][2][10]
+ B=n4227
XU4225 MUX2 $PINS O=n2306 S=FE_OFN1773_n1527 A=forward_metrics[6][2][9] B=n4226
XU4226 ND2 $PINS O=n5133 I1=LLR_sum[6][1][8] I2=FE_OFN1377_n1441
XU4227 OAI12HS $PINS O=n3846 A1=n5133 B1=FE_OFN1571_n4217 B2=n3841
XU4228 AOI22S $PINS O=n3842 A1=forward_sum[1][5][8]
+ A2=FE_OFN1600_FE_DBTN86_n985 B1=forward_sum[4][5][8] B2=FE_OFN1870_n5509
XU4229 OAI112HS $PINS O=n3845 A1=n3843 B1=n3842 C1=FE_OFN1462_n987 C2=n3844
XU4230 AO112 $PINS O=n4282 A1=n3846 B1=n3845 C1=forward_sum[5][5][8]
+ C2=FE_OFN1497_n1442
XU4231 ND2 $PINS O=n4687 I1=LLR_sum[6][4][8] I2=FE_OFN1377_n1441
XU4232 OAI12HS $PINS O=n3852 A1=n4687 B1=FE_OFN1571_n4217 B2=n3847
XU4233 AOI22S $PINS O=n3848 A1=forward_sum[1][4][8]
+ A2=FE_OFN1600_FE_DBTN86_n985 B1=forward_sum[4][4][8] B2=FE_OFN1870_n5509
XU4234 OAI112HS $PINS O=n3851 A1=n3849 B1=n3848 C1=FE_OFN1462_n987 C2=n3850
XU4235 AO112 $PINS O=N417 A1=n3852 B1=n3851 C1=forward_sum[5][4][8]
+ C2=FE_OFN1497_n1442
XU4236 MUX2 $PINS O=n4225 S=FE_OFN506_FE_DBTN92_n1501 A=n4282 B=N417
XU4237 MUX2 $PINS O=n2307 S=FE_OFN1774_n1527 A=forward_metrics[6][2][8] B=n4225
XU4238 MUX2 $PINS O=n2292 S=FE_OFN1775_n1527 A=forward_metrics[6][1][11]
+ B=n4254
XU4239 MUX2 $PINS O=n2293 S=FE_OFN1773_n1527 A=forward_metrics[6][1][10]
+ B=n4228
XU4240 MUX2 $PINS O=n2294 S=FE_OFN1774_n1527 A=forward_metrics[6][1][9] B=n4229
XU4241 MUX2 $PINS O=n2295 S=FE_OFN1774_n1527 A=forward_metrics[6][1][8] B=n4230
XU4242 ND2 $PINS O=n4555 I1=LLR_sum[6][7][7] I2=FE_OFN1404_n1441
XU4243 OAI12HS $PINS O=n3857 A1=n4555 B1=FE_OFN1579_n4217 B2=n3853
XU4244 ND2 $PINS O=n4054 I1=FE_OFN972_forward_sum_0__1__7 I2=FE_OFN1817_n5419
XU4245 AOI22S $PINS O=n3854 A1=forward_sum[1][3][7]
+ A2=FE_OFN1623_FE_DBTN86_n985 B1=forward_sum[4][3][7] B2=FE_OFN1903_n5509
XU4246 OAI112HS $PINS O=n3856 A1=n4054 B1=n3854 C1=FE_OFN1472_n987 C2=n3855
XU4247 AO112 $PINS O=n4272 A1=n3857 B1=n3856 C1=forward_sum[5][3][7]
+ C2=FE_OFN1558_n1442
XU4248 ND2 $PINS O=n5001 I1=LLR_sum[6][2][7] I2=FE_OFN1404_n1441
XU4249 OAI12HS $PINS O=n3862 A1=n5001 B1=FE_OFN1579_n4217 B2=n3858
XU4250 ND2 $PINS O=n4060 I1=FE_OFN982_forward_sum_0__2__7 I2=FE_OFN1817_n5419
XU4251 AOI22S $PINS O=n3859 A1=forward_sum[1][2][7]
+ A2=FE_OFN1623_FE_DBTN86_n985 B1=forward_sum[4][2][7] B2=FE_OFN1903_n5509
XU4252 OAI112HS $PINS O=n3861 A1=n4060 B1=n3859 C1=FE_OFN1472_n987 C2=n3860
XU4253 AO112 $PINS O=N394 A1=n3862 B1=n3861 C1=forward_sum[5][2][7]
+ C2=FE_OFN5561_n
XU4254 MUX2 $PINS O=n4231 S=FE_OFN504_FE_DBTN93_n1502 A=n4272 B=N394
XU4255 MUX2 $PINS O=n2296 S=FE_OFN1777_n1527 A=forward_metrics[6][1][7] B=n4231
XU4256 MUX2 $PINS O=n2645 S=FE_OFN2129_n1519 A=forward_sum[0][1][6]
+ B=FE_OFN2168_N936
XU4257 ND2 $PINS O=n5057 I1=LLR_sum[6][3][1] I2=FE_OFN5628_FE_OFN1416_n1441
XU4258 OAI12HS $PINS O=n3867 A1=n5057 B1=FE_OFN1567_n4217 B2=n3863
XU4259 AOI22S $PINS O=n3864 A1=forward_sum[1][7][1]
+ A2=FE_OFN1637_FE_DBTN86_n985 B1=forward_sum[4][7][1]
+ B2=FE_OFN5610_FE_OFN1897_n5509
XU4260 OAI112HS $PINS O=n3866 A1=n4081 B1=n3864 C1=FE_OFN1465_n987 C2=n3865
XU4261 AO112 $PINS O=n4299 A1=n3867 B1=n3866 C1=forward_sum[5][7][1]
+ C2=FE_OFN1517_n1442
XU4262 ND2 $PINS O=n4623 I1=LLR_sum[6][6][1] I2=FE_OFN1416_n1441
XU4263 OAI12HS $PINS O=n3872 A1=n4623 B1=FE_OFN1567_n4217 B2=n3868
XU4264 AOI22S $PINS O=n3869 A1=forward_sum[1][6][1]
+ A2=FE_OFN1637_FE_DBTN86_n985 B1=forward_sum[4][6][1]
+ B2=FE_OFN5610_FE_OFN1897_n5509
XU4265 OAI112HS $PINS O=n3871 A1=n4087 B1=n3869 C1=FE_OFN1465_n987 C2=n3870
XU4266 AO112 $PINS O=N448 A1=n3872 B1=n3871 C1=forward_sum[5][6][1]
+ C2=FE_OFN1517_n1442
XU4267 MUX2 $PINS O=n4250 S=FE_OFN509_FE_DBTN91_n1503 A=n4299 B=N448
XU4268 ND2 $PINS O=n5077 I1=LLR_sum[6][3][0] I2=FE_OFN1416_n1441
XU4269 OAI12HS $PINS O=n3877 A1=n5077 B1=FE_OFN1573_n4217 B2=n3873
XU4270 AOI22S $PINS O=n3874 A1=forward_sum[1][7][0]
+ A2=FE_OFN1637_FE_DBTN86_n985 B1=forward_sum[4][7][0]
+ B2=FE_OFN5610_FE_OFN1897_n5509
XU4271 OAI112HS $PINS O=n3876 A1=n4093 B1=n3874 C1=FE_OFN1469_n987 C2=n3875
XU4272 AO112 $PINS O=N461 A1=n3877 B1=n3876 C1=forward_sum[5][7][0]
+ C2=FE_OFN1526_n1442
XU4273 MUX2 $PINS O=n2256 S=FE_OFN1954_n1528 A=forward_metrics[5][2][11]
+ B=n4240
XU4274 MUX2 $PINS O=n2257 S=FE_OFN1954_n1528 A=forward_metrics[5][2][10]
+ B=n4227
XU4275 MUX2 $PINS O=n2258 S=FE_OFN1953_n1528 A=forward_metrics[5][2][9] B=n4226
XU4276 MUX2 $PINS O=n2259 S=FE_OFN1953_n1528 A=forward_metrics[5][2][8] B=n4225
XU4277 ND2 $PINS O=n5156 I1=LLR_sum[6][1][7] I2=FE_OFN1395_n1441
XU4278 OAI12HS $PINS O=n3883 A1=n5156 B1=FE_OFN1576_n4217 B2=n3878
XU4279 AOI22S $PINS O=n3879 A1=forward_sum[1][5][7]
+ A2=FE_OFN1636_FE_DBTN86_n985 B1=forward_sum[4][5][7]
+ B2=FE_OFN5616_FE_OFN1882_n5509
XU4280 OAI112HS $PINS O=n3882 A1=n3880 B1=n3879 C1=FE_OFN1470_n987 C2=n3881
XU4281 AO112 $PINS O=n4284 A1=n3883 B1=n3882 C1=forward_sum[5][5][7]
+ C2=FE_OFN1512_n1442
XU4282 ND2 $PINS O=n4722 I1=LLR_sum[6][4][7] I2=FE_OFN1395_n1441
XU4283 OAI12HS $PINS O=n3889 A1=n4722 B1=FE_OFN1579_n4217 B2=n3884
XU4284 AOI22S $PINS O=n3885 A1=forward_sum[1][4][7]
+ A2=FE_OFN5622_FE_OFN1636_FE_DBTN86_n985 B1=forward_sum[4][4][7]
+ B2=FE_OFN1882_n5509
XU4285 OAI112HS $PINS O=n3888 A1=n3886 B1=n3885 C1=FE_OFN1470_n987 C2=n3887
XU4286 AO112 $PINS O=N418 A1=n3889 B1=n3888 C1=forward_sum[5][4][7]
+ C2=FE_OFN1512_n1442
XU4287 MUX2 $PINS O=n4224 S=FE_OFN506_FE_DBTN92_n1501 A=n4284 B=N418
XU4288 MUX2 $PINS O=n2260 S=FE_OFN1958_n1528 A=forward_metrics[5][2][7] B=n4224
XU4289 MUX2 $PINS O=n2244 S=FE_OFN1954_n1528 A=forward_metrics[5][1][11]
+ B=n4254
XU4290 MUX2 $PINS O=n2245 S=FE_OFN1955_n1528 A=forward_metrics[5][1][10]
+ B=n4228
XU4291 MUX2 $PINS O=n2246 S=FE_OFN1953_n1528 A=forward_metrics[5][1][9] B=n4229
XU4292 MUX2 $PINS O=n2247 S=FE_OFN1958_n1528 A=forward_metrics[5][1][8] B=n4230
XU4293 MUX2 $PINS O=n2248 S=FE_OFN1960_n1528 A=forward_metrics[5][1][7] B=n4231
XU4294 ND2 $PINS O=n4573 I1=LLR_sum[6][7][6] I2=FE_OFN1419_n1441
XU4295 OAI12HS $PINS O=n3894 A1=n4573 B1=FE_OFN1583_n4217 B2=n3890
XU4296 ND2 $PINS O=n4099 I1=FE_OFN973_forward_sum_0__1__6 I2=FE_OFN1823_n5419
XU4297 AOI22S $PINS O=n3891 A1=forward_sum[1][3][6] A2=FE_OFN5676_n
+ B1=forward_sum[4][3][6] B2=FE_OFN1909_n5509
XU4298 OAI112HS $PINS O=n3893 A1=n4099 B1=n3891 C1=FE_OFN1477_n987 C2=n3892
XU4299 AO112 $PINS O=N407 A1=n3894 B1=n3893 C1=forward_sum[5][3][6]
+ C2=FE_OFN5561_n
XU4300 ND2 $PINS O=n5007 I1=LLR_sum[6][2][6] I2=FE_OFN1419_n1441
XU4301 OAI12HS $PINS O=n3899 A1=n5007 B1=FE_OFN1583_n4217 B2=n3895
XU4302 ND2 $PINS O=n4105 I1=FE_OFN983_forward_sum_0__2__6 I2=FE_OFN1823_n5419
XU4303 AOI22S $PINS O=n3896 A1=forward_sum[1][2][6] A2=FE_OFN5676_n
+ B1=forward_sum[4][2][6] B2=FE_OFN1914_n5509
XU4304 OAI112HS $PINS O=n3898 A1=n4105 B1=n3896 C1=FE_OFN1477_n987 C2=n3897
XU4305 AO112 $PINS O=n4273 A1=n3899 B1=n3898 C1=forward_sum[5][2][6]
+ C2=FE_OFN5562_n
XU4306 MUX2 $PINS O=n4232 S=FE_OFN504_FE_DBTN93_n1502 A=N407 B=n4273
XU4307 MUX2 $PINS O=n2646 S=FE_OFN2132_n1519 A=forward_sum[0][1][5]
+ B=FE_OFN2167_N935
XU4308 MUX2 $PINS O=n2622 S=FE_OFN2132_n1519 A=forward_sum[0][2][5]
+ B=FE_OFN2185_N705
XU4309 MUX2 $PINS O=n2113 S=FE_OFN2028_n1534 A=forward_metrics[2][2][10]
+ B=n4227
XU4310 MUX2 $PINS O=n2114 S=n1534 A=forward_metrics[2][2][9] B=n4226
XU4311 MUX2 $PINS O=n2115 S=FE_OFN2029_n1534 A=forward_metrics[2][2][8] B=n4225
XU4312 MUX2 $PINS O=n2116 S=FE_OFN2032_n1534 A=forward_metrics[2][2][7] B=n4224
XU4313 ND2 $PINS O=n5174 I1=LLR_sum[6][1][6] I2=FE_OFN1404_n1441
XU4314 OAI12HS $PINS O=n3906 A1=n5174 B1=FE_OFN1579_n4217 B2=n3901
XU4315 AOI22S $PINS O=n3902 A1=forward_sum[1][5][6] A2=FE_OFN5673_n
+ B1=forward_sum[4][5][6] B2=FE_OFN5634_FE_OFN1892_n5509
XU4316 OAI112HS $PINS O=n3905 A1=n3903 B1=n3902 C1=FE_OFN1470_n987 C2=n3904
XU4317 AO112 $PINS O=N431 A1=n3906 B1=n3905 C1=forward_sum[5][5][6]
+ C2=FE_OFN1520_n1442
XU4318 ND2 $PINS O=n4728 I1=LLR_sum[6][4][6] I2=FE_OFN1404_n1441
XU4319 OAI12HS $PINS O=n3912 A1=n4728 B1=FE_OFN1579_n4217 B2=n3907
XU4320 AOI22S $PINS O=n3908 A1=forward_sum[1][4][6] A2=FE_OFN5673_n
+ B1=forward_sum[4][4][6] B2=FE_OFN5634_FE_OFN1892_n5509
XU4321 OAI112HS $PINS O=n3911 A1=n3909 B1=n3908 C1=FE_OFN1470_n987 C2=n3910
XU4322 AO112 $PINS O=n4285 A1=n3912 B1=n3911 C1=forward_sum[5][4][6]
+ C2=FE_OFN1520_n1442
XU4323 MUX2 $PINS O=n4215 S=FE_OFN506_FE_DBTN92_n1501 A=N431 B=n4285
XU4324 MUX2 $PINS O=n2117 S=FE_OFN2031_n1534 A=forward_metrics[2][2][6] B=n4215
XU4325 MUX2 $PINS O=n2055 S=FE_OFN1980_n1530 A=forward_metrics[1][1][8] B=n4230
XU4326 MUX2 $PINS O=n2056 S=FE_OFN1983_n1530 A=forward_metrics[1][1][7] B=n4231
XU4327 ND2 $PINS O=n4579 I1=LLR_sum[6][7][5] I2=FE_OFN1414_n1441
XU4328 OAI12HS $PINS O=n3917 A1=n4579 B1=FE_OFN1586_n4217 B2=n3913
XU4329 ND2 $PINS O=n4111 I1=FE_OFN974_forward_sum_0__1__5
+ I2=FE_OFN5612_FE_OFN1828_n5419
XU4330 AOI22S $PINS O=n3914 A1=forward_sum[1][3][5]
+ A2=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985 B1=forward_sum[4][3][5]
+ B2=FE_OFN5633_FE_OFN1905_n5509
XU4331 OAI112HS $PINS O=n3916 A1=n4111 B1=n3914 C1=FE_OFN1480_n987 C2=n3915
XU4332 AO112 $PINS O=n4278 A1=n3917 B1=n3916 C1=forward_sum[5][3][5]
+ C2=FE_OFN1549_n1442
XU4333 ND2 $PINS O=n5025 I1=LLR_sum[6][2][5] I2=FE_OFN1414_n1441
XU4334 OAI12HS $PINS O=n3922 A1=n5025 B1=FE_OFN1586_n4217 B2=n3918
XU4335 ND2 $PINS O=n4117 I1=FE_OFN984_forward_sum_0__2__5
+ I2=FE_OFN5612_FE_OFN1828_n5419
XU4336 AOI22S $PINS O=n3919 A1=forward_sum[1][2][5]
+ A2=FE_OFN1639_FE_DBTN86_n985 B1=forward_sum[4][2][5] B2=FE_OFN1898_n5509
XU4337 OAI112HS $PINS O=n3921 A1=n4117 B1=n3919 C1=FE_OFN1480_n987 C2=n3920
XU4338 AO112 $PINS O=N396 A1=n3922 B1=n3921 C1=forward_sum[5][2][5]
+ C2=FE_OFN1549_n1442
XU4339 MUX2 $PINS O=n4233 S=FE_OFN505_FE_DBTN93_n1502 A=n4278 B=N396
XU4340 MUX2 $PINS O=n2647 S=FE_OFN2132_n1519 A=forward_sum[0][1][4]
+ B=FE_OFN2139_n1553
XU4341 ND2 $PINS O=n4597 I1=LLR_sum[6][7][4] I2=FE_OFN1414_n1441
XU4342 OAI12HS $PINS O=n3928 A1=n4597 B1=FE_OFN1586_n4217 B2=n3924
XU4343 ND2 $PINS O=n4123 I1=FE_OFN975_forward_sum_0__1__4 I2=FE_OFN1828_n5419
XU4344 AOI22S $PINS O=n3925 A1=forward_sum[1][3][4]
+ A2=FE_OFN5598_FE_OFN1622_FE_DBTN86_n985 B1=forward_sum[4][3][4]
+ B2=FE_OFN1905_n5509
XU4345 OAI112HS $PINS O=n3927 A1=n4123 B1=n3925 C1=FE_OFN1479_n987 C2=n3926
XU4346 AO112 $PINS O=N409 A1=n3928 B1=n3927 C1=forward_sum[5][3][4]
+ C2=FE_OFN5559_n
XU4347 XOR3 $PINS O=n4214 I1=N698 I2=n5518 I3=n3929
XU4348 MUX2 $PINS O=n2623 S=FE_OFN2132_n1519 A=forward_sum[0][2][4]
+ B=FE_OFN2183_n4214
XU4349 MUX2 $PINS O=n2066 S=FE_OFN1979_n1530 A=forward_metrics[1][2][9] B=n4226
XU4350 MUX2 $PINS O=n2067 S=FE_OFN1980_n1530 A=forward_metrics[1][2][8] B=n4225
XU4351 MUX2 $PINS O=n2068 S=FE_OFN1982_n1530 A=forward_metrics[1][2][7] B=n4224
XU4352 MUX2 $PINS O=n2069 S=FE_OFN1982_n1530 A=forward_metrics[1][2][6] B=n4215
XU4353 ND2 $PINS O=n5180 I1=LLR_sum[6][1][5] I2=FE_OFN5540_n
XU4354 OAI12HS $PINS O=n3935 A1=n5180 B1=FE_OFN1582_n4217 B2=n3930
XU4355 AOI22S $PINS O=n3931 A1=forward_sum[1][5][5]
+ A2=FE_OFN1621_FE_DBTN86_n985 B1=forward_sum[4][5][5] B2=FE_OFN1900_n5509
XU4356 OAI112HS $PINS O=n3934 A1=n3932 B1=n3931 C1=FE_OFN1481_n987 C2=n3933
XU4357 AO112 $PINS O=n4290 A1=n3935 B1=n3934 C1=forward_sum[5][5][5]
+ C2=FE_OFN1537_n1442
XU4358 ND2 $PINS O=n4746 I1=LLR_sum[6][4][5] I2=FE_OFN5540_n
XU4359 OAI12HS $PINS O=n3941 A1=n4746 B1=FE_OFN1582_n4217 B2=n3936
XU4360 AOI22S $PINS O=n3937 A1=forward_sum[1][4][5]
+ A2=FE_OFN1621_FE_DBTN86_n985 B1=forward_sum[4][4][5] B2=FE_OFN1900_n5509
XU4361 OAI112HS $PINS O=n3940 A1=n3938 B1=n3937 C1=FE_OFN1481_n987 C2=n3939
XU4362 AO112 $PINS O=N420 A1=n3941 B1=n3940 C1=forward_sum[5][4][5]
+ C2=FE_OFN1537_n1442
XU4363 MUX2 $PINS O=n4208 S=FE_OFN507_FE_DBTN92_n1501 A=n4290 B=N420
XU4364 ND2 $PINS O=n5198 I1=LLR_sum[6][1][4] I2=FE_OFN1412_n1441
XU4365 OAI12HS $PINS O=n3947 A1=n5198 B1=FE_OFN1582_n4217 B2=n3942
XU4366 AOI22S $PINS O=n3943 A1=forward_sum[1][5][4]
+ A2=FE_OFN1610_FE_DBTN86_n985 B1=forward_sum[4][5][4] B2=FE_OFN1889_n5509
XU4367 OAI112HS $PINS O=n3946 A1=n3944 B1=n3943 C1=FE_OFN1481_n987 C2=n3945
XU4368 AO112 $PINS O=N433 A1=n3947 B1=n3946 C1=forward_sum[5][5][4]
+ C2=FE_OFN1537_n1442
XU4369 ND2 $PINS O=n4510 I1=LLR_sum[6][5][11] I2=FE_OFN1389_n1441
XU4370 OAI12HS $PINS O=n3953 A1=n4510 B1=FE_OFN1574_n4217 B2=n3948
XU4371 AOI22S $PINS O=n3949 A1=forward_sum[1][1][11]
+ A2=FE_OFN5587_FE_OFN1620_FE_DBTN86_n985 B1=forward_sum[4][1][11]
+ B2=FE_OFN1877_n5509
XU4372 OAI112HS $PINS O=n3952 A1=n3950 B1=n3949 C1=FE_OFN1463_n987 C2=n3951
XU4373 AO112 $PINS O=N378 A1=n3953 B1=n3952 C1=forward_sum[5][1][11]
+ C2=FE_OFN1515_n1442
XU4374 ND2 $PINS O=n3954 I1=forward_sum[3][0][11]
+ I2=FE_OFN5613_FE_OFN1728_FE_DBTN71_n4217
XU4375 ND2 $PINS O=n4946 I1=LLR_sum[6][0][11] I2=FE_OFN1389_n1441
XU4376 AOI22S $PINS O=n3957 A1=forward_sum[1][0][11]
+ A2=FE_OFN1620_FE_DBTN86_n985 B1=forward_sum[4][0][11]
+ B2=FE_OFN5644_FE_OFN1878_n5509
XU4377 AOI22S $PINS O=n3956 A1=forward_sum[0][0][11] A2=FE_OFN1807_n5419
+ B1=forward_sum[2][0][11] B2=FE_OFN1684_FE_DBTN85_n987
XU4378 MUX2 $PINS O=n4255 S=FE_OFN503_FE_DBTN94_n1513 A=N378 B=n4257
XU4379 MUX2 $PINS O=n2040 S=FE_OFN1981_n1530 A=forward_metrics[1][0][11]
+ B=n4255
XU4380 ND2 $PINS O=n4699 I1=LLR_sum[6][5][10] I2=FE_OFN1389_n1441
XU4381 OAI12HS $PINS O=n3963 A1=n4699 B1=FE_OFN1574_n4217 B2=n3958
XU4382 AOI22S $PINS O=n3959 A1=forward_sum[1][1][10]
+ A2=FE_OFN1609_FE_DBTN86_n985 B1=forward_sum[4][1][10] B2=FE_OFN1885_n5509
XU4383 OAI112HS $PINS O=n3962 A1=n3960 B1=n3959 C1=FE_OFN1463_n987 C2=n3961
XU4384 AO112 $PINS O=n4259 A1=n3963 B1=n3962 C1=forward_sum[5][1][10]
+ C2=FE_OFN1507_n1442
XU4385 ND2 $PINS O=n5143 I1=LLR_sum[6][0][10] I2=FE_OFN1389_n1441
XU4386 AOI22S $PINS O=n3968 A1=forward_sum[1][0][10]
+ A2=FE_OFN5585_FE_OFN1620_FE_DBTN86_n985 B1=forward_sum[4][0][10]
+ B2=FE_OFN5644_FE_OFN1878_n5509
XU4387 AOI22S $PINS O=n3967 A1=FE_OFN1807_n5419 A2=forward_sum[0][0][10]
+ B1=forward_sum[2][0][10] B2=FE_OFN1695_FE_DBTN85_n987
XU4388 MUX2 $PINS O=n4194 S=FE_OFN503_FE_DBTN94_n1513 A=n4259 B=N367
XU4389 MUX2 $PINS O=n2041 S=FE_OFN1981_n1530 A=forward_metrics[1][0][10]
+ B=n4194
XU4390 MUX2 $PINS O=n2200 S=FE_OFN2017_n1533 A=forward_metrics[4][1][7] B=n4231
XU4391 ND2 $PINS O=n5031 I1=LLR_sum[6][2][4] I2=FE_OFN5540_n
XU4392 OAI12HS $PINS O=n3973 A1=n5031 B1=FE_OFN1582_n4217 B2=n3969
XU4393 ND2 $PINS O=n4129 I1=FE_OFN985_forward_sum_0__2__4 I2=FE_OFN1828_n5419
XU4394 AOI22S $PINS O=n3970 A1=forward_sum[1][2][4]
+ A2=FE_OFN5599_FE_OFN1622_FE_DBTN86_n985 B1=forward_sum[4][2][4]
+ B2=FE_OFN5631_FE_OFN1905_n5509
XU4395 OAI112HS $PINS O=n3972 A1=n4129 B1=n3970 C1=FE_OFN1479_n987 C2=n3971
XU4396 AO112 $PINS O=n4279 A1=n3973 B1=n3972 C1=forward_sum[5][2][4]
+ C2=FE_OFN5559_n
XU4397 MUX2 $PINS O=n4234 S=FE_OFN505_FE_DBTN93_n1502 A=N409 B=n4279
XU4398 MUX2 $PINS O=n2648 S=FE_OFN2132_n1519 A=forward_sum[0][1][3]
+ B=FE_OFN2138_n1552
XU4399 MUX2 $PINS O=n2211 S=n1533 A=forward_metrics[4][2][8] B=n4225
XU4400 MUX2 $PINS O=n2212 S=FE_OFN2017_n1533 A=forward_metrics[4][2][7] B=n4224
XU4401 ND2 $PINS O=n4752 I1=LLR_sum[6][4][4] I2=FE_OFN1412_n1441
XU4402 OAI12HS $PINS O=n3981 A1=n4752 B1=FE_OFN1582_n4217 B2=n3976
XU4403 AOI22S $PINS O=n3977 A1=forward_sum[1][4][4]
+ A2=FE_OFN1610_FE_DBTN86_n985 B1=forward_sum[4][4][4] B2=FE_OFN1889_n5509
XU4404 OAI112HS $PINS O=n3980 A1=n3978 B1=n3977 C1=FE_OFN1481_n987 C2=n3979
XU4405 AO112 $PINS O=n4291 A1=n3981 B1=n3980 C1=forward_sum[5][4][4]
+ C2=FE_OFN1537_n1442
XU4406 MUX2 $PINS O=n4209 S=FE_OFN507_FE_DBTN92_n1501 A=N433 B=n4291
XU4407 MUX2 $PINS O=n2184 S=FE_OFN2015_n1533 A=forward_metrics[4][0][11]
+ B=n4255
XU4408 MUX2 $PINS O=n2185 S=FE_OFN2015_n1533 A=forward_metrics[4][0][10]
+ B=n4194
XU4409 ND2 $PINS O=n4675 I1=LLR_sum[6][5][9] I2=FE_OFN1382_n1441
XU4410 OAI12HS $PINS O=n3987 A1=n4675 B1=FE_OFN1575_n4217 B2=n3982
XU4411 AOI22S $PINS O=n3983 A1=forward_sum[1][1][9]
+ A2=FE_OFN1609_FE_DBTN86_n985 B1=forward_sum[4][1][9] B2=FE_OFN1885_n5509
XU4412 OAI112HS $PINS O=n3986 A1=n3984 B1=n3983 C1=FE_OFN1467_n987 C2=n3985
XU4413 AO112 $PINS O=n4256 A1=n3987 B1=n3986 C1=forward_sum[5][1][9]
+ C2=FE_OFN1516_n1442
XU4414 ND2 $PINS O=n5121 I1=LLR_sum[6][0][9] I2=FE_OFN1382_n1441
XU4415 OAI12HS $PINS O=n3993 A1=n5121 B1=FE_OFN1575_n4217 B2=n3988
XU4416 AOI22S $PINS O=n3989 A1=forward_sum[1][0][9]
+ A2=FE_OFN1618_FE_DBTN86_n985 B1=forward_sum[4][0][9] B2=FE_OFN1878_n5509
XU4417 OAI112HS $PINS O=n3992 A1=n3990 B1=n3989 C1=FE_OFN1467_n987 C2=n3991
XU4418 MUX2 $PINS O=n4195 S=FE_DBTN94_n1513 A=n4256 B=N368
XU4419 MUX2 $PINS O=n2186 S=n1533 A=forward_metrics[4][0][9] B=n4195
XU4420 ND2 $PINS O=n4468 I1=LLR_sum[6][7][3] I2=FE_OFN1412_n1441
XU4421 OAI12HS $PINS O=n3998 A1=n4468 B1=FE_OFN1581_n4217 B2=n3994
XU4422 ND2 $PINS O=n4135 I1=FE_OFN5648_forward_sum_0__1__3 I2=FE_OFN1827_n5419
XU4423 AOI22S $PINS O=n3995 A1=forward_sum[1][3][3]
+ A2=FE_OFN1644_FE_DBTN86_n985 B1=forward_sum[4][3][3] B2=FE_OFN5574_n
XU4424 OAI112HS $PINS O=n3997 A1=n4135 B1=n3995 C1=FE_OFN1473_n987 C2=n3996
XU4425 AO112 $PINS O=n4276 A1=n3998 B1=n3997 C1=forward_sum[5][3][3]
+ C2=FE_OFN5606_FE_OFN1533_n1442
XU4426 ND2 $PINS O=n4486 I1=LLR_sum[6][2][3] I2=FE_OFN1412_n1441
XU4427 OAI12HS $PINS O=n4003 A1=n4486 B1=FE_OFN1581_n4217 B2=n3999
XU4428 AOI22S $PINS O=n4000 A1=forward_sum[1][2][3]
+ A2=FE_OFN1624_FE_DBTN86_n985 B1=forward_sum[4][2][3] B2=FE_OFN5574_n
XU4429 OAI112HS $PINS O=n4002 A1=n4141 B1=n4000 C1=FE_OFN1473_n987 C2=n4001
XU4430 AO112 $PINS O=N398 A1=n4003 B1=n4002 C1=forward_sum[5][2][3]
+ C2=FE_OFN5603_FE_OFN1533_n1442
XU4431 MUX2 $PINS O=n4235 S=FE_OFN505_FE_DBTN93_n1502 A=n4276 B=N398
XU4432 ND2 $PINS O=n4610 I1=LLR_sum[6][7][2] I2=FE_OFN5582_FE_OFN1388_n1441
XU4433 OAI12HS $PINS O=n4009 A1=n4610 B1=FE_OFN1577_n4217 B2=n4005
XU4434 AOI22S $PINS O=n4006 A1=forward_sum[1][3][2] A2=FE_OFN5533_n
+ B1=forward_sum[4][3][2] B2=FE_OFN1915_n5509
XU4435 OAI112HS $PINS O=n4008 A1=n4147 B1=n4006 C1=FE_OFN1474_n987 C2=n4007
XU4436 AO112 $PINS O=N411 A1=n4009 B1=n4008 C1=forward_sum[5][3][2]
+ C2=FE_OFN5604_FE_OFN1533_n1442
XU4437 MUX2 $PINS O=n2164 S=FE_OFN1970_n1529 A=forward_metrics[3][2][7] B=n4224
XU4438 ND2 $PINS O=n4480 I1=LLR_sum[6][1][3] I2=FE_OFN1393_n1441
XU4439 OAI12HS $PINS O=n4016 A1=n4480 B1=FE_OFN1572_n4217 B2=n4011
XU4440 AOI22S $PINS O=n4012 A1=forward_sum[1][5][3]
+ A2=FE_OFN1611_FE_DBTN86_n985 B1=forward_sum[4][5][3] B2=FE_OFN5510_n
XU4441 OAI112HS $PINS O=n4015 A1=n4013 B1=n4012 C1=FE_OFN1464_n987 C2=n4014
XU4442 AO112 $PINS O=n4288 A1=n4016 B1=n4015 C1=forward_sum[5][5][3]
+ C2=FE_OFN1511_n1442
XU4443 ND2 $PINS O=n4450 I1=LLR_sum[6][4][3] I2=FE_OFN1393_n1441
XU4444 OAI12HS $PINS O=n4022 A1=n4450 B1=FE_OFN1572_n4217 B2=n4017
XU4445 AOI22S $PINS O=n4018 A1=forward_sum[1][4][3]
+ A2=FE_OFN1611_FE_DBTN86_n985 B1=forward_sum[4][4][3] B2=FE_OFN5510_n
XU4446 OAI112HS $PINS O=n4021 A1=n4019 B1=n4018 C1=FE_OFN1464_n987 C2=n4020
XU4447 AO112 $PINS O=N422 A1=n4022 B1=n4021 C1=forward_sum[5][4][3]
+ C2=FE_OFN1511_n1442
XU4448 MUX2 $PINS O=n4210 S=FE_OFN507_FE_DBTN92_n1501 A=n4288 B=N422
XU4449 ND2 $PINS O=n5211 I1=LLR_sum[6][1][2] I2=FE_OFN1393_n1441
XU4450 OAI12HS $PINS O=n4028 A1=n5211 B1=FE_OFN1572_n4217 B2=n4023
XU4451 AOI22S $PINS O=n4024 A1=forward_sum[1][5][2]
+ A2=FE_OFN1630_FE_DBTN86_n985 B1=forward_sum[4][5][2] B2=FE_OFN1906_n5509
XU4452 OAI112HS $PINS O=n4027 A1=n4025 B1=n4024 C1=FE_OFN1465_n987 C2=n4026
XU4453 AO112 $PINS O=N435 A1=n4028 B1=n4027 C1=forward_sum[5][5][2]
+ C2=FE_OFN1509_n1442
XU4454 MUX2 $PINS O=n2136 S=FE_OFN1967_n1529 A=forward_metrics[3][0][11]
+ B=n4255
XU4455 MUX2 $PINS O=n2137 S=FE_OFN1967_n1529 A=forward_metrics[3][0][10]
+ B=n4194
XU4456 MUX2 $PINS O=n2138 S=n1529 A=forward_metrics[3][0][9] B=n4195
XU4457 ND2 $PINS O=n4693 I1=LLR_sum[6][5][8] I2=FE_OFN1410_n1441
XU4458 OAI12HS $PINS O=n4034 A1=n4693 B1=FE_OFN1575_n4217 B2=n4029
XU4459 AOI22S $PINS O=n4030 A1=forward_sum[1][1][8]
+ A2=FE_OFN1623_FE_DBTN86_n985 B1=forward_sum[4][1][8] B2=FE_OFN5680_n
XU4460 OAI112HS $PINS O=n4033 A1=n4031 B1=n4030 C1=FE_OFN1472_n987 C2=n4032
XU4461 AO112 $PINS O=n4258 A1=n4034 B1=n4033 C1=forward_sum[5][1][8]
+ C2=FE_OFN1543_n1442
XU4462 ND2 $PINS O=n5127 I1=LLR_sum[6][0][8] I2=FE_OFN1409_n1441
XU4463 OAI12HS $PINS O=n4040 A1=n5127 B1=FE_OFN1575_n4217 B2=n4035
XU4464 AOI22S $PINS O=n4036 A1=forward_sum[1][0][8]
+ A2=FE_OFN1604_FE_DBTN86_n985 B1=forward_sum[4][0][8] B2=FE_OFN5680_n
XU4465 OAI112HS $PINS O=n4039 A1=n4037 B1=n4036 C1=FE_OFN1472_n987 C2=n4038
XU4466 AO112 $PINS O=N369 A1=n4040 B1=n4039 C1=forward_sum[5][0][8]
+ C2=FE_OFN1543_n1442
XU4467 MUX2 $PINS O=n4196 S=FE_DBTN94_n1513 A=n4258 B=N369
XU4468 MUX2 $PINS O=n2139 S=FE_OFN1968_n1529 A=forward_metrics[3][0][8] B=n4196
XU4469 MUX2 $PINS O=n2298 S=FE_OFN1778_n1527 A=forward_metrics[6][1][5] B=n4233
XU4470 ND2 $PINS O=n5044 I1=LLR_sum[6][2][2] I2=FE_OFN5582_FE_OFN1388_n1441
XU4471 OAI12HS $PINS O=n4045 A1=n5044 B1=FE_OFN1577_n4217 B2=n4041
XU4472 AOI22S $PINS O=n4042 A1=forward_sum[1][2][2] A2=FE_OFN5643_FE_OFN5534_n
+ B1=forward_sum[4][2][2] B2=FE_OFN5597_FE_OFN1915_n5509
XU4473 OAI112HS $PINS O=n4044 A1=n4153 B1=n4042 C1=FE_OFN1474_n987 C2=n4043
XU4474 AO112 $PINS O=n4277 A1=n4045 B1=n4044 C1=forward_sum[5][2][2]
+ C2=FE_OFN1533_n1442
XU4475 MUX2 $PINS O=n4236 S=FE_OFN505_FE_DBTN93_n1502 A=N411 B=n4277
XU4476 MUX2 $PINS O=n2309 S=FE_OFN1778_n1527 A=forward_metrics[6][2][6] B=n4215
XU4477 MUX2 $PINS O=n2310 S=FE_OFN1781_n1527 A=forward_metrics[6][2][5] B=n4208
XU4478 ND2 $PINS O=n4765 I1=LLR_sum[6][4][2] I2=FE_OFN1393_n1441
XU4479 OAI12HS $PINS O=n4051 A1=n4765 B1=FE_OFN1572_n4217 B2=n4046
XU4480 AOI22S $PINS O=n4047 A1=forward_sum[1][4][2] A2=FE_OFN5682_n
+ B1=forward_sum[4][4][2] B2=FE_OFN1906_n5509
XU4481 OAI112HS $PINS O=n4050 A1=n4048 B1=n4047 C1=FE_OFN1465_n987 C2=n4049
XU4482 AO112 $PINS O=n4289 A1=n4051 B1=n4050 C1=forward_sum[5][4][2]
+ C2=FE_OFN1509_n1442
XU4483 MUX2 $PINS O=n4211 S=FE_OFN507_FE_DBTN92_n1501 A=N435 B=n4289
XU4484 MUX2 $PINS O=n2280 S=FE_OFN1775_n1527 A=forward_metrics[6][0][11]
+ B=n4255
XU4485 MUX2 $PINS O=n2281 S=FE_OFN1773_n1527 A=forward_metrics[6][0][10]
+ B=n4194
XU4486 MUX2 $PINS O=n2282 S=FE_OFN1774_n1527 A=forward_metrics[6][0][9] B=n4195
XU4487 MUX2 $PINS O=n2283 S=FE_OFN1777_n1527 A=forward_metrics[6][0][8] B=n4196
XU4488 ND2 $PINS O=n4716 I1=LLR_sum[6][5][7] I2=FE_OFN1419_n1441
XU4489 OAI12HS $PINS O=n4057 A1=n4716 B1=FE_OFN1583_n4217 B2=n4052
XU4490 AOI22S $PINS O=n4053 A1=forward_sum[1][1][7]
+ A2=FE_OFN1635_FE_DBTN86_n985 B1=forward_sum[4][1][7] B2=FE_OFN1909_n5509
XU4491 OAI112HS $PINS O=n4056 A1=n4054 B1=n4053 C1=FE_OFN1477_n987 C2=n4055
XU4492 AO112 $PINS O=n4260 A1=n4057 B1=n4056 C1=forward_sum[5][1][7]
+ C2=FE_OFN5561_n
XU4493 ND2 $PINS O=n5162 I1=LLR_sum[6][0][7] I2=FE_OFN1420_n1441
XU4494 OAI12HS $PINS O=n4063 A1=n5162 B1=FE_OFN1583_n4217 B2=n4058
XU4495 AOI22S $PINS O=n4059 A1=forward_sum[1][0][7]
+ A2=FE_OFN1635_FE_DBTN86_n985 B1=forward_sum[4][0][7] B2=FE_OFN1908_n5509
XU4496 OAI112HS $PINS O=n4062 A1=n4060 B1=n4059 C1=FE_OFN1477_n987 C2=n4061
XU4497 AO112 $PINS O=N370 A1=n4063 B1=n4062 C1=forward_sum[5][0][7]
+ C2=FE_OFN1556_n1442
XU4498 MUX2 $PINS O=n4197 S=FE_DBTN94_n1513 A=n4260 B=N370
XU4499 MUX2 $PINS O=n2284 S=FE_OFN1777_n1527 A=forward_metrics[6][0][7] B=n4197
XU4500 ND2 $PINS O=n4617 I1=LLR_sum[6][7][1] I2=FE_OFN1388_n1441
XU4501 OAI12HS $PINS O=n4068 A1=n4617 B1=FE_OFN1580_n4217 B2=n4064
XU4502 AOI22S $PINS O=n4065 A1=forward_sum[1][3][1]
+ A2=FE_OFN1650_FE_DBTN86_n985 B1=forward_sum[4][3][1] B2=FE_OFN1919_n5509
XU4503 OAI112HS $PINS O=n4067 A1=n4159 B1=n4065 C1=FE_OFN1478_n987 C2=n4066
XU4504 AO112 $PINS O=n4275 A1=n4068 B1=n4067 C1=forward_sum[5][3][1]
+ C2=FE_OFN1530_n1442
XU4505 ND2 $PINS O=n5063 I1=LLR_sum[6][2][1] I2=FE_OFN1388_n1441
XU4506 OAI12HS $PINS O=n4073 A1=n5063 B1=FE_OFN1580_n4217 B2=n4069
XU4507 AOI22S $PINS O=n4070 A1=forward_sum[1][2][1]
+ A2=FE_OFN1655_FE_DBTN86_n985 B1=forward_sum[4][2][1] B2=FE_OFN5524_n
XU4508 OAI112HS $PINS O=n4072 A1=n4165 B1=n4070 C1=FE_OFN1474_n987 C2=n4071
XU4509 AO112 $PINS O=N400 A1=n4073 B1=n4072 C1=forward_sum[5][2][1]
+ C2=FE_OFN1530_n1442
XU4510 MUX2 $PINS O=n4237 S=FE_OFN505_FE_DBTN93_n1502 A=n4275 B=N400
XU4511 ND2 $PINS O=n4637 I1=LLR_sum[6][7][0] I2=FE_OFN5583_FE_OFN1388_n1441
XU4512 OAI12HS $PINS O=n4078 A1=n4637 B1=FE_OFN1580_n4217 B2=n4074
XU4513 AOI22S $PINS O=n4075 A1=forward_sum[1][3][0]
+ A2=FE_OFN1655_FE_DBTN86_n985 B1=forward_sum[4][3][0] B2=FE_OFN5524_n
XU4514 OAI112HS $PINS O=n4077 A1=n4171 B1=n4075 C1=FE_OFN1478_n987 C2=n4076
XU4515 AO112 $PINS O=N413 A1=n4078 B1=n4077 C1=forward_sum[5][3][0]
+ C2=FE_OFN5647_FE_OFN1530_n1442
XU4516 ND2 $PINS O=n5218 I1=LLR_sum[6][1][1] I2=FE_OFN5552_n
XU4517 OAI12HS $PINS O=n4084 A1=n5218 B1=FE_OFN1573_n4217 B2=n4079
XU4518 AOI22S $PINS O=n4080 A1=forward_sum[1][5][1]
+ A2=FE_OFN3103_FE_DBTN86_n985 B1=forward_sum[4][5][1] B2=FE_OFN3102_n5509
XU4519 OAI112HS $PINS O=n4083 A1=n4081 B1=n4080 C1=FE_OFN1469_n987 C2=n4082
XU4520 AO112 $PINS O=n4287 A1=n4084 B1=n4083 C1=forward_sum[5][5][1]
+ C2=FE_OFN5639_FE_OFN1526_n1442
XU4521 ND2 $PINS O=n4784 I1=LLR_sum[6][4][1] I2=FE_OFN5552_n
XU4522 OAI12HS $PINS O=n4090 A1=n4784 B1=FE_OFN1573_n4217 B2=n4085
XU4523 AOI22S $PINS O=n4086 A1=forward_sum[1][4][1]
+ A2=FE_OFN3103_FE_DBTN86_n985 B1=forward_sum[4][4][1] B2=FE_OFN3102_n5509
XU4524 OAI112HS $PINS O=n4089 A1=n4087 B1=n4086 C1=FE_OFN1469_n987 C2=n4088
XU4525 AO112 $PINS O=N424 A1=n4090 B1=n4089 C1=forward_sum[5][4][1]
+ C2=FE_OFN5639_FE_OFN1526_n1442
XU4526 MUX2 $PINS O=n4212 S=FE_OFN507_FE_DBTN92_n1501 A=n4287 B=N424
XU4527 ND2 $PINS O=n5238 I1=LLR_sum[6][1][0] I2=FE_OFN5552_n
XU4528 OAI12HS $PINS O=n4096 A1=n5238 B1=FE_OFN1573_n4217 B2=n4091
XU4529 AOI22S $PINS O=n4092 A1=forward_sum[1][5][0]
+ A2=FE_OFN3103_FE_DBTN86_n985 B1=forward_sum[4][5][0] B2=FE_OFN3102_n5509
XU4530 OAI112HS $PINS O=n4095 A1=n4093 B1=n4092 C1=FE_OFN1469_n987 C2=n4094
XU4531 AO112 $PINS O=N437 A1=n4096 B1=n4095 C1=forward_sum[5][5][0]
+ C2=FE_OFN5637_FE_OFN1526_n1442
XU4532 MUX2 $PINS O=n2232 S=FE_OFN1954_n1528 A=forward_metrics[5][0][11]
+ B=n4255
XU4533 MUX2 $PINS O=n2233 S=FE_OFN1955_n1528 A=forward_metrics[5][0][10]
+ B=n4194
XU4534 MUX2 $PINS O=n2234 S=FE_OFN1953_n1528 A=forward_metrics[5][0][9] B=n4195
XU4535 MUX2 $PINS O=n2235 S=FE_OFN1958_n1528 A=forward_metrics[5][0][8] B=n4196
XU4536 MUX2 $PINS O=n2236 S=FE_OFN1960_n1528 A=forward_metrics[5][0][7] B=n4197
XU4537 ND2 $PINS O=n4734 I1=LLR_sum[6][5][6] I2=FE_OFN1423_n1441
XU4538 OAI12HS $PINS O=n4102 A1=n4734 B1=FE_OFN1583_n4217 B2=n4097
XU4539 AOI22S $PINS O=n4098 A1=forward_sum[1][1][6]
+ A2=FE_OFN1645_FE_DBTN86_n985 B1=forward_sum[4][1][6] B2=FE_OFN1916_n5509
XU4540 OAI112HS $PINS O=n4101 A1=n4099 B1=n4098 C1=FE_OFN1477_n987 C2=n4100
XU4541 AO112 $PINS O=N383 A1=n4102 B1=n4101 C1=forward_sum[5][1][6]
+ C2=FE_OFN5562_n
XU4542 ND2 $PINS O=n5168 I1=LLR_sum[6][0][6] I2=FE_OFN1423_n1441
XU4543 OAI12HS $PINS O=n4108 A1=n5168 B1=FE_OFN1583_n4217 B2=n4103
XU4544 AOI22S $PINS O=n4104 A1=forward_sum[1][0][6]
+ A2=FE_OFN1645_FE_DBTN86_n985 B1=forward_sum[4][0][6] B2=FE_OFN1916_n5509
XU4545 OAI112HS $PINS O=n4107 A1=n4105 B1=n4104 C1=FE_OFN1477_n987 C2=n4106
XU4546 AO112 $PINS O=n4261 A1=n4108 B1=n4107 C1=forward_sum[5][0][6]
+ C2=FE_OFN5562_n
XU4547 MUX2 $PINS O=n4198 S=FE_DBTN94_n1513 A=N383 B=n4261
XU4548 MUX2 $PINS O=n2237 S=FE_OFN1959_n1528 A=forward_metrics[5][0][6] B=n4198
XU4549 MUX2 $PINS O=n2043 S=FE_OFN1980_n1530 A=forward_metrics[1][0][8] B=n4196
XU4550 MUX2 $PINS O=n2044 S=FE_OFN1983_n1530 A=forward_metrics[1][0][7] B=n4197
XU4551 ND2 $PINS O=n4740 I1=LLR_sum[6][5][5] I2=FE_OFN1414_n1441
XU4552 OAI12HS $PINS O=n4114 A1=n4740 B1=FE_OFN1586_n4217 B2=n4109
XU4553 AOI22S $PINS O=n4110 A1=forward_sum[1][1][5]
+ A2=FE_OFN1639_FE_DBTN86_n985 B1=forward_sum[4][1][5] B2=FE_OFN1898_n5509
XU4554 OAI112HS $PINS O=n4113 A1=n4111 B1=n4110 C1=FE_OFN1480_n987 C2=n4112
XU4555 AO112 $PINS O=n4266 A1=n4114 B1=n4113 C1=forward_sum[5][1][5]
+ C2=FE_OFN1554_n1442
XU4556 ND2 $PINS O=n5186 I1=LLR_sum[6][0][5] I2=FE_OFN1414_n1441
XU4557 OAI12HS $PINS O=n4120 A1=n5186 B1=FE_OFN1586_n4217 B2=n4115
XU4558 AOI22S $PINS O=n4116 A1=forward_sum[1][0][5]
+ A2=FE_OFN1640_FE_DBTN86_n985 B1=forward_sum[4][0][5] B2=FE_OFN1911_n5509
XU4559 OAI112HS $PINS O=n4119 A1=n4117 B1=n4116 C1=FE_OFN1480_n987 C2=n4118
XU4560 AO112 $PINS O=N372 A1=n4120 B1=n4119 C1=forward_sum[5][0][5]
+ C2=FE_OFN1554_n1442
XU4561 MUX2 $PINS O=n4199 S=FE_OFN502_FE_DBTN94_n1513 A=n4266 B=N372
XU4562 ND2 $PINS O=n4758 I1=LLR_sum[6][5][4] I2=FE_OFN1422_n1441
XU4563 OAI12HS $PINS O=n4126 A1=n4758 B1=FE_OFN1585_n4217 B2=n4121
XU4564 AOI22S $PINS O=n4122 A1=forward_sum[1][1][4]
+ A2=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985 B1=forward_sum[4][1][4]
+ B2=FE_OFN1905_n5509
XU4565 OAI112HS $PINS O=n4125 A1=n4123 B1=n4122 C1=FE_OFN1479_n987 C2=n4124
XU4566 AO112 $PINS O=N385 A1=n4126 B1=n4125 C1=forward_sum[5][1][4]
+ C2=FE_OFN1548_n1442
XU4567 MUX2 $PINS O=n2188 S=FE_OFN2017_n1533 A=forward_metrics[4][0][7] B=n4197
XU4568 ND2 $PINS O=n5192 I1=LLR_sum[6][0][4] I2=FE_OFN1422_n1441
XU4569 OAI12HS $PINS O=n4132 A1=n5192 B1=FE_OFN1585_n4217 B2=n4127
XU4570 AOI22S $PINS O=n4128 A1=forward_sum[1][0][4]
+ A2=FE_OFN5599_FE_OFN1622_FE_DBTN86_n985 B1=forward_sum[4][0][4]
+ B2=FE_OFN5631_FE_OFN1905_n5509
XU4571 OAI112HS $PINS O=n4131 A1=n4129 B1=n4128 C1=FE_OFN1479_n987 C2=n4130
XU4572 AO112 $PINS O=n4267 A1=n4132 B1=n4131 C1=forward_sum[5][0][4]
+ C2=FE_OFN1548_n1442
XU4573 MUX2 $PINS O=n4200 S=FE_OFN502_FE_DBTN94_n1513 A=N385 B=n4267
XU4574 MUX2 $PINS O=n2141 S=FE_OFN1972_n1529 A=forward_metrics[3][0][6] B=n4198
XU4575 ND2 $PINS O=n4456 I1=LLR_sum[6][5][3] I2=FE_OFN1412_n1441
XU4576 OAI12HS $PINS O=n4138 A1=n4456 B1=FE_OFN1581_n4217 B2=n4133
XU4577 AOI22S $PINS O=n4134 A1=forward_sum[1][1][3]
+ A2=FE_OFN1624_FE_DBTN86_n985 B1=forward_sum[4][1][3] B2=FE_OFN5574_n
XU4578 OAI112HS $PINS O=n4137 A1=n4135 B1=n4134 C1=FE_OFN1473_n987 C2=n4136
XU4579 AO112 $PINS O=n4264 A1=n4138 B1=n4137 C1=forward_sum[5][1][3]
+ C2=FE_OFN5603_FE_OFN1533_n1442
XU4580 ND2 $PINS O=n4474 I1=LLR_sum[6][0][3] I2=FE_OFN1421_n1441
XU4581 OAI12HS $PINS O=n4144 A1=n4474 B1=FE_OFN1581_n4217 B2=n4139
XU4582 AOI22S $PINS O=n4140 A1=forward_sum[1][0][3]
+ A2=FE_OFN1624_FE_DBTN86_n985 B1=forward_sum[4][0][3] B2=FE_OFN5575_n
XU4583 OAI112HS $PINS O=n4143 A1=n4141 B1=n4140 C1=FE_OFN1473_n987 C2=n4142
XU4584 AO112 $PINS O=N374 A1=n4144 B1=n4143 C1=forward_sum[5][0][3]
+ C2=FE_OFN1539_n1442
XU4585 MUX2 $PINS O=n4201 S=FE_OFN502_FE_DBTN94_n1513 A=n4264 B=N374
XU4586 ND2 $PINS O=n4771 I1=LLR_sum[6][5][2] I2=FE_OFN5582_FE_OFN1388_n1441
XU4587 OAI12HS $PINS O=n4150 A1=n4771 B1=FE_OFN1581_n4217 B2=n4145
XU4588 AOI22S $PINS O=n4146 A1=forward_sum[1][1][2] A2=FE_OFN5532_n
+ B1=forward_sum[4][1][2] B2=FE_OFN5592_FE_OFN1915_n5509
XU4589 OAI112HS $PINS O=n4149 A1=n4147 B1=n4146 C1=FE_OFN1473_n987 C2=n4148
XU4590 AO112 $PINS O=N387 A1=n4150 B1=n4149 C1=forward_sum[5][1][2]
+ C2=FE_OFN5604_FE_OFN1533_n1442
XU4591 MUX2 $PINS O=n2286 S=FE_OFN1778_n1527 A=forward_metrics[6][0][5] B=n4199
XU4592 ND2 $PINS O=n5205 I1=LLR_sum[6][0][2] I2=FE_OFN5582_FE_OFN1388_n1441
XU4593 OAI12HS $PINS O=n4156 A1=n5205 B1=FE_OFN1581_n4217 B2=n4151
XU4594 AOI22S $PINS O=n4152 A1=forward_sum[1][0][2]
+ A2=FE_OFN1641_FE_DBTN86_n985 B1=forward_sum[4][0][2]
+ B2=FE_OFN5592_FE_OFN1915_n5509
XU4595 OAI112HS $PINS O=n4155 A1=n4153 B1=n4152 C1=FE_OFN1474_n987 C2=n4154
XU4596 AO112 $PINS O=n4265 A1=n4156 B1=n4155 C1=forward_sum[5][0][2]
+ C2=FE_OFN5604_FE_OFN1533_n1442
XU4597 MUX2 $PINS O=n4202 S=FE_OFN502_FE_DBTN94_n1513 A=N387 B=n4265
XU4598 ND2 $PINS O=n4778 I1=LLR_sum[6][5][1] I2=FE_OFN5583_FE_OFN1388_n1441
XU4599 OAI12HS $PINS O=n4162 A1=n4778 B1=FE_OFN1577_n4217 B2=n4157
XU4600 AOI22S $PINS O=n4158 A1=forward_sum[1][1][1]
+ A2=FE_OFN1651_FE_DBTN86_n985 B1=forward_sum[4][1][1] B2=FE_OFN1919_n5509
XU4601 OAI112HS $PINS O=n4161 A1=n4159 B1=n4158 C1=FE_OFN1478_n987 C2=n4160
XU4602 AO112 $PINS O=n4263 A1=n4162 B1=n4161 C1=forward_sum[5][1][1]
+ C2=FE_OFN1534_n1442
XU4603 ND2 $PINS O=n5224 I1=LLR_sum[6][0][1] I2=FE_OFN5583_FE_OFN1388_n1441
XU4604 OAI12HS $PINS O=n4168 A1=n5224 B1=FE_OFN1577_n4217 B2=n4163
XU4605 AOI22S $PINS O=n4164 A1=forward_sum[1][0][1]
+ A2=FE_OFN1650_FE_DBTN86_n985 B1=forward_sum[4][0][1] B2=FE_OFN5523_n
XU4606 OAI112HS $PINS O=n4167 A1=n4165 B1=n4164 C1=FE_OFN1474_n987 C2=n4166
XU4607 AO112 $PINS O=N376 A1=n4168 B1=n4167 C1=forward_sum[5][0][1]
+ C2=FE_OFN1534_n1442
XU4608 MUX2 $PINS O=n4203 S=FE_OFN502_FE_DBTN94_n1513 A=n4263 B=N376
XU4609 ND2 $PINS O=n4798 I1=LLR_sum[6][5][0] I2=FE_OFN1400_n1441
XU4610 OAI12HS $PINS O=n4174 A1=n4798 B1=FE_OFN1580_n4217 B2=n4169
XU4611 AOI22S $PINS O=n4170 A1=forward_sum[1][1][0]
+ A2=FE_OFN1652_FE_DBTN86_n985 B1=forward_sum[4][1][0] B2=FE_OFN5522_n
XU4612 OAI112HS $PINS O=n4173 A1=n4171 B1=n4170 C1=FE_OFN1478_n987 C2=n4172
XU4613 AO112 $PINS O=N389 A1=n4174 B1=n4173 C1=forward_sum[5][1][0]
+ C2=FE_OFN1547_n1442
XU4614 ND2 $PINS O=n5232 I1=LLR_sum[6][0][0] I2=FE_OFN5583_FE_OFN1388_n1441
XU4615 OAI12HS $PINS O=n4179 A1=n5232 B1=FE_OFN1580_n4217 B2=n4175
XU4616 AOI22S $PINS O=n4176 A1=forward_sum[1][0][0]
+ A2=FE_OFN1652_FE_DBTN86_n985 B1=forward_sum[4][0][0] B2=FE_OFN5522_n
XU4617 OAI112HS $PINS O=n4178 A1=n4190 B1=n4176 C1=FE_OFN1478_n987 C2=n4177
XU4618 AO112 $PINS O=n4262 A1=n4179 B1=n4178 C1=forward_sum[5][0][0]
+ C2=FE_OFN1547_n1442
XU4619 MUX2 $PINS O=n4204 S=FE_OFN502_FE_DBTN94_n1513 A=N389 B=n4262
XU4620 MUX2 $PINS O=n2856 S=FE_OFN2073_n1514 A=branch_metrics[5][0][11]
+ B=FE_OFN2192_N711
XU4621 MUX2 $PINS O=n2857 S=FE_OFN2073_n1514
+ A=FE_OFN922_branch_metrics_5__0__10 B=FE_OFN2191_N710
XU4622 MUX2 $PINS O=n2858 S=FE_OFN2077_n1514 A=FE_OFN923_branch_metrics_5__0__9
+ B=N709
XU4623 MUX2 $PINS O=n2859 S=FE_OFN2077_n1514 A=FE_OFN924_branch_metrics_5__0__8
+ B=FE_OFN2189_N708
XU4624 MUX2 $PINS O=n2860 S=FE_OFN2078_n1514 A=FE_OFN925_branch_metrics_5__0__7
+ B=FE_OFN2188_N707
XU4625 MUX2 $PINS O=n2904 S=FE_OFN2147_n4223 A=FE_OFN1276_backward_sum_0__0__11
+ B=FE_OFN2192_N711
XU4626 MUX2 $PINS O=n2905 S=FE_OFN2147_n4223 A=FE_OFN1277_backward_sum_0__0__10
+ B=FE_OFN2191_N710
XU4627 MUX2 $PINS O=n2906 S=FE_OFN2145_n4223 A=backward_sum[0][4][9]
+ B=FE_OFN2190_N709
XU4628 MUX2 $PINS O=n2907 S=FE_OFN2148_n4223 A=backward_sum[0][4][8] B=N708
XU4629 MUX2 $PINS O=n2908 S=FE_OFN2149_n4223 A=backward_sum[0][4][7]
+ B=FE_OFN2188_N707
XU4630 MUX2 $PINS O=n2909 S=FE_OFN2149_n4223 A=backward_sum[0][4][6]
+ B=FE_OFN2187_N706
XU4631 MUX2 $PINS O=n2910 S=FE_OFN2149_n4223 A=backward_sum[0][4][5]
+ B=FE_OFN2185_N705
XU4632 MUX2 $PINS O=n2760 S=FE_OFN2094_n1516 A=branch_metrics[3][0][11] B=N711
XU4633 MUX2 $PINS O=n2761 S=FE_OFN2094_n1516 A=branch_metrics[3][0][10] B=N710
XU4634 MUX2 $PINS O=n2762 S=FE_OFN2099_n1516 A=branch_metrics[3][0][9] B=N709
XU4635 MUX2 $PINS O=n2763 S=FE_OFN2100_n1516 A=branch_metrics[3][0][8] B=N708
XU4636 MUX2 $PINS O=n2808 S=FE_OFN2085_n1515
+ A=FE_OFN873_branch_metrics_4__0__11 B=FE_OFN2192_N711
XU4637 MUX2 $PINS O=n2809 S=FE_OFN2085_n1515 A=branch_metrics[4][0][10]
+ B=FE_OFN2191_N710
XU4638 MUX2 $PINS O=n2810 S=FE_OFN2087_n1515 A=branch_metrics[4][0][9]
+ B=FE_OFN2190_N709
XU4639 MUX2 $PINS O=n2811 S=FE_OFN2087_n1515 A=branch_metrics[4][0][8]
+ B=FE_OFN2189_N708
XU4640 MUX2 $PINS O=n2664 S=FE_OFN2114_n1518
+ A=FE_OFN729_branch_metrics_1__0__11 B=FE_OFN2192_N711
XU4641 MUX2 $PINS O=n2665 S=FE_OFN2114_n1518 A=branch_metrics[1][0][10]
+ B=FE_OFN2191_N710
XU4642 MUX2 $PINS O=n2666 S=FE_OFN2116_n1518 A=branch_metrics[1][0][9]
+ B=FE_OFN2190_N709
XU4643 MUX2 $PINS O=n2667 S=FE_OFN2116_n1518 A=branch_metrics[1][0][8]
+ B=FE_OFN2189_N708
XU4644 MUX2 $PINS O=n2668 S=FE_OFN2118_n1518 A=branch_metrics[1][0][7]
+ B=FE_OFN2188_N707
XU4645 MUX2 $PINS O=n2238 S=FE_OFN1959_n1528 A=forward_metrics[5][0][5] B=n4199
XU4646 MUX2 $PINS O=n2868 S=FE_OFN2069_n1514
+ A=FE_OFN933_branch_metrics_5__1__11 B=FE_OFN2165_N826
XU4647 MUX2 $PINS O=n2869 S=FE_OFN2069_n1514
+ A=FE_OFN934_branch_metrics_5__1__10 B=FE_OFN2164_N825
XU4648 MUX2 $PINS O=n2870 S=FE_OFN2068_n1514 A=FE_OFN935_branch_metrics_5__1__9
+ B=FE_OFN2163_N824
XU4649 MUX2 $PINS O=n2871 S=FE_OFN2076_n1514 A=FE_OFN936_branch_metrics_5__1__8
+ B=FE_OFN2162_N823
XU4650 MUX2 $PINS O=n2872 S=FE_OFN2076_n1514 A=branch_metrics[5][1][7]
+ B=FE_OFN2161_N822
XU4651 MUX2 $PINS O=n2873 S=FE_OFN2076_n1514 A=FE_OFN938_branch_metrics_5__1__6
+ B=FE_OFN2160_N821
XU4652 ND2 $PINS O=n4792 I1=LLR_sum[6][4][0] I2=FE_OFN5552_n
XU4653 OAI12HS $PINS O=n4187 A1=n4792 B1=FE_OFN1573_n4217 B2=n4183
XU4654 AOI22S $PINS O=n4184 A1=forward_sum[1][4][0]
+ A2=FE_OFN3103_FE_DBTN86_n985 B1=forward_sum[4][4][0] B2=FE_OFN3102_n5509
XU4655 OAI112HS $PINS O=n4186 A1=n4219 B1=n4184 C1=FE_OFN1469_n987 C2=n4185
XU4656 AO112 $PINS O=n4286 A1=n4187 B1=n4186 C1=forward_sum[5][4][0]
+ C2=FE_OFN5637_FE_OFN1526_n1442
XU4657 MUX2 $PINS O=n4213 S=FE_OFN507_FE_DBTN92_n1501 A=N437 B=n4286
XU4658 ND2 $PINS O=n5071 I1=LLR_sum[6][2][0] I2=FE_OFN1388_n1441
XU4659 OAI12HS $PINS O=n4193 A1=n5071 B1=FE_OFN1580_n4217 B2=n4188
XU4660 AOI22S $PINS O=n4189 A1=forward_sum[1][2][0]
+ A2=FE_OFN1655_FE_DBTN86_n985 B1=forward_sum[4][2][0] B2=FE_OFN5524_n
XU4661 OAI112HS $PINS O=n4192 A1=n4190 B1=n4189 C1=FE_OFN1478_n987 C2=n4191
XU4662 AO112 $PINS O=n4274 A1=n4193 B1=n4192 C1=forward_sum[5][2][0]
+ C2=FE_OFN5647_FE_OFN1530_n1442
XU4663 MUX2 $PINS O=n4238 S=FE_OFN505_FE_DBTN93_n1502 A=N413 B=n4274
XU4664 MUX2 $PINS O=n2881 S=FE_OFN2073_n1514 A=branch_metrics[5][2][10]
+ B=FE_OFN2172_N940
XU4665 MUX2 $PINS O=n2882 S=FE_OFN2077_n1514 A=branch_metrics[5][2][9]
+ B=FE_OFN2171_N939
XU4666 MUX2 $PINS O=n2883 S=FE_OFN2077_n1514 A=FE_OFN947_branch_metrics_5__2__8
+ B=FE_OFN2170_N938
XU4667 MUX2 $PINS O=n2884 S=FE_OFN2078_n1514 A=FE_OFN948_branch_metrics_5__2__7
+ B=FE_OFN2169_N937
XU4668 MUX2 $PINS O=n2621 S=FE_OFN2129_n1519 A=forward_sum[0][2][6]
+ B=FE_OFN2187_N706
XU4669 MUX2 $PINS O=n2285 S=FE_OFN1780_n1527 A=forward_metrics[6][0][6] B=n4198
XU4670 MUX2 $PINS O=n2916 S=FE_OFN2146_n4223 A=branch_metrics[6][1][11]
+ B=FE_OFN2165_N826
XU4671 MUX2 $PINS O=n2917 S=FE_OFN2146_n4223
+ A=FE_OFN968_branch_metrics_6__1__10 B=FE_OFN2164_N825
XU4672 MUX2 $PINS O=n2918 S=FE_OFN2145_n4223 A=backward_sum[0][1][9]
+ B=FE_OFN2163_N824
XU4673 MUX2 $PINS O=n2919 S=FE_OFN2145_n4223 A=backward_sum[0][1][8]
+ B=FE_OFN2162_N823
XU4674 MUX2 $PINS O=n2920 S=FE_OFN2148_n4223 A=backward_sum[0][1][7]
+ B=FE_OFN2161_N822
XU4675 MUX2 $PINS O=n2921 S=FE_OFN2150_n4223 A=backward_sum[0][1][6]
+ B=FE_OFN2160_N821
XU4676 MUX2 $PINS O=n2922 S=FE_OFN2150_n4223 A=backward_sum[0][1][5]
+ B=FE_OFN2159_N820
XU4677 MUX2 $PINS O=n2923 S=FE_OFN2153_n4223 A=backward_sum[0][1][4]
+ B=FE_OFN2182_n4205
XU4678 MUX2 $PINS O=n2929 S=FE_OFN2147_n4223 A=FE_OFN1279_backward_sum_0__2__10
+ B=FE_OFN2172_N940
XU4679 MUX2 $PINS O=n2930 S=FE_OFN2145_n4223 A=backward_sum[0][6][9]
+ B=FE_OFN2171_N939
XU4680 MUX2 $PINS O=n2931 S=FE_OFN2148_n4223 A=backward_sum[0][6][8] B=N938
XU4681 MUX2 $PINS O=n2932 S=FE_OFN2149_n4223 A=backward_sum[0][6][7]
+ B=FE_OFN2169_N937
XU4682 MUX2 $PINS O=n2933 S=FE_OFN2149_n4223 A=backward_sum[0][6][6]
+ B=FE_OFN2168_N936
XU4683 MUX2 $PINS O=n2934 S=FE_OFN2149_n4223 A=backward_sum[0][6][5]
+ B=FE_OFN2167_N935
XU4684 MUX2 $PINS O=n2620 S=FE_OFN2129_n1519 A=FE_OFN982_forward_sum_0__2__7
+ B=FE_OFN2188_N707
XU4685 MUX2 $PINS O=n2140 S=FE_OFN1970_n1529 A=forward_metrics[3][0][7] B=n4197
XU4686 MUX2 $PINS O=n2772 S=FE_OFN2095_n1516 A=branch_metrics[3][1][11] B=N826
XU4687 MUX2 $PINS O=n2773 S=FE_OFN2095_n1516
+ A=FE_OFN838_branch_metrics_3__1__10 B=N825
XU4688 MUX2 $PINS O=n2774 S=FE_OFN2094_n1516 A=FE_OFN839_branch_metrics_3__1__9
+ B=FE_OFN2163_N824
XU4689 MUX2 $PINS O=n2775 S=FE_OFN2099_n1516 A=branch_metrics[3][1][8]
+ B=FE_OFN2162_N823
XU4690 MUX2 $PINS O=n2776 S=FE_OFN2100_n1516 A=FE_OFN841_branch_metrics_3__1__7
+ B=FE_OFN2161_N822
XU4691 MUX2 $PINS O=n2785 S=FE_OFN2094_n1516 A=branch_metrics[3][2][10] B=N940
XU4692 MUX2 $PINS O=n2786 S=FE_OFN2099_n1516 A=FE_OFN851_branch_metrics_3__2__9
+ B=N939
XU4693 MUX2 $PINS O=n2787 S=FE_OFN2100_n1516 A=FE_OFN852_branch_metrics_3__2__8
+ B=N938
XU4694 MUX2 $PINS O=n2788 S=FE_OFN2101_n1516 A=branch_metrics[3][2][7] B=N937
XU4695 MUX2 $PINS O=n2619 S=FE_OFN2129_n1519 A=FE_OFN981_forward_sum_0__2__8
+ B=FE_OFN2189_N708
XU4696 MUX2 $PINS O=n2187 S=FE_OFN2017_n1533 A=forward_metrics[4][0][8] B=n4196
XU4697 MUX2 $PINS O=n2820 S=FE_OFN2084_n1515
+ A=FE_OFN885_branch_metrics_4__1__11 B=FE_OFN2165_N826
XU4698 MUX2 $PINS O=n2821 S=FE_OFN2084_n1515
+ A=FE_OFN886_branch_metrics_4__1__10 B=FE_OFN2164_N825
XU4699 MUX2 $PINS O=n2822 S=FE_OFN2083_n1515 A=FE_OFN887_branch_metrics_4__1__9
+ B=FE_OFN2163_N824
XU4700 MUX2 $PINS O=n2823 S=FE_OFN2083_n1515 A=FE_OFN888_branch_metrics_4__1__8
+ B=FE_OFN2162_N823
XU4701 MUX2 $PINS O=n2824 S=FE_OFN2088_n1515 A=FE_OFN889_branch_metrics_4__1__7
+ B=FE_OFN2161_N822
XU4702 MUX2 $PINS O=n2825 S=FE_OFN2088_n1515 A=branch_metrics[4][1][6]
+ B=FE_OFN2160_N821
XU4703 MUX2 $PINS O=n2833 S=FE_OFN2085_n1515 A=branch_metrics[4][2][10]
+ B=FE_OFN2172_N940
XU4704 MUX2 $PINS O=n2834 S=FE_OFN2087_n1515 A=FE_OFN899_branch_metrics_4__2__9
+ B=FE_OFN2171_N939
XU4705 MUX2 $PINS O=n2835 S=FE_OFN2087_n1515 A=FE_OFN900_branch_metrics_4__2__8
+ B=FE_OFN2170_N938
XU4706 MUX2 $PINS O=n2836 S=FE_OFN2089_n1515 A=FE_OFN901_branch_metrics_4__2__7
+ B=FE_OFN2169_N937
XU4707 MUX2 $PINS O=n2042 S=n1530 A=forward_metrics[1][0][9] B=n4195
XU4708 MUX2 $PINS O=n2676 S=n1518 A=branch_metrics[1][1][11] B=FE_OFN2165_N826
XU4709 MUX2 $PINS O=n2677 S=n1518 A=branch_metrics[1][1][10] B=FE_OFN2164_N825
XU4710 MUX2 $PINS O=n2678 S=FE_OFN2113_n1518 A=branch_metrics[1][1][9]
+ B=FE_OFN2163_N824
XU4711 MUX2 $PINS O=n2679 S=FE_OFN2113_n1518 A=FE_OFN744_branch_metrics_1__1__8
+ B=FE_OFN2162_N823
XU4712 MUX2 $PINS O=n2680 S=FE_OFN2115_n1518 A=branch_metrics[1][1][7]
+ B=FE_OFN2161_N822
XU4713 MUX2 $PINS O=n2681 S=FE_OFN2115_n1518 A=branch_metrics[1][1][6]
+ B=FE_OFN2160_N821
XU4714 MUX2 $PINS O=n2689 S=FE_OFN2116_n1518 A=branch_metrics[1][2][10]
+ B=FE_OFN2172_N940
XU4715 MUX2 $PINS O=n2690 S=FE_OFN2116_n1518 A=branch_metrics[1][2][9]
+ B=FE_OFN2171_N939
XU4716 MUX2 $PINS O=n2691 S=FE_OFN2116_n1518 A=branch_metrics[1][2][8]
+ B=FE_OFN2170_N938
XU4717 MUX2 $PINS O=n2692 S=FE_OFN2118_n1518 A=branch_metrics[1][2][7]
+ B=FE_OFN2169_N937
XU4718 MUX2 $PINS O=n2693 S=FE_OFN2118_n1518 A=FE_OFN758_branch_metrics_1__2__6
+ B=FE_OFN2168_N936
XU4719 MUX2 $PINS O=n2617 S=FE_OFN2126_n1519 A=forward_sum[0][0][10]
+ B=FE_OFN2191_N710
XU4720 MUX2 $PINS O=n2089 S=FE_OFN2030_n1534 A=forward_metrics[2][0][10]
+ B=n4194
XU4721 MUX2 $PINS O=n2090 S=n1534 A=forward_metrics[2][0][9] B=n4195
XU4722 MUX2 $PINS O=n2091 S=FE_OFN2029_n1534 A=forward_metrics[2][0][8] B=n4196
XU4723 MUX2 $PINS O=n2092 S=FE_OFN2032_n1534 A=forward_metrics[2][0][7] B=n4197
XU4724 MUX2 $PINS O=n2093 S=FE_OFN2033_n1534 A=forward_metrics[2][0][6] B=n4198
XU4725 MUX2 $PINS O=n2724 S=FE_OFN2103_n1517
+ A=FE_OFN789_branch_metrics_2__1__11 B=FE_OFN2165_N826
XU4726 MUX2 $PINS O=n2725 S=FE_OFN2103_n1517
+ A=FE_OFN790_branch_metrics_2__1__10 B=FE_OFN2164_N825
XU4727 MUX2 $PINS O=n2726 S=n1517 A=FE_OFN791_branch_metrics_2__1__9
+ B=FE_OFN2163_N824
XU4728 MUX2 $PINS O=n2727 S=n1517 A=branch_metrics[2][1][8] B=FE_OFN2162_N823
XU4729 MUX2 $PINS O=n2728 S=FE_OFN2109_n1517 A=branch_metrics[2][1][7]
+ B=FE_OFN2161_N822
XU4730 MUX2 $PINS O=n2729 S=FE_OFN2109_n1517 A=branch_metrics[2][1][6]
+ B=FE_OFN2160_N821
XU4731 MUX2 $PINS O=n2712 S=FE_OFN2107_n1517
+ A=FE_OFN777_branch_metrics_2__0__11 B=FE_OFN2192_N711
XU4732 MUX2 $PINS O=n2713 S=FE_OFN2107_n1517 A=branch_metrics[2][0][10]
+ B=FE_OFN2191_N710
XU4733 MUX2 $PINS O=n2714 S=FE_OFN2108_n1517 A=branch_metrics[2][0][9]
+ B=FE_OFN2190_N709
XU4734 MUX2 $PINS O=n2715 S=FE_OFN2108_n1517 A=branch_metrics[2][0][8]
+ B=FE_OFN2189_N708
XU4735 MUX2 $PINS O=n2716 S=FE_OFN2112_n1517 A=FE_OFN781_branch_metrics_2__0__7
+ B=FE_OFN2188_N707
XU4736 MUX2 $PINS O=n2892 S=FE_OFN2073_n1514
+ A=FE_OFN956_branch_metrics_5__3__11 B=FE_OFN2180_N1057
XU4737 MUX2 $PINS O=n2893 S=FE_OFN2073_n1514
+ A=FE_OFN957_branch_metrics_5__3__10 B=FE_OFN2179_N1056
XU4738 MUX2 $PINS O=n2894 S=FE_OFN2068_n1514 A=FE_OFN958_branch_metrics_5__3__9
+ B=FE_OFN2178_N1055
XU4739 MUX2 $PINS O=n2895 S=FE_OFN2068_n1514 A=FE_OFN959_branch_metrics_5__3__8
+ B=FE_OFN2177_N1054
XU4740 MUX2 $PINS O=n2896 S=FE_OFN2076_n1514 A=FE_OFN960_branch_metrics_5__3__7
+ B=FE_OFN2176_N1053
XU4741 MUX2 $PINS O=n2633 S=FE_OFN2125_n1519 A=forward_sum[0][6][6] B=N821
XU4742 ND2 $PINS O=n4631 I1=LLR_sum[6][6][0] I2=FE_OFN5628_FE_OFN1416_n1441
XU4743 OAI12HS $PINS O=n4222 A1=n4631 B1=FE_OFN1573_n4217 B2=n4216
XU4744 AOI22S $PINS O=n4218 A1=forward_sum[1][6][0]
+ A2=FE_OFN1637_FE_DBTN86_n985 B1=forward_sum[4][6][0]
+ B2=FE_OFN5610_FE_OFN1897_n5509
XU4745 OAI112HS $PINS O=n4221 A1=n4219 B1=n4218 C1=FE_OFN1469_n987 C2=n4220
XU4746 AO112 $PINS O=n4298 A1=n4222 B1=n4221 C1=forward_sum[5][6][0] C2=n3966
XU4747 MUX2 $PINS O=n4251 S=FE_OFN509_FE_DBTN91_n1503 A=N461 B=n4298
XU4748 MUX2 $PINS O=n2297 S=FE_OFN1780_n1527 A=forward_metrics[6][1][6] B=n4232
XU4749 MUX2 $PINS O=n2940 S=FE_OFN2146_n4223 A=branch_metrics[6][3][11]
+ B=FE_OFN2180_N1057
XU4750 MUX2 $PINS O=n2941 S=n4223 A=FE_OFN969_branch_metrics_6__3__10
+ B=FE_OFN2179_N1056
XU4751 MUX2 $PINS O=n2942 S=n4223 A=backward_sum[0][3][9] B=FE_OFN2178_N1055
XU4752 MUX2 $PINS O=n2943 S=FE_OFN2145_n4223 A=backward_sum[0][3][8]
+ B=FE_OFN2177_N1054
XU4753 MUX2 $PINS O=n2944 S=FE_OFN2148_n4223 A=backward_sum[0][3][7]
+ B=FE_OFN2176_N1053
XU4754 MUX2 $PINS O=n2945 S=FE_OFN2150_n4223 A=backward_sum[0][3][6]
+ B=FE_OFN2175_N1052
XU4755 MUX2 $PINS O=n2632 S=FE_OFN2123_n1519 A=forward_sum[0][6][7] B=N822
XU4756 MUX2 $PINS O=n2308 S=FE_OFN1777_n1527 A=forward_metrics[6][2][7] B=n4224
XU4757 MUX2 $PINS O=n2152 S=FE_OFN1970_n1529 A=forward_metrics[3][1][7] B=n4231
XU4758 MUX2 $PINS O=n2796 S=FE_OFN2095_n1516
+ A=FE_OFN861_branch_metrics_3__3__11 B=N1057
XU4759 MUX2 $PINS O=n2797 S=FE_OFN2095_n1516 A=branch_metrics[3][3][10] B=N1056
XU4760 MUX2 $PINS O=n2798 S=FE_OFN2095_n1516 A=branch_metrics[3][3][9]
+ B=FE_OFN2178_N1055
XU4761 MUX2 $PINS O=n2799 S=FE_OFN2099_n1516 A=branch_metrics[3][3][8]
+ B=FE_OFN2177_N1054
XU4762 MUX2 $PINS O=n2631 S=FE_OFN2123_n1519 A=forward_sum[0][6][8] B=N823
XU4763 MUX2 $PINS O=n2163 S=FE_OFN1968_n1529 A=forward_metrics[3][2][8] B=n4225
XU4764 MUX2 $PINS O=n2199 S=FE_OFN2017_n1533 A=forward_metrics[4][1][8] B=n4230
XU4765 MUX2 $PINS O=n2844 S=FE_OFN2084_n1515
+ A=FE_OFN909_branch_metrics_4__3__11 B=FE_OFN2180_N1057
XU4766 MUX2 $PINS O=n2845 S=FE_OFN2085_n1515 A=branch_metrics[4][3][10]
+ B=FE_OFN2179_N1056
XU4767 MUX2 $PINS O=n2846 S=n1515 A=FE_OFN911_branch_metrics_4__3__9
+ B=FE_OFN2178_N1055
XU4768 MUX2 $PINS O=n2847 S=FE_OFN2083_n1515 A=branch_metrics[4][3][8]
+ B=FE_OFN2177_N1054
XU4769 MUX2 $PINS O=n2630 S=n1519 A=FE_OFN1000_forward_sum_0__6__9 B=N824
XU4770 MUX2 $PINS O=n2210 S=FE_OFN2013_n1533 A=forward_metrics[4][2][9] B=n4226
XU4771 MUX2 $PINS O=n2054 S=FE_OFN1979_n1530 A=forward_metrics[1][1][9] B=n4229
XU4772 MUX2 $PINS O=n2700 S=n1518 A=FE_OFN765_branch_metrics_1__3__11
+ B=FE_OFN2180_N1057
XU4773 MUX2 $PINS O=n2701 S=FE_OFN2114_n1518
+ A=FE_OFN766_branch_metrics_1__3__10 B=FE_OFN2179_N1056
XU4774 MUX2 $PINS O=n2702 S=n1518 A=branch_metrics[1][3][9] B=FE_OFN2178_N1055
XU4775 MUX2 $PINS O=n2703 S=FE_OFN2113_n1518 A=FE_OFN768_branch_metrics_1__3__8
+ B=FE_OFN2177_N1054
XU4776 MUX2 $PINS O=n2704 S=FE_OFN2113_n1518 A=FE_OFN769_branch_metrics_1__3__7
+ B=FE_OFN2176_N1053
XU4777 MUX2 $PINS O=n2629 S=FE_OFN2124_n1519 A=forward_sum[0][4][10]
+ B=FE_OFN2164_N825
XU4778 MUX2 $PINS O=n2065 S=FE_OFN1981_n1530 A=forward_metrics[1][2][10]
+ B=n4227
XU4779 MUX2 $PINS O=n2101 S=FE_OFN2030_n1534 A=forward_metrics[2][1][10]
+ B=n4228
XU4780 MUX2 $PINS O=n2102 S=n1534 A=forward_metrics[2][1][9] B=n4229
XU4781 MUX2 $PINS O=n2103 S=FE_OFN2029_n1534 A=forward_metrics[2][1][8] B=n4230
XU4782 MUX2 $PINS O=n2104 S=FE_OFN2032_n1534 A=forward_metrics[2][1][7] B=n4231
XU4783 MUX2 $PINS O=n2105 S=FE_OFN2033_n1534 A=forward_metrics[2][1][6] B=n4232
XU4784 MUX2 $PINS O=n2748 S=FE_OFN2103_n1517
+ A=FE_OFN813_branch_metrics_2__3__11 B=FE_OFN2180_N1057
XU4785 MUX2 $PINS O=n2749 S=FE_OFN2103_n1517 A=branch_metrics[2][3][10]
+ B=FE_OFN2179_N1056
XU4786 MUX2 $PINS O=n2750 S=FE_OFN2103_n1517 A=branch_metrics[2][3][9]
+ B=FE_OFN2178_N1055
XU4787 MUX2 $PINS O=n2751 S=n1517 A=branch_metrics[2][3][8] B=FE_OFN2177_N1054
XU4788 MUX2 $PINS O=n2752 S=FE_OFN2108_n1517 A=FE_OFN817_branch_metrics_2__3__7
+ B=FE_OFN2176_N1053
XU4789 MUX2 $PINS O=n2628 S=FE_OFN2124_n1519 A=forward_sum[0][4][11]
+ B=FE_OFN2165_N826
XU4790 MUX2 $PINS O=n2112 S=FE_OFN2030_n1534 A=forward_metrics[2][2][11]
+ B=n4240
XU4791 MUX2 $PINS O=n2321 S=FE_OFN1778_n1527 A=forward_metrics[6][3][6] B=n4245
XU4792 MUX2 $PINS O=n2176 S=FE_OFN1970_n1529 A=forward_metrics[3][3][7] B=n4244
XU4793 MUX2 $PINS O=n2223 S=n1533 A=forward_metrics[4][3][8] B=n4243
XU4794 MUX2 $PINS O=n2078 S=FE_OFN1979_n1530 A=forward_metrics[1][3][9] B=n4242
XU4795 MUX2 $PINS O=n2125 S=FE_OFN2028_n1534 A=forward_metrics[2][3][10]
+ B=n4241
XU4796 MUX2 $PINS O=n2126 S=FE_OFN2028_n1534 A=forward_metrics[2][3][9] B=n4242
XU4797 MUX2 $PINS O=n2127 S=FE_OFN2029_n1534 A=forward_metrics[2][3][8] B=n4243
XU4798 MUX2 $PINS O=n2128 S=FE_OFN2031_n1534 A=forward_metrics[2][3][7] B=n4244
XU4799 MUX2 $PINS O=n2124 S=FE_OFN2030_n1534 A=forward_metrics[2][3][11]
+ B=n4252
XU4800 MUX2 $PINS O=n2737 S=FE_OFN2107_n1517 A=branch_metrics[2][2][10]
+ B=FE_OFN2172_N940
XU4801 MUX2 $PINS O=n2738 S=FE_OFN2108_n1517 A=FE_OFN803_branch_metrics_2__2__9
+ B=FE_OFN2171_N939
XU4802 MUX2 $PINS O=n2739 S=FE_OFN2108_n1517 A=FE_OFN804_branch_metrics_2__2__8
+ B=FE_OFN2170_N938
XU4803 MUX2 $PINS O=n2740 S=FE_OFN2112_n1517 A=FE_OFN805_branch_metrics_2__2__7
+ B=FE_OFN2169_N937
XU4804 MUX2 $PINS O=n2741 S=FE_OFN2112_n1517 A=FE_OFN806_branch_metrics_2__2__6
+ B=FE_OFN2168_N936
XU4805 MUX2 $PINS O=n2616 S=FE_OFN2124_n1519 A=forward_sum[0][0][11]
+ B=FE_OFN2192_N711
XU4806 MUX2 $PINS O=n2100 S=FE_OFN2030_n1534 A=forward_metrics[2][1][11]
+ B=n4254
XU4807 MUX2 $PINS O=n2088 S=FE_OFN2030_n1534 A=forward_metrics[2][0][11]
+ B=n4255
XU4808 MUX2 $PINS O=n2400 S=FE_OFN2004_n1532 A=backward_metrics[2][2][11]
+ B=n1462
XU4809 MUX2 $PINS O=n2401 S=FE_OFN2004_n1532 A=backward_metrics[2][2][10]
+ B=n1481
XU4810 MUX2 $PINS O=n2402 S=n1532 A=backward_metrics[2][2][9] B=n1478
XU4811 MUX2 $PINS O=n2403 S=n1532 A=backward_metrics[2][2][8] B=n1476
XU4812 MUX2 $PINS O=n2404 S=FE_OFN2003_n1532 A=backward_metrics[2][2][7]
+ B=n1473
XU4813 MUX2 $PINS O=n2405 S=FE_OFN2003_n1532 A=backward_metrics[2][2][6]
+ B=n1465
XU4814 MUX2 $PINS O=n2406 S=FE_OFN2009_n1532 A=backward_metrics[2][2][5]
+ B=n1470
XU4815 MUX2 $PINS O=n2407 S=FE_OFN2009_n1532
+ A=FE_OFN1089_backward_metrics_2__2__4 B=n1485
XU4816 MUX2 $PINS O=n2408 S=FE_OFN2008_n1532 A=backward_metrics[2][2][3]
+ B=n1468
XU4817 MUX2 $PINS O=n2412 S=FE_OFN2004_n1532 A=backward_metrics[2][3][11]
+ B=n1463
XU4818 MUX2 $PINS O=n2413 S=FE_OFN2004_n1532 A=backward_metrics[2][3][10]
+ B=n1483
XU4819 MUX2 $PINS O=n2414 S=FE_OFN2004_n1532
+ A=FE_OFN1096_backward_metrics_2__3__9 B=n1482
XU4820 MUX2 $PINS O=n2415 S=FE_OFN2003_n1532 A=backward_metrics[2][3][8]
+ B=n1480
XU4821 MUX2 $PINS O=n2416 S=FE_OFN2003_n1532 A=backward_metrics[2][3][7]
+ B=n1479
XU4822 MUX2 $PINS O=n2417 S=FE_OFN2003_n1532
+ A=FE_OFN1099_backward_metrics_2__3__6 B=n1466
XU4823 MUX2 $PINS O=n2364 S=n1526 A=backward_metrics[1][3][11] B=n1463
XU4824 MUX2 $PINS O=n2365 S=n1526 A=backward_metrics[1][3][10] B=n1483
XU4825 MUX2 $PINS O=n2366 S=n1526 A=backward_metrics[1][3][9] B=n1482
XU4826 MUX2 $PINS O=n2367 S=FE_OFN1941_n1526 A=backward_metrics[1][3][8]
+ B=n1480
XU4827 MUX2 $PINS O=n2368 S=FE_OFN1941_n1526
+ A=FE_OFN1050_backward_metrics_1__3__7 B=n1479
XU4828 MUX2 $PINS O=n2369 S=FE_OFN1941_n1526
+ A=FE_OFN1051_backward_metrics_1__3__6 B=n1466
XU4829 MUX2 $PINS O=n2370 S=FE_OFN1946_n1526 A=backward_metrics[1][3][5]
+ B=n1474
XU4830 MUX2 $PINS O=n2371 S=FE_OFN1946_n1526
+ A=FE_OFN1053_backward_metrics_1__3__4 B=n1461
XU4831 AO222S $PINS O=n4306 A1=backward_sum[6][7][1]
+ A2=FE_OFN5626_FE_OFN1416_n1441 B1=backward_sum[3][7][1] B2=FE_OFN5539_n
+ C1=backward_sum[5][7][1] C2=n3966
XU4832 AOI22S $PINS O=n4305 A1=backward_sum[1][7][1] A2=FE_OFN5670_n
+ B1=backward_sum[4][7][1] B2=FE_OFN1897_n5509
XU4833 AOI12HS $PINS O=n4304 A1=n1569 B1=backward_sum[2][7][1]
+ B2=FE_OFN5589_FE_OFN5578_n
XU4834 OR3B2 $PINS O=n4449 I1=n4306 B1=n4305 B2=n4304
XU4835 AO222S $PINS O=n4309 A1=backward_sum[6][6][1] A2=FE_OFN1406_n1441
+ B1=backward_sum[3][6][1] B2=FE_OFN1740_FE_DBTN71_n4217 C1=backward_sum[5][6][1]
+ C2=FE_OFN1541_n1442
XU4836 AOI22S $PINS O=n4308 A1=backward_sum[1][6][1]
+ A2=FE_OFN1648_FE_DBTN86_n985 B1=backward_sum[4][6][1] B2=FE_OFN1918_n5509
XU4837 AOI12HS $PINS O=n4307 A1=n1663 B1=backward_sum[2][6][1] B2=FE_OFN5667_n
XU4838 OR3B2 $PINS O=N551 I1=n4309 B1=n4308 B2=n4307
XU4839 MUX2 $PINS O=n4429 S=FE_OFN5512_n1455 A=n4449 B=N551
XU4840 AO222S $PINS O=n4312 A1=backward_sum[6][7][0]
+ A2=FE_OFN5626_FE_OFN1416_n1441 B1=backward_sum[3][7][0] B2=FE_OFN5539_n
+ C1=backward_sum[5][7][0] C2=FE_OFN1518_n1442
XU4841 AOI22S $PINS O=n4311 A1=backward_sum[1][7][0]
+ A2=FE_OFN1625_FE_DBTN86_n985 B1=backward_sum[4][7][0]
+ B2=FE_OFN5608_FE_OFN1897_n5509
XU4842 AOI12HS $PINS O=n4310 A1=n1570 B1=backward_sum[2][7][0]
+ B2=FE_OFN5589_FE_OFN5578_n
XU4843 OR3B2 $PINS O=N564 I1=n4312 B1=n4311 B2=n4310
XU4844 AO222S $PINS O=n4315 A1=backward_sum[6][6][0] A2=FE_OFN1400_n1441
+ B1=backward_sum[3][6][0] B2=FE_OFN1748_FE_DBTN71_n4217 C1=backward_sum[5][6][0]
+ C2=FE_OFN1541_n1442
XU4845 AOI22S $PINS O=n4314 A1=backward_sum[1][6][0]
+ A2=FE_OFN1648_FE_DBTN86_n985 B1=backward_sum[4][6][0] B2=FE_OFN2193_n3782
XU4846 AOI12HS $PINS O=n4313 A1=n1661 B1=backward_sum[2][6][0] B2=FE_OFN5667_n
XU4847 OR3B2 $PINS O=n4448 I1=n4315 B1=n4314 B2=n4313
XU4848 MUX2 $PINS O=n4428 S=FE_OFN5512_n1455 A=N564 B=n4448
XU4849 MUX2 $PINS O=n2508 S=n1531 A=backward_metrics[4][3][11] B=n1463
XU4850 MUX2 $PINS O=n2509 S=n1531 A=backward_metrics[4][3][10] B=n1483
XU4851 MUX2 $PINS O=n2510 S=FE_OFN1992_n1531 A=backward_metrics[4][3][9]
+ B=n1482
XU4852 MUX2 $PINS O=n2511 S=FE_OFN1992_n1531 A=backward_metrics[4][3][8]
+ B=n1480
XU4853 MUX2 $PINS O=n2512 S=FE_OFN1992_n1531
+ A=FE_OFN1194_backward_metrics_4__3__7 B=n1479
XU4854 MUX2 $PINS O=n2513 S=FE_OFN1994_n1531
+ A=FE_OFN1195_backward_metrics_4__3__6 B=n1466
XU4855 MUX2 $PINS O=n2514 S=FE_OFN1994_n1531
+ A=FE_OFN1196_backward_metrics_4__3__5 B=n1474
XU4856 MUX2 $PINS O=n2515 S=FE_OFN1994_n1531
+ A=FE_OFN1197_backward_metrics_4__3__4 B=n1461
XU4857 MUX2 $PINS O=n2516 S=FE_OFN1994_n1531
+ A=FE_OFN1198_backward_metrics_4__3__3 B=n1471
XU4858 MUX2 $PINS O=n2460 S=n1525 A=backward_metrics[3][3][11] B=n1463
XU4859 MUX2 $PINS O=n2461 S=n1525 A=backward_metrics[3][3][10] B=n1483
XU4860 MUX2 $PINS O=n2462 S=FE_OFN1932_n1525 A=backward_metrics[3][3][9]
+ B=n1482
XU4861 MUX2 $PINS O=n2463 S=FE_OFN1932_n1525 A=backward_metrics[3][3][8]
+ B=n1480
XU4862 MUX2 $PINS O=n2464 S=FE_OFN1932_n1525 A=backward_metrics[3][3][7]
+ B=n1479
XU4863 MUX2 $PINS O=n2465 S=FE_OFN1934_n1525
+ A=FE_OFN1147_backward_metrics_3__3__6 B=n1466
XU4864 MUX2 $PINS O=n2604 S=FE_OFN1761_n1523 A=backward_metrics[6][3][11]
+ B=n1463
XU4865 MUX2 $PINS O=n2605 S=FE_OFN1761_n1523 A=backward_metrics[6][3][10]
+ B=n1483
XU4866 MUX2 $PINS O=n2606 S=FE_OFN1761_n1523
+ A=FE_OFN1266_backward_metrics_6__3__9 B=n1482
XU4867 MUX2 $PINS O=n2607 S=n1523 A=FE_OFN1267_backward_metrics_6__3__8 B=n1480
XU4868 MUX2 $PINS O=n2608 S=n1523 A=FE_OFN1268_backward_metrics_6__3__7 B=n1479
XU4869 MUX2 $PINS O=n2609 S=FE_OFN1765_n1523 A=backward_metrics[6][3][6]
+ B=n1466
XU4870 MUX2 $PINS O=n2610 S=FE_OFN1764_n1523
+ A=FE_OFN1270_backward_metrics_6__3__5 B=n1474
XU4871 MUX2 $PINS O=n2611 S=FE_OFN1764_n1523
+ A=FE_OFN1271_backward_metrics_6__3__4 B=n1461
XU4872 MUX2 $PINS O=n2556 S=FE_OFN1922_n1524
+ A=FE_OFN1238_backward_metrics_5__3__11 B=n1463
XU4873 MUX2 $PINS O=n2557 S=FE_OFN1922_n1524
+ A=FE_OFN1239_backward_metrics_5__3__10 B=n1483
XU4874 MUX2 $PINS O=n2558 S=FE_OFN1922_n1524
+ A=FE_OFN1240_backward_metrics_5__3__9 B=n1482
XU4875 MUX2 $PINS O=n2559 S=n1524 A=backward_metrics[5][3][8] B=n1480
XU4876 MUX2 $PINS O=n2560 S=n1524 A=backward_metrics[5][3][7] B=n1479
XU4877 MUX2 $PINS O=n2561 S=n1524 A=FE_OFN1243_backward_metrics_5__3__6 B=n1466
XU4878 MUX2 $PINS O=n2562 S=FE_OFN1927_n1524
+ A=FE_OFN1244_backward_metrics_5__3__5 B=n1474
XU4879 MUX2 $PINS O=n2563 S=FE_OFN1927_n1524
+ A=FE_OFN1245_backward_metrics_5__3__4 B=n1461
XU4880 MUX2 $PINS O=n2564 S=FE_OFN1927_n1524
+ A=FE_OFN1246_backward_metrics_5__3__3 B=n1471
XU4881 MUX2 $PINS O=n2388 S=FE_OFN2005_n1532
+ A=FE_OFN1070_backward_metrics_2__1__11 B=n1546
XU4882 MUX2 $PINS O=n2389 S=FE_OFN2005_n1532
+ A=FE_OFN1071_backward_metrics_2__1__10 B=n1547
XU4883 MUX2 $PINS O=n2390 S=FE_OFN2005_n1532 A=backward_metrics[2][1][9]
+ B=n1477
XU4884 MUX2 $PINS O=n2391 S=FE_OFN2007_n1532 A=backward_metrics[2][1][8]
+ B=n1475
XU4885 MUX2 $PINS O=n2392 S=FE_OFN2007_n1532 A=backward_metrics[2][1][7]
+ B=n1472
XU4886 MUX2 $PINS O=n2393 S=FE_OFN2007_n1532 A=backward_metrics[2][1][6]
+ B=n1464
XU4887 MUX2 $PINS O=n2394 S=FE_OFN2011_n1532 A=backward_metrics[2][1][5]
+ B=n1469
XU4888 MUX2 $PINS O=n2395 S=FE_OFN2011_n1532 A=backward_metrics[2][1][4]
+ B=n1484
XU4889 MUX2 $PINS O=n2396 S=FE_OFN2009_n1532 A=backward_metrics[2][1][3]
+ B=n1467
XU4890 AO222S $PINS O=n4319 A1=backward_sum[6][5][0]
+ A2=FE_OFN5626_FE_OFN1416_n1441 B1=backward_sum[3][5][0] B2=FE_OFN5539_n
+ C1=backward_sum[5][5][0] C2=FE_OFN1518_n1442
XU4891 AOI22S $PINS O=n4318 A1=backward_sum[1][5][0] A2=FE_OFN5670_n
+ B1=backward_sum[4][5][0] B2=FE_OFN1897_n5509
XU4892 AOI12HS $PINS O=n4317 A1=n1572 B1=backward_sum[2][5][0]
+ B2=FE_OFN5591_FE_OFN5578_n
XU4893 OR3B2 $PINS O=N540 I1=n4319 B1=n4318 B2=n4317
XU4894 MUX2 $PINS O=n2352 S=FE_OFN1942_n1526 A=backward_metrics[1][2][11]
+ B=n1462
XU4895 MUX2 $PINS O=n2353 S=FE_OFN1942_n1526 A=backward_metrics[1][2][10]
+ B=n1481
XU4896 MUX2 $PINS O=n2354 S=FE_OFN1941_n1526 A=backward_metrics[1][2][9]
+ B=n1478
XU4897 MUX2 $PINS O=n2355 S=FE_OFN1943_n1526 A=backward_metrics[1][2][8]
+ B=n1476
XU4898 MUX2 $PINS O=n2356 S=FE_OFN1947_n1526 A=backward_metrics[1][2][7]
+ B=n1473
XU4899 MUX2 $PINS O=n2357 S=FE_OFN1947_n1526 A=backward_metrics[1][2][6]
+ B=n1465
XU4900 MUX2 $PINS O=n2358 S=FE_OFN1949_n1526
+ A=FE_OFN1040_backward_metrics_1__2__5 B=n1470
XU4901 MUX2 $PINS O=n2359 S=FE_OFN1948_n1526 A=backward_metrics[1][2][4]
+ B=n1485
XU4902 MUX2 $PINS O=n2360 S=FE_OFN1946_n1526 A=backward_metrics[1][2][3]
+ B=n1468
XU4903 AO222S $PINS O=n4322 A1=backward_sum[6][5][1]
+ A2=FE_OFN5626_FE_OFN1416_n1441 B1=backward_sum[3][5][1]
+ B2=FE_OFN1723_FE_DBTN71_n4217 C1=backward_sum[5][5][1] C2=FE_OFN1518_n1442
XU4904 AOI22S $PINS O=n4321 A1=backward_sum[1][5][1] A2=FE_OFN5670_n
+ B1=backward_sum[4][5][1] B2=FE_OFN1897_n5509
XU4905 AOI12HS $PINS O=n4320 A1=n1571 B1=backward_sum[2][5][1]
+ B2=FE_OFN5589_FE_OFN5578_n
XU4906 OR3B2 $PINS O=n4447 I1=n4322 B1=n4321 B2=n4320
XU4907 AO222S $PINS O=n4325 A1=backward_sum[6][4][1] A2=FE_OFN1406_n1441
+ B1=backward_sum[3][4][1] B2=FE_OFN1748_FE_DBTN71_n4217 C1=backward_sum[5][4][1]
+ C2=FE_OFN1541_n1442
XU4908 AOI22S $PINS O=n4324 A1=backward_sum[1][4][1]
+ A2=FE_OFN1649_FE_DBTN86_n985 B1=backward_sum[4][4][1] B2=FE_OFN1918_n5509
XU4909 AOI12HS $PINS O=n4323 A1=n1664 B1=backward_sum[2][4][1] B2=FE_OFN5667_n
XU4910 OR3B2 $PINS O=N527 I1=n4325 B1=n4324 B2=n4323
XU4911 MUX2P $PINS O=n4430 S=FE_OFN1429_FE_DBTN88_n1454 A=n4447 B=N527
XU4912 AO222S $PINS O=n4328 A1=backward_sum[6][4][0] A2=FE_OFN1400_n1441
+ B1=backward_sum[3][4][0] B2=FE_OFN1748_FE_DBTN71_n4217 C1=backward_sum[5][4][0]
+ C2=FE_OFN1541_n1442
XU4913 AOI22S $PINS O=n4327 A1=backward_sum[1][4][0]
+ A2=FE_OFN1648_FE_DBTN86_n985 B1=backward_sum[4][4][0] B2=FE_OFN2193_n3782
XU4914 AOI12HS $PINS O=n4326 A1=n1662 B1=backward_sum[2][4][0] B2=FE_OFN5666_n
XU4915 OR3B2 $PINS O=n4446 I1=n4328 B1=n4327 B2=n4326
XU4916 MUX2 $PINS O=n4426 S=FE_OFN1429_FE_DBTN88_n1454 A=N540 B=n4446
XU4917 MUX2 $PINS O=n2496 S=FE_OFN1993_n1531 A=backward_metrics[4][2][11]
+ B=n1462
XU4918 MUX2 $PINS O=n2497 S=FE_OFN1993_n1531 A=backward_metrics[4][2][10]
+ B=n1481
XU4919 MUX2 $PINS O=n2498 S=FE_OFN1992_n1531 A=backward_metrics[4][2][9]
+ B=n1478
XU4920 MUX2 $PINS O=n2499 S=FE_OFN1992_n1531 A=backward_metrics[4][2][8]
+ B=n1476
XU4921 MUX2 $PINS O=n2500 S=FE_OFN1995_n1531 A=backward_metrics[4][2][7]
+ B=n1473
XU4922 MUX2 $PINS O=n2501 S=FE_OFN1995_n1531 A=backward_metrics[4][2][6]
+ B=n1465
XU4923 MUX2 $PINS O=n2502 S=FE_OFN1995_n1531 A=backward_metrics[4][2][5]
+ B=n1470
XU4924 MUX2 $PINS O=n2503 S=FE_OFN1997_n1531 A=backward_metrics[4][2][4]
+ B=n1485
XU4925 MUX2 $PINS O=n2504 S=FE_OFN1997_n1531
+ A=FE_OFN1186_backward_metrics_4__2__3 B=n1468
XU4926 MUX2 $PINS O=n2448 S=FE_OFN1933_n1525 A=backward_metrics[3][2][11]
+ B=n1462
XU4927 MUX2 $PINS O=n2449 S=FE_OFN1933_n1525
+ A=FE_OFN1131_backward_metrics_3__2__10 B=n1481
XU4928 MUX2 $PINS O=n2450 S=FE_OFN1932_n1525
+ A=FE_OFN1132_backward_metrics_3__2__9 B=n1478
XU4929 MUX2 $PINS O=n2451 S=FE_OFN1932_n1525 A=backward_metrics[3][2][8]
+ B=n1476
XU4930 MUX2 $PINS O=n2452 S=FE_OFN1934_n1525 A=backward_metrics[3][2][7]
+ B=n1473
XU4931 MUX2 $PINS O=n2453 S=FE_OFN1936_n1525 A=backward_metrics[3][2][6]
+ B=n1465
XU4932 MUX2 $PINS O=n2454 S=FE_OFN1934_n1525
+ A=FE_OFN1136_backward_metrics_3__2__5 B=n1470
XU4933 MUX2 $PINS O=n2455 S=FE_OFN1937_n1525
+ A=FE_OFN1137_backward_metrics_3__2__4 B=n1485
XU4934 MUX2 $PINS O=n2456 S=FE_OFN1935_n1525 A=backward_metrics[3][2][3]
+ B=n1468
XU4935 MUX2 $PINS O=n2457 S=FE_OFN1935_n1525 A=backward_metrics[3][2][2]
+ B=n1459
XU4936 MUX2 $PINS O=n2592 S=FE_OFN1763_n1523 A=backward_metrics[6][2][11]
+ B=n1462
XU4937 MUX2 $PINS O=n2593 S=FE_OFN1761_n1523 A=backward_metrics[6][2][10]
+ B=n1481
XU4938 MUX2 $PINS O=n2594 S=FE_OFN1761_n1523 A=backward_metrics[6][2][9]
+ B=n1478
XU4939 MUX2 $PINS O=n2595 S=n1523 A=backward_metrics[6][2][8] B=n1476
XU4940 MUX2 $PINS O=n2596 S=FE_OFN1765_n1523 A=backward_metrics[6][2][7]
+ B=n1473
XU4941 MUX2 $PINS O=n2597 S=FE_OFN1765_n1523 A=backward_metrics[6][2][6]
+ B=n1465
XU4942 MUX2 $PINS O=n2598 S=FE_OFN1765_n1523 A=backward_metrics[6][2][5]
+ B=n1470
XU4943 MUX2 $PINS O=n2599 S=FE_OFN1765_n1523 A=backward_metrics[6][2][4]
+ B=n1485
XU4944 MUX2 $PINS O=n2544 S=FE_OFN1922_n1524
+ A=FE_OFN1226_backward_metrics_5__2__11 B=n1462
XU4945 MUX2 $PINS O=n2545 S=FE_OFN1922_n1524
+ A=FE_OFN1227_backward_metrics_5__2__10 B=n1481
XU4946 MUX2 $PINS O=n2546 S=FE_OFN1922_n1524 A=backward_metrics[5][2][9]
+ B=n1478
XU4947 MUX2 $PINS O=n2547 S=FE_OFN1923_n1524 A=backward_metrics[5][2][8]
+ B=n1476
XU4948 MUX2 $PINS O=n2548 S=FE_OFN1924_n1524
+ A=FE_OFN1230_backward_metrics_5__2__7 B=n1473
XU4949 MUX2 $PINS O=n2549 S=FE_OFN1924_n1524 A=backward_metrics[5][2][6]
+ B=n1465
XU4950 MUX2 $PINS O=n2550 S=FE_OFN1924_n1524 A=backward_metrics[5][2][5]
+ B=n1470
XU4951 MUX2 $PINS O=n2551 S=FE_OFN1924_n1524 A=backward_metrics[5][2][4]
+ B=n1485
XU4952 MUX2 $PINS O=n2552 S=FE_OFN1927_n1524 A=backward_metrics[5][2][3]
+ B=n1468
XU4953 AO222S $PINS O=n4331 A1=backward_sum[6][3][0]
+ A2=FE_OFN5628_FE_OFN1416_n1441 B1=backward_sum[3][3][0] B2=FE_OFN5539_n
+ C1=backward_sum[5][3][0] C2=FE_OFN1536_n1442
XU4954 AOI22S $PINS O=n4330 A1=backward_sum[1][3][0]
+ A2=FE_OFN1638_FE_DBTN86_n985 B1=backward_sum[4][3][0]
+ B2=FE_OFN5608_FE_OFN1897_n5509
XU4955 AOI12HS $PINS O=n4329 A1=n1570 B1=backward_sum[2][3][0]
+ B2=FE_OFN5590_FE_OFN5578_n
XU4956 OR3B2 $PINS O=N516 I1=n4331 B1=n4330 B2=n4329
XU4957 AO222S $PINS O=n4335 A1=LLR_sum[0][4][11] A2=FE_OFN1373_n1441
+ B1=backward_sum[3][1][11] B2=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217
+ C1=backward_sum[5][1][11] C2=FE_OFN1488_n1442
XU4958 AOI22S $PINS O=n4334 A1=backward_sum[1][1][11]
+ A2=FE_OFN1605_FE_DBTN86_n985 B1=backward_sum[4][1][11] B2=FE_OFN1857_n5509
XU4959 AOI12HS $PINS O=n4333 A1=n6 B1=backward_sum[2][1][11]
+ B2=FE_OFN1696_FE_DBTN85_n987
XU4960 OR3B2 $PINS O=N481 I1=n4335 B1=n4334 B2=n4333
XU4961 AO222S $PINS O=n4338 A1=LLR_sum[0][0][11] A2=FE_OFN1402_n1441
+ B1=backward_sum[3][0][11] B2=FE_OFN1743_FE_DBTN71_n4217
+ C1=backward_sum[5][0][11] C2=FE_OFN1515_n1442
XU4962 AOI22S $PINS O=n4337 A1=backward_sum[1][0][11]
+ A2=FE_OFN1615_FE_DBTN86_n985 B1=backward_sum[4][0][11] B2=FE_OFN1864_n5509
XU4963 AOI22S $PINS O=n4336 A1=backward_sum[0][0][11] A2=FE_OFN1801_n5419
+ B1=backward_sum[2][0][11] B2=FE_OFN1705_FE_DBTN85_n987
XU4964 OR3B2 $PINS O=n4433 I1=n4338 B1=n4337 B2=n4336
XU4965 MUX2 $PINS O=n4431 S=FE_OFN511_FE_DBTN90_n1497 A=N481 B=n4433
XU4966 MUX2 $PINS O=n2328 S=FE_OFN1942_n1526
+ A=FE_OFN1010_backward_metrics_1__0__11 B=n4431
XU4967 AO222S $PINS O=n4341 A1=LLR_sum[0][4][10] A2=FE_OFN1373_n1441
+ B1=backward_sum[3][1][10] B2=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217
+ C1=backward_sum[5][1][10] C2=FE_OFN1488_n1442
XU4968 AOI22S $PINS O=n4340 A1=backward_sum[1][1][10]
+ A2=FE_OFN1605_FE_DBTN86_n985 B1=backward_sum[4][1][10] B2=FE_OFN1857_n5509
XU4969 AOI12HS $PINS O=n4339 A1=n1659 B1=backward_sum[2][1][10]
+ B2=FE_OFN1696_FE_DBTN85_n987
XU4970 OR3B2 $PINS O=n4435 I1=n4341 B1=n4340 B2=n4339
XU4971 AO222S $PINS O=n4344 A1=LLR_sum[0][0][10] A2=FE_OFN1402_n1441
+ B1=backward_sum[3][0][10] B2=FE_OFN1743_FE_DBTN71_n4217
+ C1=backward_sum[5][0][10] C2=FE_OFN1515_n1442
XU4972 AOI22S $PINS O=n4343 A1=backward_sum[1][0][10]
+ A2=FE_OFN1620_FE_DBTN86_n985 B1=backward_sum[4][0][10] B2=FE_OFN1864_n5509
XU4973 AOI22S $PINS O=n4342 A1=backward_sum[0][0][10] A2=FE_OFN1796_n5419
+ B1=backward_sum[2][0][10] B2=FE_OFN1705_FE_DBTN85_n987
XU4974 OR3B2 $PINS O=N470 I1=n4344 B1=n4343 B2=n4342
XU4975 MUX2 $PINS O=n4405 S=FE_OFN511_FE_DBTN90_n1497 A=FE_OFN2217_n4435 B=N470
XU4976 MUX2 $PINS O=n2329 S=FE_OFN1942_n1526 A=backward_metrics[1][0][10]
+ B=n4405
XU4977 AO222S $PINS O=n4347 A1=LLR_sum[0][0][9] A2=FE_OFN1382_n1441
+ B1=backward_sum[3][0][9] B2=FE_OFN1753_FE_DBTN71_n4217 C1=backward_sum[5][0][9]
+ C2=FE_OFN1528_n1442
XU4978 AOI22S $PINS O=n4346 A1=backward_sum[1][0][9]
+ A2=FE_OFN1618_FE_DBTN86_n985 B1=backward_sum[4][0][9] B2=FE_OFN1878_n5509
XU4979 AOI12HS $PINS O=n4345 A1=n1580 B1=backward_sum[2][0][9]
+ B2=FE_OFN5645_FE_OFN1690_FE_DBTN85_n987
XU4980 OR3B2 $PINS O=N471 I1=n4347 B1=n4346 B2=n4345
XU4981 AO222S $PINS O=n4350 A1=LLR_sum[0][4][9] A2=FE_OFN1370_n1441
+ B1=backward_sum[3][1][9] B2=FE_OFN1720_FE_DBTN71_n4217 C1=backward_sum[5][1][9]
+ C2=FE_OFN1490_n1442
XU4982 AOI22S $PINS O=n4349 A1=backward_sum[1][1][9] A2=FE_OFN5678_n
+ B1=backward_sum[4][1][9] B2=FE_OFN5566_n
XU4983 AOI12HS $PINS O=n4348 A1=n1577 B1=backward_sum[2][1][9]
+ B2=FE_OFN1678_FE_DBTN85_n987
XU4984 OR3B2 $PINS O=n4432 I1=n4350 B1=n4349 B2=n4348
XU4985 MUX2 $PINS O=n4406 S=FE_DBTN90_n1497 A=n4432 B=N471
XU4986 MUX2 $PINS O=n2330 S=FE_OFN1943_n1526
+ A=FE_OFN1012_backward_metrics_1__0__9 B=n4406
XU4987 MUX2 $PINS O=n2472 S=FE_OFN1993_n1531 A=backward_metrics[4][0][11]
+ B=n4431
XU4988 MUX2 $PINS O=n2473 S=FE_OFN1993_n1531 A=backward_metrics[4][0][10]
+ B=n4405
XU4989 MUX2 $PINS O=n2474 S=FE_OFN2002_n1531
+ A=FE_OFN1156_backward_metrics_4__0__9 B=n4406
XU4990 AO222S $PINS O=n4353 A1=LLR_sum[0][4][8] A2=FE_OFN1377_n1441
+ B1=backward_sum[3][1][8] B2=FE_OFN1727_FE_DBTN71_n4217 C1=backward_sum[5][1][8]
+ C2=FE_OFN1497_n1442
XU4991 AOI22S $PINS O=n4352 A1=backward_sum[1][1][8]
+ A2=FE_OFN1600_FE_DBTN86_n985 B1=backward_sum[4][1][8] B2=FE_OFN1870_n5509
XU4992 AOI12HS $PINS O=n4351 A1=n1578 B1=backward_sum[2][1][8]
+ B2=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987
XU4993 OR3B2 $PINS O=n4434 I1=n4353 B1=n4352 B2=n4351
XU4994 AO222S $PINS O=n4356 A1=LLR_sum[0][0][8] A2=FE_OFN1410_n1441
+ B1=backward_sum[3][0][8] B2=FE_OFN1749_FE_DBTN71_n4217 C1=backward_sum[5][0][8]
+ C2=FE_OFN1544_n1442
XU4995 AOI22S $PINS O=n4355 A1=backward_sum[1][0][8]
+ A2=FE_OFN1629_FE_DBTN86_n985 B1=backward_sum[4][0][8] B2=FE_OFN1902_n5509
XU4996 AOI12HS $PINS O=n4354 A1=n1581 B1=backward_sum[2][0][8]
+ B2=FE_OFN1685_FE_DBTN85_n987
XU4997 OR3B2 $PINS O=N472 I1=n4356 B1=n4355 B2=n4354
XU4998 MUX2 $PINS O=n4407 S=FE_DBTN90_n1497 A=n4434 B=N472
XU4999 MUX2 $PINS O=n2475 S=FE_OFN1995_n1531
+ A=FE_OFN1157_backward_metrics_4__0__8 B=n4407
XU5000 MUX2 $PINS O=n2424 S=FE_OFN1933_n1525 A=backward_metrics[3][0][11]
+ B=n4431
XU5001 MUX2 $PINS O=n2425 S=FE_OFN1933_n1525 A=backward_metrics[3][0][10]
+ B=n4405
XU5002 MUX2 $PINS O=n2426 S=FE_OFN1936_n1525 A=backward_metrics[3][0][9]
+ B=n4406
XU5003 MUX2 $PINS O=n2427 S=FE_OFN1936_n1525
+ A=FE_OFN1109_backward_metrics_3__0__8 B=n4407
XU5004 AO222S $PINS O=n4359 A1=LLR_sum[0][4][7] A2=FE_OFN1385_n1441
+ B1=backward_sum[3][1][7] B2=FE_OFN1738_FE_DBTN71_n4217 C1=backward_sum[5][1][7]
+ C2=FE_OFN1512_n1442
XU5005 AOI22S $PINS O=n4358 A1=backward_sum[1][1][7]
+ A2=FE_OFN5621_FE_OFN1636_FE_DBTN86_n985 B1=backward_sum[4][1][7]
+ B2=FE_OFN5616_FE_OFN1882_n5509
XU5006 AOI12HS $PINS O=n4357 A1=n1575 B1=backward_sum[2][1][7]
+ B2=FE_OFN1671_FE_DBTN85_n987
XU5007 OR3B2 $PINS O=n4436 I1=n4359 B1=n4358 B2=n4357
XU5008 AO222S $PINS O=n4362 A1=LLR_sum[0][0][7] A2=FE_OFN1420_n1441
+ B1=backward_sum[3][0][7] B2=FE_OFN2194_n4217 C1=backward_sum[5][0][7]
+ C2=FE_OFN1556_n1442
XU5009 AOI22S $PINS O=n4361 A1=backward_sum[1][0][7]
+ A2=FE_OFN5655_FE_OFN1628_FE_DBTN86_n985 B1=backward_sum[4][0][7]
+ B2=FE_OFN1908_n5509
XU5010 AOI12HS $PINS O=n4360 A1=n1579 B1=backward_sum[2][0][7]
+ B2=FE_OFN1694_FE_DBTN85_n987
XU5011 OR3B2 $PINS O=N473 I1=n4362 B1=n4361 B2=n4360
XU5012 MUX2 $PINS O=n4408 S=FE_DBTN90_n1497 A=n4436 B=N473
XU5013 MUX2 $PINS O=n2428 S=FE_OFN1939_n1525 A=backward_metrics[3][0][7]
+ B=n4408
XU5014 AO222S $PINS O=n4365 A1=LLR_sum[0][4][6] A2=FE_OFN1396_n1441
+ B1=backward_sum[3][1][6] B2=FE_OFN1738_FE_DBTN71_n4217 C1=backward_sum[5][1][6]
+ C2=FE_OFN1520_n1442
XU5015 AOI22S $PINS O=n4364 A1=backward_sum[1][1][6]
+ A2=FE_OFN1607_FE_DBTN86_n985 B1=backward_sum[4][1][6]
+ B2=FE_OFN5634_FE_OFN1892_n5509
XU5016 AOI12HS $PINS O=n4363 A1=n1582 B1=backward_sum[2][1][6]
+ B2=FE_OFN1683_FE_DBTN85_n987
XU5017 OR3B2 $PINS O=N486 I1=n4365 B1=n4364 B2=n4363
XU5018 MUX2 $PINS O=n2568 S=FE_OFN1763_n1523 A=backward_metrics[6][0][11]
+ B=n4431
XU5019 MUX2 $PINS O=n2569 S=FE_OFN1763_n1523 A=backward_metrics[6][0][10]
+ B=n4405
XU5020 MUX2 $PINS O=n2570 S=FE_OFN1766_n1523 A=backward_metrics[6][0][9]
+ B=n4406
XU5021 MUX2 $PINS O=n2571 S=FE_OFN1766_n1523 A=backward_metrics[6][0][8]
+ B=n4407
XU5022 MUX2 $PINS O=n2572 S=FE_OFN1766_n1523 A=backward_metrics[6][0][7]
+ B=n4408
XU5023 AO222S $PINS O=n4368 A1=LLR_sum[0][0][6] A2=FE_OFN1424_n1441
+ B1=backward_sum[3][0][6] B2=FE_OFN2196_n4217 C1=backward_sum[5][0][6]
+ C2=FE_OFN1560_n1442
XU5024 AOI22S $PINS O=n4367 A1=backward_sum[1][0][6]
+ A2=FE_OFN1645_FE_DBTN86_n985 B1=backward_sum[4][0][6] B2=FE_OFN1916_n5509
XU5025 AOI12HS $PINS O=n4366 A1=n1573 B1=backward_sum[2][0][6]
+ B2=FE_OFN1697_FE_DBTN85_n987
XU5026 OR3B2 $PINS O=n4437 I1=n4368 B1=n4367 B2=n4366
XU5027 MUX2 $PINS O=n4409 S=FE_DBTN90_n1497 A=N486 B=n4437
XU5028 MUX2 $PINS O=n2573 S=FE_OFN1769_n1523 A=backward_metrics[6][0][6]
+ B=n4409
XU5029 MUX2 $PINS O=n2520 S=FE_OFN1925_n1524 A=backward_metrics[5][0][11]
+ B=n4431
XU5030 MUX2 $PINS O=n2521 S=FE_OFN1925_n1524 A=backward_metrics[5][0][10]
+ B=n4405
XU5031 MUX2 $PINS O=n2522 S=FE_OFN1923_n1524 A=backward_metrics[5][0][9]
+ B=n4406
XU5032 MUX2 $PINS O=n2523 S=FE_OFN1926_n1524 A=backward_metrics[5][0][8]
+ B=n4407
XU5033 MUX2 $PINS O=n2524 S=FE_OFN1926_n1524 A=backward_metrics[5][0][7]
+ B=n4408
XU5034 MUX2 $PINS O=n2525 S=FE_OFN1926_n1524
+ A=FE_OFN1207_backward_metrics_5__0__6 B=n4409
XU5035 AO222S $PINS O=n4371 A1=LLR_sum[0][4][5] A2=FE_OFN1385_n1441
+ B1=backward_sum[3][1][5] B2=FE_OFN1746_FE_DBTN71_n4217 C1=backward_sum[5][1][5]
+ C2=FE_OFN5544_n
XU5036 AOI22S $PINS O=n4370 A1=backward_sum[1][1][5] A2=FE_OFN5672_n
+ B1=backward_sum[4][1][5] B2=FE_OFN1892_n5509
XU5037 AOI12HS $PINS O=n4369 A1=n1574 B1=backward_sum[2][1][5]
+ B2=FE_OFN1689_FE_DBTN85_n987
XU5038 OR3B2 $PINS O=n4442 I1=n4371 B1=n4370 B2=n4369
XU5039 AO222S $PINS O=n4374 A1=LLR_sum[0][0][5] A2=FE_OFN1423_n1441
+ B1=backward_sum[3][0][5] B2=FE_OFN2197_n4217 C1=backward_sum[5][0][5]
+ C2=FE_OFN1561_n1442
XU5040 AOI22S $PINS O=n4373 A1=backward_sum[1][0][5]
+ A2=FE_OFN1639_FE_DBTN86_n985 B1=backward_sum[4][0][5] B2=FE_OFN1898_n5509
XU5041 AOI12HS $PINS O=n4372 A1=n1566 B1=backward_sum[2][0][5] B2=FE_OFN5565_n
XU5042 OR3B2 $PINS O=N475 I1=n4374 B1=n4373 B2=n4372
XU5043 MUX2 $PINS O=n4410 S=FE_OFN510_FE_DBTN90_n1497 A=n4442 B=N475
XU5044 MUX2 $PINS O=n2526 S=FE_OFN1931_n1524 A=backward_metrics[5][0][5]
+ B=n4410
XU5045 AO222S $PINS O=n4377 A1=LLR_sum[0][4][4] A2=FE_OFN1398_n1441
+ B1=backward_sum[3][1][4] B2=FE_OFN1726_FE_DBTN71_n4217 C1=backward_sum[5][1][4]
+ C2=FE_OFN1522_n1442
XU5046 AOI22S $PINS O=n4376 A1=backward_sum[1][1][4]
+ A2=FE_OFN1610_FE_DBTN86_n985 B1=backward_sum[4][1][4] B2=FE_OFN1884_n5509
XU5047 AOI12HS $PINS O=n4375 A1=n1583 B1=backward_sum[2][1][4]
+ B2=FE_OFN5636_FE_OFN1664_FE_DBTN85_n987
XU5048 OR3B2 $PINS O=N488 I1=n4377 B1=n4376 B2=n4375
XU5049 AO222S $PINS O=n4380 A1=LLR_sum[0][0][4] A2=FE_OFN1422_n1441
+ B1=backward_sum[3][0][4] B2=FE_OFN1752_FE_DBTN71_n4217 C1=backward_sum[5][0][4]
+ C2=FE_OFN1555_n1442
XU5050 AOI22S $PINS O=n4379 A1=backward_sum[1][0][4]
+ A2=FE_OFN5598_FE_OFN1622_FE_DBTN86_n985 B1=backward_sum[4][0][4]
+ B2=FE_OFN1910_n5509
XU5051 AOI12HS $PINS O=n4378 A1=n1567 B1=backward_sum[2][0][4]
+ B2=FE_OFN1688_FE_DBTN85_n987
XU5052 OR3B2 $PINS O=n4443 I1=n4380 B1=n4379 B2=n4378
XU5053 MUX2 $PINS O=n4411 S=FE_OFN510_FE_DBTN90_n1497 A=N488 B=n4443
XU5054 MUX2 $PINS O=n2527 S=FE_OFN1931_n1524
+ A=FE_OFN1209_backward_metrics_5__0__4 B=n4411
XU5055 AO222S $PINS O=n4383 A1=LLR_sum[0][0][3] A2=FE_OFN1421_n1441
+ B1=backward_sum[3][0][3] B2=FE_OFN1756_FE_DBTN71_n4217 C1=backward_sum[5][0][3]
+ C2=FE_OFN1539_n1442
XU5056 AOI22S $PINS O=n4382 A1=backward_sum[1][0][3]
+ A2=FE_OFN1626_FE_DBTN86_n985 B1=backward_sum[4][0][3] B2=FE_OFN5574_n
XU5057 AOI12HS $PINS O=n4381 A1=n1568 B1=backward_sum[2][0][3]
+ B2=FE_OFN1681_FE_DBTN85_n987
XU5058 OR3B2 $PINS O=N477 I1=n4383 B1=n4382 B2=n4381
XU5059 AO222S $PINS O=n4386 A1=LLR_sum[0][4][3] A2=FE_OFN1386_n1441
+ B1=backward_sum[3][1][3] B2=FE_OFN1729_FE_DBTN71_n4217 C1=backward_sum[5][1][3]
+ C2=FE_OFN1511_n1442
XU5060 AOI22S $PINS O=n4385 A1=backward_sum[1][1][3]
+ A2=FE_OFN1611_FE_DBTN86_n985 B1=backward_sum[4][1][3] B2=FE_OFN1872_n5509
XU5061 AOI12HS $PINS O=n4384 A1=n1561 B1=backward_sum[2][1][3]
+ B2=FE_OFN5635_FE_OFN1664_FE_DBTN85_n987
XU5062 OR3B2 $PINS O=n4440 I1=n4386 B1=n4385 B2=n4384
XU5063 MUX2P $PINS O=n4412 S=FE_OFN510_FE_DBTN90_n1497 A=n4440 B=N477
XU5064 MUX2 $PINS O=n2528 S=FE_OFN1931_n1524
+ A=FE_OFN1210_backward_metrics_5__0__3 B=n4412
XU5065 AO222S $PINS O=n4389 A1=LLR_sum[0][4][2] A2=FE_OFN1393_n1441
+ B1=backward_sum[3][1][2] B2=FE_OFN1719_FE_DBTN71_n4217 C1=backward_sum[5][1][2]
+ C2=FE_OFN1526_n1442
XU5066 AOI22S $PINS O=n4388 A1=backward_sum[1][1][2]
+ A2=FE_OFN1630_FE_DBTN86_n985 B1=backward_sum[4][1][2] B2=FE_OFN1906_n5509
XU5067 AOI12HS $PINS O=n4387 A1=n1576 B1=backward_sum[2][1][2]
+ B2=FE_OFN1663_FE_DBTN85_n987
XU5068 OR3B2 $PINS O=N490 I1=n4389 B1=n4388 B2=n4387
XU5069 AO222S $PINS O=n4392 A1=LLR_sum[0][0][2] A2=FE_OFN1407_n1441
+ B1=backward_sum[3][0][2] B2=FE_OFN1741_FE_DBTN71_n4217 C1=backward_sum[5][0][2]
+ C2=FE_OFN1531_n1442
XU5070 AOI22S $PINS O=n4391 A1=backward_sum[1][0][2] A2=FE_OFN5534_n
+ B1=backward_sum[4][0][2] B2=FE_OFN5594_FE_OFN1915_n5509
XU5071 AOI12HS $PINS O=n4390 A1=n1565 B1=backward_sum[2][0][2]
+ B2=FE_OFN1680_FE_DBTN85_n987
XU5072 OR3B2 $PINS O=n4441 I1=n4392 B1=n4391 B2=n4390
XU5073 MUX2 $PINS O=n4413 S=FE_OFN510_FE_DBTN90_n1497 A=N490 B=n4441
XU5074 AO222S $PINS O=n4395 A1=LLR_sum[0][0][1] A2=FE_OFN1406_n1441
+ B1=backward_sum[3][0][1] B2=FE_OFN1740_FE_DBTN71_n4217 C1=backward_sum[5][0][1]
+ C2=FE_OFN1541_n1442
XU5075 AOI22S $PINS O=n4394 A1=backward_sum[1][0][1]
+ A2=FE_OFN1646_FE_DBTN86_n985 B1=backward_sum[4][0][1] B2=FE_OFN1918_n5509
XU5076 AOI12HS $PINS O=n4393 A1=n1664 B1=backward_sum[2][0][1] B2=FE_OFN5667_n
XU5077 OR3B2 $PINS O=N479 I1=n4395 B1=n4394 B2=n4393
XU5078 AO222S $PINS O=n4398 A1=LLR_sum[0][4][1] A2=FE_OFN5552_n
+ B1=backward_sum[3][1][1] B2=FE_OFN5630_FE_OFN5539_n C1=backward_sum[5][1][1]
+ C2=FE_OFN1536_n1442
XU5079 AOI22S $PINS O=n4397 A1=backward_sum[1][1][1]
+ A2=FE_OFN1638_FE_DBTN86_n985 B1=backward_sum[4][1][1]
+ B2=FE_OFN5608_FE_OFN1897_n5509
XU5080 AOI12HS $PINS O=n4396 A1=n1571 B1=backward_sum[2][1][1]
+ B2=FE_OFN5591_FE_OFN5578_n
XU5081 OR3B2 $PINS O=n4439 I1=n4398 B1=n4397 B2=n4396
XU5082 MUX2P $PINS O=n4414 S=FE_OFN510_FE_DBTN90_n1497 A=n4439 B=N479
XU5083 AO222S $PINS O=n4401 A1=LLR_sum[0][4][0] A2=FE_OFN5628_FE_OFN1416_n1441
+ B1=backward_sum[3][1][0] B2=FE_OFN5630_FE_OFN5539_n C1=backward_sum[5][1][0]
+ C2=FE_OFN1536_n1442
XU5084 AOI22S $PINS O=n4400 A1=backward_sum[1][1][0]
+ A2=FE_OFN1638_FE_DBTN86_n985 B1=backward_sum[4][1][0]
+ B2=FE_OFN5608_FE_OFN1897_n5509
XU5085 AOI12HS $PINS O=n4399 A1=n1572 B1=backward_sum[2][1][0]
+ B2=FE_OFN5590_FE_OFN5578_n
XU5086 OR3B2 $PINS O=N492 I1=n4401 B1=n4400 B2=n4399
XU5087 AO222S $PINS O=n4404 A1=LLR_sum[0][0][0] A2=FE_OFN1400_n1441
+ B1=backward_sum[3][0][0] B2=FE_OFN1748_FE_DBTN71_n4217 C1=backward_sum[5][0][0]
+ C2=n3966
XU5088 AOI22S $PINS O=n4403 A1=backward_sum[1][0][0]
+ A2=FE_OFN1648_FE_DBTN86_n985 B1=backward_sum[4][0][0] B2=FE_OFN2193_n3782
XU5089 AOI12HS $PINS O=n4402 A1=n1662 B1=backward_sum[2][0][0] B2=FE_OFN5666_n
XU5090 OR3B2 $PINS O=n4438 I1=n4404 B1=n4403 B2=n4402
XU5091 MUX2P $PINS O=n4415 S=FE_OFN510_FE_DBTN90_n1497 A=N492 B=n4438
XU5092 MUX2 $PINS O=n2574 S=FE_OFN1769_n1523 A=backward_metrics[6][0][5]
+ B=n4410
XU5093 MUX2 $PINS O=n2575 S=FE_OFN1769_n1523 A=backward_metrics[6][0][4]
+ B=n4411
XU5094 MUX2 $PINS O=n2429 S=FE_OFN1939_n1525 A=backward_metrics[3][0][6]
+ B=n4409
XU5095 MUX2 $PINS O=n2430 S=FE_OFN1939_n1525 A=backward_metrics[3][0][5]
+ B=n4410
XU5096 MUX2 $PINS O=n2431 S=FE_OFN1937_n1525 A=backward_metrics[3][0][4]
+ B=n4411
XU5097 MUX2 $PINS O=n2432 S=FE_OFN1937_n1525
+ A=FE_OFN5660_backward_metrics_3__0__3 B=n4412
XU5098 MUX2 $PINS O=n2433 S=FE_OFN1940_n1525 A=backward_metrics[3][0][2]
+ B=n4413
XU5099 MUX2 $PINS O=n2476 S=FE_OFN2001_n1531 A=backward_metrics[4][0][7]
+ B=n4408
XU5100 MUX2 $PINS O=n2477 S=FE_OFN2001_n1531 A=backward_metrics[4][0][6]
+ B=n4409
XU5101 MUX2 $PINS O=n2478 S=FE_OFN1999_n1531
+ A=FE_OFN1160_backward_metrics_4__0__5 B=n4410
XU5102 MUX2 $PINS O=n2479 S=FE_OFN1999_n1531 A=backward_metrics[4][0][4]
+ B=n4411
XU5103 MUX2 $PINS O=n2480 S=FE_OFN1997_n1531
+ A=FE_OFN1162_backward_metrics_4__0__3 B=n4412
XU5104 MUX2 $PINS O=n2331 S=FE_OFN1943_n1526 A=backward_metrics[1][0][8]
+ B=n4407
XU5105 MUX2 $PINS O=n2332 S=FE_OFN1945_n1526 A=backward_metrics[1][0][7]
+ B=n4408
XU5106 MUX2 $PINS O=n2333 S=FE_OFN1945_n1526 A=backward_metrics[1][0][6]
+ B=n4409
XU5107 MUX2 $PINS O=n2334 S=FE_OFN1945_n1526 A=backward_metrics[1][0][5]
+ B=n4410
XU5108 MUX2 $PINS O=n2335 S=FE_OFN1949_n1526 A=backward_metrics[1][0][4]
+ B=n4411
XU5109 MUX2 $PINS O=n2336 S=FE_OFN1949_n1526 A=backward_metrics[1][0][3]
+ B=n4412
XU5110 MUX2 $PINS O=n2377 S=FE_OFN2005_n1532 A=backward_metrics[2][0][10]
+ B=n4405
XU5111 MUX2 $PINS O=n2378 S=FE_OFN2007_n1532 A=backward_metrics[2][0][9]
+ B=n4406
XU5112 MUX2 $PINS O=n2379 S=FE_OFN2007_n1532 A=backward_metrics[2][0][8]
+ B=n4407
XU5113 MUX2 $PINS O=n2380 S=FE_OFN2007_n1532 A=backward_metrics[2][0][7]
+ B=n4408
XU5114 MUX2 $PINS O=n2381 S=FE_OFN2011_n1532 A=backward_metrics[2][0][6]
+ B=n4409
XU5115 MUX2 $PINS O=n2382 S=FE_OFN2011_n1532
+ A=FE_OFN1064_backward_metrics_2__0__5 B=n4410
XU5116 MUX2 $PINS O=n2383 S=FE_OFN2011_n1532
+ A=FE_OFN1065_backward_metrics_2__0__4 B=n4411
XU5117 MUX2 $PINS O=n2384 S=FE_OFN2009_n1532 A=backward_metrics[2][0][3]
+ B=n4412
XU5118 AO222S $PINS O=n4418 A1=backward_sum[6][2][0] A2=FE_OFN1400_n1441
+ B1=backward_sum[3][2][0] B2=FE_OFN1748_FE_DBTN71_n4217 C1=backward_sum[5][2][0]
+ C2=FE_OFN1541_n1442
XU5119 AOI22S $PINS O=n4417 A1=backward_sum[1][2][0]
+ A2=FE_OFN1648_FE_DBTN86_n985 B1=backward_sum[4][2][0] B2=FE_OFN2193_n3782
XU5120 AOI12HS $PINS O=n4416 A1=n1661 B1=backward_sum[2][2][0] B2=FE_OFN5667_n
XU5121 OR3B2 $PINS O=n4444 I1=n4418 B1=n4417 B2=n4416
XU5122 MUX2 $PINS O=n4425 S=FE_DBTN89_N2299 A=N516 B=n4444
XU5123 MUX2 $PINS O=n2340 S=FE_OFN1942_n1526
+ A=FE_OFN1022_backward_metrics_1__1__11 B=n1546
XU5124 MUX2 $PINS O=n2341 S=FE_OFN1942_n1526
+ A=FE_OFN1023_backward_metrics_1__1__10 B=n1547
XU5125 MUX2 $PINS O=n2342 S=FE_OFN1943_n1526
+ A=FE_OFN1024_backward_metrics_1__1__9 B=n1477
XU5126 MUX2 $PINS O=n2343 S=FE_OFN1943_n1526
+ A=FE_OFN1025_backward_metrics_1__1__8 B=n1475
XU5127 MUX2 $PINS O=n2344 S=FE_OFN1945_n1526
+ A=FE_OFN1026_backward_metrics_1__1__7 B=n1472
XU5128 MUX2 $PINS O=n2345 S=FE_OFN1945_n1526 A=backward_metrics[1][1][6]
+ B=n1464
XU5129 MUX2 $PINS O=n2346 S=FE_OFN1945_n1526 A=backward_metrics[1][1][5]
+ B=n1469
XU5130 MUX2 $PINS O=n2347 S=FE_OFN1949_n1526
+ A=FE_OFN1029_backward_metrics_1__1__4 B=n1484
XU5131 MUX2 $PINS O=n2348 S=FE_OFN1949_n1526
+ A=FE_OFN1030_backward_metrics_1__1__3 B=n1467
XU5132 AO222S $PINS O=n4421 A1=backward_sum[6][3][1]
+ A2=FE_OFN5628_FE_OFN1416_n1441 B1=backward_sum[3][3][1] B2=FE_OFN5539_n
+ C1=backward_sum[5][3][1] C2=FE_OFN1536_n1442
XU5133 AOI22S $PINS O=n4420 A1=backward_sum[1][3][1]
+ A2=FE_OFN1638_FE_DBTN86_n985 B1=backward_sum[4][3][1]
+ B2=FE_OFN5608_FE_OFN1897_n5509
XU5134 AOI12HS $PINS O=n4419 A1=n1569 B1=backward_sum[2][3][1]
+ B2=FE_OFN5591_FE_OFN5578_n
XU5135 OR3B2 $PINS O=n4445 I1=n4421 B1=n4420 B2=n4419
XU5136 AO222S $PINS O=n4424 A1=backward_sum[6][2][1] A2=FE_OFN1406_n1441
+ B1=backward_sum[3][2][1] B2=FE_OFN1740_FE_DBTN71_n4217 C1=backward_sum[5][2][1]
+ C2=FE_OFN1534_n1442
XU5137 AOI22S $PINS O=n4423 A1=backward_sum[1][2][1]
+ A2=FE_OFN1647_FE_DBTN86_n985 B1=backward_sum[4][2][1] B2=FE_OFN1918_n5509
XU5138 AOI12HS $PINS O=n4422 A1=n1663 B1=backward_sum[2][2][1] B2=FE_OFN5667_n
XU5139 OR3B2 $PINS O=N503 I1=n4424 B1=n4423 B2=n4422
XU5140 MUX2 $PINS O=n4427 S=FE_DBTN89_N2299 A=n4445 B=N503
XU5141 MUX2 $PINS O=n2484 S=FE_OFN1993_n1531
+ A=FE_OFN1166_backward_metrics_4__1__11 B=n1546
XU5142 MUX2 $PINS O=n2485 S=FE_OFN1993_n1531 A=backward_metrics[4][1][10]
+ B=n1547
XU5143 MUX2 $PINS O=n2486 S=FE_OFN2002_n1531
+ A=FE_OFN1168_backward_metrics_4__1__9 B=n1477
XU5144 MUX2 $PINS O=n2487 S=FE_OFN2002_n1531
+ A=FE_OFN1169_backward_metrics_4__1__8 B=n1475
XU5145 MUX2 $PINS O=n2488 S=FE_OFN2001_n1531 A=backward_metrics[4][1][7]
+ B=n1472
XU5146 MUX2 $PINS O=n2489 S=FE_OFN2001_n1531 A=backward_metrics[4][1][6]
+ B=n1464
XU5147 MUX2 $PINS O=n2490 S=FE_OFN1999_n1531 A=backward_metrics[4][1][5]
+ B=n1469
XU5148 MUX2 $PINS O=n2491 S=FE_OFN1999_n1531 A=backward_metrics[4][1][4]
+ B=n1484
XU5149 MUX2 $PINS O=n2492 S=FE_OFN1997_n1531 A=backward_metrics[4][1][3]
+ B=n1467
XU5150 MUX2 $PINS O=n2493 S=FE_OFN2000_n1531 A=backward_metrics[4][1][2]
+ B=n1458
XU5151 MUX2 $PINS O=n2436 S=FE_OFN1933_n1525 A=backward_metrics[3][1][11]
+ B=n1546
XU5152 MUX2 $PINS O=n2437 S=FE_OFN1933_n1525 A=backward_metrics[3][1][10]
+ B=n1547
XU5153 MUX2 $PINS O=n2438 S=FE_OFN1936_n1525 A=backward_metrics[3][1][9]
+ B=n1477
XU5154 MUX2 $PINS O=n2439 S=FE_OFN1936_n1525
+ A=FE_OFN1121_backward_metrics_3__1__8 B=n1475
XU5155 MUX2 $PINS O=n2440 S=FE_OFN1939_n1525
+ A=FE_OFN1122_backward_metrics_3__1__7 B=n1472
XU5156 MUX2 $PINS O=n2441 S=FE_OFN1939_n1525
+ A=FE_OFN1123_backward_metrics_3__1__6 B=n1464
XU5157 MUX2 $PINS O=n2442 S=FE_OFN1939_n1525 A=backward_metrics[3][1][5]
+ B=n1469
XU5158 MUX2 $PINS O=n2443 S=FE_OFN1937_n1525 A=backward_metrics[3][1][4]
+ B=n1484
XU5159 MUX2 $PINS O=n2580 S=FE_OFN1763_n1523 A=backward_metrics[6][1][11]
+ B=n1546
XU5160 MUX2 $PINS O=n2581 S=FE_OFN1763_n1523
+ A=FE_OFN1252_backward_metrics_6__1__10 B=n1547
XU5161 MUX2 $PINS O=n2582 S=FE_OFN1766_n1523
+ A=FE_OFN1253_backward_metrics_6__1__9 B=n1477
XU5162 MUX2 $PINS O=n2583 S=FE_OFN1766_n1523 A=backward_metrics[6][1][8]
+ B=n1475
XU5163 MUX2 $PINS O=n2584 S=FE_OFN1766_n1523
+ A=FE_OFN1255_backward_metrics_6__1__7 B=n1472
XU5164 MUX2 $PINS O=n2585 S=FE_OFN1769_n1523
+ A=FE_OFN1256_backward_metrics_6__1__6 B=n1464
XU5165 MUX2 $PINS O=n2586 S=FE_OFN1769_n1523 A=backward_metrics[6][1][5]
+ B=n1469
XU5166 MUX2 $PINS O=n2587 S=FE_OFN1769_n1523 A=backward_metrics[6][1][4]
+ B=n1484
XU5167 MUX2 $PINS O=n2532 S=FE_OFN1925_n1524 A=backward_metrics[5][1][11]
+ B=n1546
XU5168 MUX2 $PINS O=n2533 S=FE_OFN1925_n1524
+ A=FE_OFN1215_backward_metrics_5__1__10 B=n1547
XU5169 MUX2 $PINS O=n2534 S=FE_OFN1925_n1524
+ A=FE_OFN1216_backward_metrics_5__1__9 B=n1477
XU5170 MUX2 $PINS O=n2535 S=FE_OFN1926_n1524 A=backward_metrics[5][1][8]
+ B=n1475
XU5171 MUX2 $PINS O=n2536 S=FE_OFN1926_n1524 A=backward_metrics[5][1][7]
+ B=n1472
XU5172 MUX2 $PINS O=n2537 S=FE_OFN1926_n1524
+ A=FE_OFN1219_backward_metrics_5__1__6 B=n1464
XU5173 MUX2 $PINS O=n2538 S=FE_OFN1931_n1524 A=backward_metrics[5][1][5]
+ B=n1469
XU5174 MUX2 $PINS O=n2539 S=FE_OFN1931_n1524 A=backward_metrics[5][1][4]
+ B=n1484
XU5175 MUX2 $PINS O=n2376 S=FE_OFN2005_n1532
+ A=FE_OFN1058_backward_metrics_2__0__11 B=n4431
XU5176 AO12 $PINS O=n4455 A1=n4451 B1=LLR_sum[3][4][3]
+ B2=FE_OFN1729_FE_DBTN71_n4217
XU5177 AOI22S $PINS O=n4453 A1=LLR_sum[0][4][3] A2=FE_OFN1812_n5419
+ B1=LLR_sum[2][4][3] B2=FE_OFN1658_FE_DBTN85_n987
XU5178 AOI22S $PINS O=n4452 A1=LLR_sum[1][4][3] A2=FE_OFN1611_FE_DBTN86_n985
+ B1=LLR_sum[4][4][3] B2=FE_OFN5510_n
XU5179 AO112 $PINS O=N628 A1=n4455 B1=n4454 C1=LLR_sum[5][4][3]
+ C2=FE_OFN1511_n1442
XU5180 AO12 $PINS O=n4461 A1=n4457 B1=LLR_sum[3][5][3]
+ B2=FE_OFN1745_FE_DBTN71_n4217
XU5181 AOI22S $PINS O=n4459 A1=LLR_sum[0][5][3] A2=FE_OFN1827_n5419
+ B1=LLR_sum[2][5][3] B2=FE_OFN1681_FE_DBTN85_n987
XU5182 AOI22S $PINS O=n4458 A1=LLR_sum[1][5][3] A2=FE_OFN1624_FE_DBTN86_n985
+ B1=LLR_sum[4][5][3] B2=FE_OFN5575_n
XU5183 AO112P $PINS O=n4866 A1=n4461 B1=n4460 C1=LLR_sum[5][5][3]
+ C2=FE_OFN5603_FE_OFN1533_n1442
XU5184 AO12 $PINS O=n4467 A1=n4463 B1=LLR_sum[3][6][3]
+ B2=FE_OFN1713_FE_DBTN71_n4217
XU5185 AOI22S $PINS O=n4465 A1=LLR_sum[0][6][3] A2=FE_OFN5568_n
+ B1=LLR_sum[2][6][3] B2=FE_OFN1660_FE_DBTN85_n987
XU5186 AOI22S $PINS O=n4464 A1=LLR_sum[1][6][3] A2=FE_OFN1634_FE_DBTN86_n985
+ B1=LLR_sum[4][6][3] B2=FE_OFN1883_n5509
XU5187 AO112 $PINS O=N652 A1=n4467 B1=n4466 C1=LLR_sum[5][6][3] C2=FE_OFN5576_n
XU5188 AO12 $PINS O=n4473 A1=n4469 B1=LLR_sum[3][7][3]
+ B2=FE_OFN1745_FE_DBTN71_n4217
XU5189 AOI22S $PINS O=n4471 A1=LLR_sum[0][7][3] A2=FE_OFN1827_n5419
+ B1=LLR_sum[2][7][3] B2=FE_OFN1681_FE_DBTN85_n987
XU5190 AOI22S $PINS O=n4470 A1=LLR_sum[1][7][3] A2=FE_OFN1641_FE_DBTN86_n985
+ B1=LLR_sum[4][7][3] B2=FE_OFN1915_n5509
XU5191 AO112 $PINS O=n4867 A1=n4473 B1=n4472 C1=LLR_sum[5][7][3]
+ C2=FE_OFN5606_FE_OFN1533_n1442
XU5192 AO12 $PINS O=n4479 A1=n4475 B1=LLR_sum[3][0][3]
+ B2=FE_OFN1756_FE_DBTN71_n4217
XU5193 AOI22S $PINS O=n4477 A1=LLR_sum[0][0][3] A2=FE_OFN1827_n5419
+ B1=LLR_sum[2][0][3] B2=FE_OFN1681_FE_DBTN85_n987
XU5194 AOI22S $PINS O=n4476 A1=LLR_sum[1][0][3] A2=FE_OFN1624_FE_DBTN86_n985
+ B1=LLR_sum[4][0][3] B2=FE_OFN5575_n
XU5195 AO112P $PINS O=N580 A1=n4479 B1=n4478 C1=LLR_sum[5][0][3]
+ C2=FE_OFN1539_n1442
XU5196 AO12 $PINS O=n4485 A1=n4481 B1=LLR_sum[3][1][3]
+ B2=FE_OFN1729_FE_DBTN71_n4217
XU5197 AOI22S $PINS O=n4483 A1=LLR_sum[0][1][3] A2=FE_OFN1812_n5419
+ B1=LLR_sum[2][1][3] B2=FE_OFN1658_FE_DBTN85_n987
XU5198 AOI22S $PINS O=n4482 A1=LLR_sum[1][1][3] A2=FE_OFN1611_FE_DBTN86_n985
+ B1=LLR_sum[4][1][3] B2=FE_OFN5510_n
XU5199 AO112 $PINS O=n5306 A1=n4485 B1=n4484 C1=LLR_sum[5][1][3]
+ C2=FE_OFN1511_n1442
XU5200 AO12 $PINS O=n4491 A1=n4487 B1=LLR_sum[3][2][3]
+ B2=FE_OFN1745_FE_DBTN71_n4217
XU5201 AOI22S $PINS O=n4489 A1=LLR_sum[0][2][3] A2=FE_OFN1827_n5419
+ B1=LLR_sum[2][2][3] B2=FE_OFN1681_FE_DBTN85_n987
XU5202 AOI22S $PINS O=n4488 A1=LLR_sum[1][2][3] A2=FE_OFN1641_FE_DBTN86_n985
+ B1=LLR_sum[4][2][3] B2=FE_OFN1915_n5509
XU5203 AO112 $PINS O=N604 A1=n4491 B1=n4490 C1=LLR_sum[5][2][3]
+ C2=FE_OFN5603_FE_OFN1533_n1442
XU5204 AO12 $PINS O=n4497 A1=n4493 B1=LLR_sum[3][3][3]
+ B2=FE_OFN1713_FE_DBTN71_n4217
XU5205 AOI22S $PINS O=n4495 A1=LLR_sum[0][3][3] A2=FE_OFN5568_n
+ B1=LLR_sum[2][3][3] B2=FE_OFN1660_FE_DBTN85_n987
XU5206 AOI22S $PINS O=n4494 A1=LLR_sum[1][3][3]
+ A2=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985 B1=LLR_sum[4][3][3] B2=FE_OFN1904_n5509
XU5207 AO112 $PINS O=n5307 A1=n4497 B1=n4496 C1=LLR_sum[5][3][3]
+ C2=FE_OFN1503_n1442
XU5210 XOR2HS $PINS O=n4498 I1=n4544 I2=forward_sum[6][6][11]
XU5211 AOI22S $PINS O=n4499 A1=FE_OFN1364_n1441 A2=n4498 B1=LLR_sum[0][6][11]
+ B2=FE_OFN1792_n5419
XU5213 AOI22H $PINS O=n4504 A1=LLR_sum[2][7][11] A2=FE_OFN1684_FE_DBTN85_n987
+ B1=LLR_sum[1][7][11] B2=FE_OFN1620_FE_DBTN86_n985
XU5214 XOR2HS $PINS O=n4502 I1=n4540 I2=forward_sum[6][3][11]
XU5215 AOI22H $PINS O=n4503 A1=FE_OFN1381_n1441 A2=n4502 B1=LLR_sum[0][7][11]
+ B2=FE_OFN1796_n5419
XU5217 AO222S $PINS O=n4509 A1=LLR_sum[3][4][11]
+ A2=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217 B1=LLR_sum[4][4][11]
+ B2=FE_OFN1857_n5509 C1=LLR_sum[5][4][11] C2=FE_OFN1488_n1442
XU5218 AOI22H $PINS O=n4508 A1=LLR_sum[2][4][11] A2=FE_OFN5664_n
+ B1=LLR_sum[1][4][11] B2=FE_OFN1598_FE_DBTN86_n985
XU5219 XOR2HS $PINS O=n4506 I1=n4705 I2=forward_sum[6][4][11]
XU5220 AOI22S $PINS O=n4507 A1=FE_OFN1373_n1441 A2=n4506 B1=LLR_sum[0][4][11]
+ B2=FE_OFN1800_n5419
XU5222 AO12 $PINS O=n4515 A1=n4511 B1=LLR_sum[3][5][11]
+ B2=FE_OFN5613_FE_OFN1728_FE_DBTN71_n4217
XU5223 AOI22S $PINS O=n4513 A1=LLR_sum[0][5][11] A2=FE_OFN1807_n5419
+ B1=LLR_sum[2][5][11] B2=FE_OFN1695_FE_DBTN85_n987
XU5224 AOI22S $PINS O=n4512 A1=LLR_sum[1][5][11]
+ A2=FE_OFN5587_FE_OFN1620_FE_DBTN86_n985 B1=LLR_sum[4][5][11]
+ B2=FE_OFN1877_n5509
XU5225 ND2P $PINS O=n4514 I1=n4513 I2=n4512
XU5227 AO12 $PINS O=n4521 A1=n4517 B1=LLR_sum[3][7][9]
+ B2=FE_OFN1728_FE_DBTN71_n4217
XU5228 AOI22S $PINS O=n4519 A1=LLR_sum[0][7][9] A2=FE_OFN1815_n5419
+ B1=LLR_sum[2][7][9] B2=FE_OFN1690_FE_DBTN85_n987
XU5229 AOI22S $PINS O=n4518 A1=LLR_sum[1][7][9] A2=FE_OFN1609_FE_DBTN86_n985
+ B1=LLR_sum[4][7][9] B2=FE_OFN1885_n5509
XU5231 AO12 $PINS O=n4527 A1=n4523 B1=LLR_sum[3][6][9]
+ B2=FE_OFN1706_FE_DBTN71_n4217
XU5232 AOI22S $PINS O=n4525 A1=LLR_sum[0][6][9] A2=FE_OFN1806_n5419
+ B1=LLR_sum[2][6][9] B2=FE_OFN1676_FE_DBTN85_n987
XU5233 AOI22S $PINS O=n4524 A1=LLR_sum[1][6][9] A2=FE_OFN1590_FE_DBTN86_n985
+ B1=LLR_sum[4][6][9] B2=FE_OFN1868_n5509
XU5234 ND2 $PINS O=n4526 I1=n4525 I2=n4524
XU5235 AO112 $PINS O=n4673 A1=n4527 B1=n4526 C1=LLR_sum[5][6][9]
+ C2=FE_OFN1485_n1442
XU5236 AO12 $PINS O=n4533 A1=n4529 B1=LLR_sum[3][6][8]
+ B2=FE_OFN1715_FE_DBTN71_n4217
XU5237 AOI22S $PINS O=n4531 A1=LLR_sum[0][6][8] A2=FE_OFN1803_n5419
+ B1=LLR_sum[2][6][8] B2=FE_OFN5619_FE_OFN1672_FE_DBTN85_n987
XU5238 AOI22S $PINS O=n4530 A1=LLR_sum[1][6][8] A2=FE_OFN1454_n985
+ B1=LLR_sum[4][6][8] B2=FE_OFN1865_n5509
XU5239 ND2 $PINS O=n4532 I1=n4531 I2=n4530
XU5240 AO112 $PINS O=n4836 A1=n4533 B1=n4532 C1=LLR_sum[5][6][8]
+ C2=FE_OFN1489_n1442
XU5241 AO12 $PINS O=n4539 A1=n4535 B1=LLR_sum[3][7][8]
+ B2=FE_OFN1755_FE_DBTN71_n4217
XU5242 AOI22S $PINS O=n4537 A1=LLR_sum[0][7][8] A2=FE_OFN1816_n5419
+ B1=LLR_sum[2][7][8] B2=FE_OFN1698_FE_DBTN85_n987
XU5243 AOI22S $PINS O=n4536 A1=LLR_sum[1][7][8] A2=FE_OFN1604_FE_DBTN86_n985
+ B1=LLR_sum[4][7][8] B2=FE_OFN1895_n5509
XU5244 AO112 $PINS O=n4837 A1=n4539 B1=n4538 C1=LLR_sum[5][7][8]
+ C2=FE_OFN1529_n1442
XU5245 AO222 $PINS O=n4543 A1=FE_OFN1381_n1441 A2=n4540 B1=LLR_sum[3][7][10]
+ B2=FE_OFN5614_FE_OFN1728_FE_DBTN71_n4217 C1=LLR_sum[5][7][10]
+ C2=FE_OFN1507_n1442
XU5246 AOI22S $PINS O=n4542 A1=LLR_sum[1][7][10]
+ A2=FE_OFN5587_FE_OFN1620_FE_DBTN86_n985 B1=LLR_sum[4][7][10]
+ B2=FE_OFN1877_n5509
XU5247 AOI22S $PINS O=n4541 A1=LLR_sum[0][7][10] A2=FE_OFN1814_n5419
+ B1=LLR_sum[2][7][10] B2=FE_OFN1695_FE_DBTN85_n987
XU5248 OR3B2 $PINS O=n4841 I1=n4543 B1=n4542 B2=n4541
XU5249 AOI22S $PINS O=n4546 A1=LLR_sum[1][6][10] A2=FE_OFN1591_FE_DBTN86_n985
+ B1=LLR_sum[4][6][10] B2=FE_OFN1844_n5509
XU5250 AOI22S $PINS O=n4545 A1=LLR_sum[0][6][10] A2=FE_OFN1789_n5419
+ B1=LLR_sum[2][6][10] B2=FE_OFN1682_FE_DBTN85_n987
XU5252 AO12 $PINS O=n4560 A1=n4556 B1=LLR_sum[3][7][7]
+ B2=FE_OFN1758_FE_DBTN71_n4217
XU5253 AOI22S $PINS O=n4558 A1=LLR_sum[0][7][7] A2=FE_OFN1817_n5419
+ B1=LLR_sum[2][7][7] B2=FE_OFN1694_FE_DBTN85_n987
XU5254 AOI22S $PINS O=n4557 A1=LLR_sum[1][7][7] A2=FE_OFN1628_FE_DBTN86_n985
+ B1=LLR_sum[4][7][7] B2=FE_OFN1903_n5509
XU5255 AO112 $PINS O=n4853 A1=n4560 B1=n4559 C1=LLR_sum[5][7][7]
+ C2=FE_OFN1557_n1442
XU5256 AO12 $PINS O=n4566 A1=n4562 B1=LLR_sum[3][6][7]
+ B2=FE_OFN1736_FE_DBTN71_n4217
XU5257 AOI22S $PINS O=n4564 A1=LLR_sum[0][6][7] A2=FE_OFN5527_n
+ B1=LLR_sum[2][6][7] B2=FE_OFN5619_FE_OFN1672_FE_DBTN85_n987
XU5258 AOI22S $PINS O=n4563 A1=LLR_sum[1][6][7] A2=FE_OFN5521_n
+ B1=LLR_sum[4][6][7] B2=FE_OFN1873_n5509
XU5259 AO112 $PINS O=n4852 A1=n4566 B1=n4565 C1=LLR_sum[5][6][7]
+ C2=FE_OFN1499_n1442
XU5260 AO12 $PINS O=n4572 A1=n4568 B1=LLR_sum[3][6][6]
+ B2=FE_OFN1736_FE_DBTN71_n4217
XU5261 AOI22S $PINS O=n4570 A1=LLR_sum[0][6][6] A2=FE_OFN5527_n
+ B1=LLR_sum[2][6][6] B2=FE_OFN1665_FE_DBTN85_n987
XU5262 AOI22S $PINS O=n4569 A1=LLR_sum[1][6][6] A2=FE_OFN1602_FE_DBTN86_n985
+ B1=LLR_sum[4][6][6] B2=FE_OFN1873_n5509
XU5263 AO112 $PINS O=n4856 A1=n4572 B1=n4571 C1=LLR_sum[5][6][6]
+ C2=FE_OFN1499_n1442
XU5264 AO12 $PINS O=n4578 A1=n4574 B1=LLR_sum[3][7][6] B2=FE_OFN2195_n4217
XU5265 AOI22S $PINS O=n4576 A1=LLR_sum[0][7][6] A2=FE_OFN1823_n5419
+ B1=LLR_sum[2][7][6] B2=FE_OFN1699_FE_DBTN85_n987
XU5266 AOI22S $PINS O=n4575 A1=LLR_sum[1][7][6] A2=FE_OFN5676_n
+ B1=LLR_sum[4][7][6] B2=FE_OFN1914_n5509
XU5267 AO112 $PINS O=n4857 A1=n4578 B1=n4577 C1=LLR_sum[5][7][6]
+ C2=FE_OFN5562_n
XU5268 AO12 $PINS O=n4584 A1=n4580 B1=LLR_sum[3][7][5]
+ B2=FE_OFN1759_FE_DBTN71_n4217
XU5269 AOI22S $PINS O=n4582 A1=LLR_sum[0][7][5] A2=FE_OFN1828_n5419
+ B1=LLR_sum[2][7][5] B2=FE_OFN1693_FE_DBTN85_n987
XU5270 AOI22S $PINS O=n4581 A1=LLR_sum[1][7][5]
+ A2=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985 B1=LLR_sum[4][7][5]
+ B2=FE_OFN5633_FE_OFN1905_n5509
XU5271 AO112P $PINS O=n4861 A1=n4584 B1=n4583 C1=LLR_sum[5][7][5]
+ C2=FE_OFN1549_n1442
XU5272 AO12 $PINS O=n4590 A1=n4586 B1=LLR_sum[3][6][5]
+ B2=FE_OFN1730_FE_DBTN71_n4217
XU5273 AOI22S $PINS O=n4588 A1=LLR_sum[0][6][5] A2=FE_OFN1822_n5419
+ B1=LLR_sum[2][6][5] B2=FE_OFN1659_FE_DBTN85_n987
XU5274 AOI22S $PINS O=n4587 A1=LLR_sum[1][6][5] A2=FE_OFN1634_FE_DBTN86_n985
+ B1=LLR_sum[4][6][5] B2=FE_OFN1904_n5509
XU5275 AO112 $PINS O=n4860 A1=n4590 B1=n4589 C1=LLR_sum[5][6][5]
+ C2=FE_OFN1506_n1442
XU5276 AO12 $PINS O=n4596 A1=n4592 B1=LLR_sum[3][6][4]
+ B2=FE_OFN1730_FE_DBTN71_n4217
XU5277 AOI22S $PINS O=n4594 A1=LLR_sum[0][6][4] A2=FE_OFN1822_n5419
+ B1=LLR_sum[2][6][4] B2=FE_OFN1659_FE_DBTN85_n987
XU5278 AOI22S $PINS O=n4593 A1=LLR_sum[1][6][4] A2=FE_OFN1634_FE_DBTN86_n985
+ B1=LLR_sum[4][6][4] B2=FE_OFN1904_n5509
XU5279 AO112 $PINS O=n4864 A1=n4596 B1=n4595 C1=LLR_sum[5][6][4]
+ C2=FE_OFN1506_n1442
XU5280 AO12 $PINS O=n4602 A1=n4598 B1=LLR_sum[3][7][4]
+ B2=FE_OFN1757_FE_DBTN71_n4217
XU5281 AOI22S $PINS O=n4600 A1=LLR_sum[0][7][4] A2=FE_OFN1821_n5419
+ B1=LLR_sum[2][7][4] B2=FE_OFN1693_FE_DBTN85_n987
XU5282 AOI22S $PINS O=n4599 A1=LLR_sum[1][7][4]
+ A2=FE_OFN5600_FE_OFN1622_FE_DBTN86_n985 B1=LLR_sum[4][7][4] B2=FE_OFN1905_n5509
XU5283 AO112P $PINS O=n4865 A1=n4602 B1=n4601 C1=LLR_sum[5][7][4]
+ C2=FE_OFN5559_n
XU5284 ND2 $PINS O=n4629 I1=n4867 I2=n4603
XU5285 AO12 $PINS O=n4609 A1=n4605 B1=LLR_sum[3][6][2]
+ B2=FE_OFN1734_FE_DBTN71_n4217
XU5286 AOI22S $PINS O=n4607 A1=LLR_sum[0][6][2] A2=FE_OFN5568_n
+ B1=LLR_sum[2][6][2] B2=FE_OFN1662_FE_DBTN85_n987
XU5287 AOI22S $PINS O=n4606 A1=LLR_sum[1][6][2] A2=FE_OFN5670_n
+ B1=LLR_sum[4][6][2] B2=FE_OFN1883_n5509
XU5288 AO112 $PINS O=n4868 A1=n4609 B1=n4608 C1=LLR_sum[5][6][2]
+ C2=FE_OFN5576_n
XU5289 AO12 $PINS O=n4615 A1=n4611 B1=LLR_sum[3][7][2]
+ B2=FE_OFN1734_FE_DBTN71_n4217
XU5290 AOI22S $PINS O=n4613 A1=LLR_sum[0][7][2] A2=FE_OFN1824_n5419
+ B1=LLR_sum[2][7][2] B2=FE_OFN1680_FE_DBTN85_n987
XU5291 AOI22S $PINS O=n4612 A1=LLR_sum[1][7][2] A2=FE_OFN5643_FE_OFN5534_n
+ B1=LLR_sum[4][7][2] B2=FE_OFN5597_FE_OFN1915_n5509
XU5292 AO112 $PINS O=n4869 A1=n4615 B1=n4614 C1=LLR_sum[5][7][2]
+ C2=FE_OFN1533_n1442
XU5293 AO12 $PINS O=n4622 A1=n4618 B1=LLR_sum[3][7][1]
+ B2=FE_OFN1744_FE_DBTN71_n4217
XU5294 AOI22S $PINS O=n4620 A1=LLR_sum[0][7][1] A2=FE_OFN1832_n5419
+ B1=LLR_sum[2][7][1] B2=FE_OFN1687_FE_DBTN85_n987
XU5295 AOI22S $PINS O=n4619 A1=LLR_sum[1][7][1] A2=FE_OFN1653_FE_DBTN86_n985
+ B1=LLR_sum[4][7][1] B2=FE_OFN5523_n
XU5296 AO112P $PINS O=n4876 A1=n4622 B1=n4621 C1=LLR_sum[5][7][1]
+ C2=FE_OFN1530_n1442
XU5297 AO12 $PINS O=n4628 A1=n4624 B1=LLR_sum[3][6][1]
+ B2=FE_OFN1723_FE_DBTN71_n4217
XU5298 AOI22S $PINS O=n4626 A1=LLR_sum[0][6][1] A2=FE_OFN5528_n
+ B1=LLR_sum[2][6][1] B2=FE_OFN1662_FE_DBTN85_n987
XU5299 AOI22S $PINS O=n4625 A1=LLR_sum[1][6][1] A2=FE_OFN5681_n
+ B1=LLR_sum[4][6][1] B2=FE_OFN1879_n5509
XU5300 AO112 $PINS O=n4875 A1=n4628 B1=n4627 C1=LLR_sum[5][6][1]
+ C2=FE_OFN1517_n1442
XU5301 OAI12HS $PINS O=n4649 A1=n4629 B1=n4630 B2=n4875
XU5302 AO12 $PINS O=n4636 A1=n4632 B1=LLR_sum[3][6][0]
+ B2=FE_OFN1723_FE_DBTN71_n4217
XU5303 AOI22S $PINS O=n4634 A1=LLR_sum[0][6][0] A2=FE_OFN5528_n
+ B1=LLR_sum[2][6][0] B2=FE_OFN1662_FE_DBTN85_n987
XU5304 AOI22S $PINS O=n4633 A1=LLR_sum[1][6][0] A2=FE_OFN5681_n
+ B1=LLR_sum[4][6][0] B2=FE_OFN1879_n5509
XU5305 AO112 $PINS O=n4936 A1=n4636 B1=n4635 C1=LLR_sum[5][6][0]
+ C2=FE_OFN1518_n1442
XU5306 AO12 $PINS O=n4642 A1=n4638 B1=LLR_sum[3][7][0]
+ B2=FE_OFN1744_FE_DBTN71_n4217
XU5307 AOI22S $PINS O=n4640 A1=LLR_sum[0][7][0] A2=FE_OFN3101_n5419
+ B1=LLR_sum[2][7][0] B2=FE_OFN1673_FE_DBTN85_n987
XU5308 AOI22S $PINS O=n4639 A1=LLR_sum[1][7][0] A2=FE_OFN1652_FE_DBTN86_n985
+ B1=LLR_sum[4][7][0] B2=FE_OFN5522_n
XU5309 AO112P $PINS O=n4937 A1=n4642 B1=n4641 C1=LLR_sum[5][7][0]
+ C2=FE_OFN1530_n1442
XU5310 OAI22S $PINS O=n4645 A1=n4644 A2=n4937 B1=n4643 B2=n4876
XU5311 OAI12HS $PINS O=n4648 A1=n4645 B1=n4646 B2=n4868
XU5312 OAI222S $PINS O=n4652 A1=n4651 A2=n4650 B1=n4649 B2=n4648 C1=n4647
+ C2=n4865
XU5314 AN2 $PINS O=n4656 I1=n4655 I2=n4861
XU5317 AN2 $PINS O=n4664 I1=n4662 I2=n4853
XU5319 MUX2 $PINS O=n4918 S=FE_OFN512_FE_DBTN82_n5 A=FE_OFN5579_n4674 B=n4673
XU5320 AO12 $PINS O=n4680 A1=n4676 B1=LLR_sum[3][5][9]
+ B2=FE_OFN1755_FE_DBTN71_n4217
XU5321 AOI22S $PINS O=n4678 A1=LLR_sum[0][5][9] A2=FE_OFN1815_n5419
+ B1=LLR_sum[2][5][9] B2=FE_OFN1690_FE_DBTN85_n987
XU5322 AOI22S $PINS O=n4677 A1=LLR_sum[1][5][9] A2=FE_OFN1609_FE_DBTN86_n985
+ B1=LLR_sum[4][5][9] B2=FE_OFN1885_n5509
XU5323 AO112 $PINS O=n4835 A1=n4680 B1=n4679 C1=LLR_sum[5][5][9]
+ C2=FE_OFN1529_n1442
XU5324 AO12 $PINS O=n4686 A1=n4682 B1=LLR_sum[3][4][9]
+ B2=FE_OFN1720_FE_DBTN71_n4217
XU5325 AOI22S $PINS O=n4684 A1=LLR_sum[0][4][9] A2=FE_OFN1806_n5419
+ B1=LLR_sum[2][4][9] B2=FE_OFN1686_FE_DBTN85_n987
XU5326 AOI22S $PINS O=n4683 A1=LLR_sum[1][4][9]
+ A2=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985 B1=LLR_sum[4][4][9] B2=FE_OFN5566_n
XU5327 AO112 $PINS O=n4834 A1=n4686 B1=n4685 C1=LLR_sum[5][4][9]
+ C2=FE_OFN1494_n1442
XU5328 ND2P $PINS O=n4825 I1=n4712 I2=n4834
XU5329 AO12 $PINS O=n4692 A1=n4688 B1=LLR_sum[3][4][8]
+ B2=FE_OFN1727_FE_DBTN71_n4217
XU5330 AOI22S $PINS O=n4690 A1=LLR_sum[0][4][8] A2=FE_OFN1810_n5419
+ B1=LLR_sum[2][4][8] B2=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987
XU5331 AOI22S $PINS O=n4689 A1=LLR_sum[1][4][8] A2=FE_OFN1600_FE_DBTN86_n985
+ B1=LLR_sum[4][4][8] B2=FE_OFN1870_n5509
XU5332 AO112 $PINS O=n4838 A1=n4692 B1=n4691 C1=LLR_sum[5][4][8]
+ C2=FE_OFN1497_n1442
XU5333 AO12 $PINS O=n4698 A1=n4694 B1=LLR_sum[3][5][8]
+ B2=FE_OFN1755_FE_DBTN71_n4217
XU5334 AOI22S $PINS O=n4696 A1=LLR_sum[0][5][8] A2=FE_OFN1816_n5419
+ B1=LLR_sum[2][5][8] B2=FE_OFN1698_FE_DBTN85_n987
XU5335 AOI22S $PINS O=n4695 A1=LLR_sum[1][5][8] A2=FE_OFN1623_FE_DBTN86_n985
+ B1=LLR_sum[4][5][8] B2=FE_OFN5680_n
XU5336 AO112 $PINS O=n4839 A1=n4698 B1=n4697 C1=LLR_sum[5][5][8]
+ C2=FE_OFN1543_n1442
XU5337 ND2 $PINS O=n4710 I1=n4822 I2=n4839
XU5338 AO12 $PINS O=n4704 A1=n4700 B1=LLR_sum[3][5][10]
+ B2=FE_OFN1728_FE_DBTN71_n4217
XU5339 AOI22S $PINS O=n4702 A1=LLR_sum[0][5][10] A2=FE_OFN1807_n5419
+ B1=LLR_sum[2][5][10] B2=FE_OFN1695_FE_DBTN85_n987
XU5340 AOI22S $PINS O=n4701 A1=LLR_sum[1][5][10] A2=FE_OFN1609_FE_DBTN86_n985
+ B1=LLR_sum[4][5][10] B2=FE_OFN1885_n5509
XU5342 AO222S $PINS O=n4708 A1=FE_OFN1373_n1441 A2=n4705 B1=LLR_sum[3][4][10]
+ B2=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217 C1=LLR_sum[5][4][10]
+ C2=FE_OFN1488_n1442
XU5343 AOI22S $PINS O=n4707 A1=LLR_sum[1][4][10] A2=FE_OFN1594_FE_DBTN86_n985
+ B1=LLR_sum[4][4][10] B2=FE_OFN1854_n5509
XU5344 AOI22S $PINS O=n4706 A1=LLR_sum[0][4][10] A2=FE_OFN1795_n5419
+ B1=LLR_sum[2][4][10] B2=FE_OFN1686_FE_DBTN85_n987
XU5346 OA222 $PINS O=n4830 A1=n4712 A2=n4834 B1=n4711 B2=n4710 C1=n4709
+ C2=n4842
XU5348 AO12 $PINS O=n4721 A1=n4717 B1=LLR_sum[3][5][7]
+ B2=FE_OFN1758_FE_DBTN71_n4217
XU5349 AOI22S $PINS O=n4719 A1=LLR_sum[0][5][7] A2=FE_OFN1820_n5419
+ B1=LLR_sum[2][5][7] B2=FE_OFN1697_FE_DBTN85_n987
XU5350 AOI22S $PINS O=n4718 A1=LLR_sum[1][5][7] A2=FE_OFN1635_FE_DBTN86_n985
+ B1=LLR_sum[4][5][7] B2=FE_OFN1909_n5509
XU5351 AO112 $PINS O=n4851 A1=n4721 B1=n4720 C1=LLR_sum[5][5][7]
+ C2=FE_OFN5561_n
XU5352 AO12 $PINS O=n4727 A1=n4723 B1=LLR_sum[3][4][7]
+ B2=FE_OFN1738_FE_DBTN71_n4217
XU5353 AOI22S $PINS O=n4725 A1=LLR_sum[0][4][7] A2=FE_OFN1811_n5419
+ B1=LLR_sum[2][4][7] B2=FE_OFN1671_FE_DBTN85_n987
XU5354 AOI22S $PINS O=n4724 A1=LLR_sum[1][4][7]
+ A2=FE_OFN5622_FE_OFN1636_FE_DBTN86_n985 B1=LLR_sum[4][4][7] B2=FE_OFN1882_n5509
XU5355 AO112 $PINS O=n4850 A1=n4727 B1=n4726 C1=LLR_sum[5][4][7]
+ C2=FE_OFN1512_n1442
XU5356 AO12 $PINS O=n4733 A1=n4729 B1=LLR_sum[3][4][6]
+ B2=FE_OFN1738_FE_DBTN71_n4217
XU5357 AOI22S $PINS O=n4731 A1=LLR_sum[0][4][6] A2=FE_OFN1804_n5419
+ B1=LLR_sum[2][4][6] B2=FE_OFN1689_FE_DBTN85_n987
XU5358 AOI22S $PINS O=n4730 A1=LLR_sum[1][4][6] A2=FE_OFN5673_n
+ B1=LLR_sum[4][4][6] B2=FE_OFN5634_FE_OFN1892_n5509
XU5359 AO112 $PINS O=n4854 A1=n4733 B1=n4732 C1=LLR_sum[5][4][6]
+ C2=FE_OFN1520_n1442
XU5360 AO12 $PINS O=n4739 A1=n4735 B1=LLR_sum[3][5][6] B2=FE_OFN2195_n4217
XU5361 AOI22S $PINS O=n4737 A1=LLR_sum[0][5][6] A2=FE_OFN1823_n5419
+ B1=LLR_sum[2][5][6] B2=FE_OFN1699_FE_DBTN85_n987
XU5362 AOI22S $PINS O=n4736 A1=LLR_sum[1][5][6] A2=FE_OFN1645_FE_DBTN86_n985
+ B1=LLR_sum[4][5][6] B2=FE_OFN1916_n5509
XU5363 AO112P $PINS O=n4855 A1=n4739 B1=n4738 C1=LLR_sum[5][5][6]
+ C2=FE_OFN1561_n1442
XU5364 AO12 $PINS O=n4745 A1=n4741 B1=LLR_sum[3][5][5]
+ B2=FE_OFN1759_FE_DBTN71_n4217
XU5365 AOI22S $PINS O=n4743 A1=LLR_sum[0][5][5] A2=FE_OFN5611_FE_OFN1828_n5419
+ B1=LLR_sum[2][5][5] B2=FE_OFN5564_n
XU5366 AOI22S $PINS O=n4742 A1=LLR_sum[1][5][5] A2=FE_OFN1640_FE_DBTN86_n985
+ B1=LLR_sum[4][5][5] B2=FE_OFN1911_n5509
XU5367 AO112 $PINS O=n4859 A1=n4745 B1=n4744 C1=LLR_sum[5][5][5]
+ C2=FE_OFN1554_n1442
XU5368 AO12 $PINS O=n4751 A1=n4747 B1=LLR_sum[3][4][5]
+ B2=FE_OFN1757_FE_DBTN71_n4217
XU5369 AOI22S $PINS O=n4749 A1=LLR_sum[0][4][5] A2=FE_OFN1818_n5419
+ B1=LLR_sum[2][4][5] B2=FE_OFN1668_FE_DBTN85_n987
XU5370 AOI22S $PINS O=n4748 A1=LLR_sum[1][4][5] A2=FE_OFN1621_FE_DBTN86_n985
+ B1=LLR_sum[4][4][5] B2=FE_OFN1900_n5509
XU5371 AO112 $PINS O=n4858 A1=n4751 B1=n4750 C1=LLR_sum[5][4][5]
+ C2=FE_OFN5544_n
XU5372 AO12 $PINS O=n4757 A1=n4753 B1=LLR_sum[3][4][4]
+ B2=FE_OFN1757_FE_DBTN71_n4217
XU5373 AOI22S $PINS O=n4755 A1=LLR_sum[0][4][4] A2=FE_OFN1818_n5419
+ B1=LLR_sum[2][4][4] B2=FE_OFN1668_FE_DBTN85_n987
XU5374 AOI22S $PINS O=n4754 A1=LLR_sum[1][4][4] A2=FE_OFN1621_FE_DBTN86_n985
+ B1=LLR_sum[4][4][4] B2=FE_OFN1900_n5509
XU5375 AO112 $PINS O=n4862 A1=n4757 B1=n4756 C1=LLR_sum[5][4][4]
+ C2=FE_OFN5544_n
XU5376 AO12 $PINS O=n4763 A1=n4759 B1=LLR_sum[3][5][4]
+ B2=FE_OFN1759_FE_DBTN71_n4217
XU5377 AOI22S $PINS O=n4761 A1=LLR_sum[0][5][4] A2=FE_OFN5611_FE_OFN1828_n5419
+ B1=LLR_sum[2][5][4] B2=FE_OFN5564_n
XU5378 AOI22S $PINS O=n4760 A1=LLR_sum[1][5][4] A2=FE_OFN1640_FE_DBTN86_n985
+ B1=LLR_sum[4][5][4] B2=FE_OFN1911_n5509
XU5379 AO112P $PINS O=n4863 A1=n4763 B1=n4762 C1=LLR_sum[5][5][4]
+ C2=FE_OFN1554_n1442
XU5380 ND2 $PINS O=n4790 I1=n4866 I2=n4764
XU5381 AO12 $PINS O=n4770 A1=n4766 B1=LLR_sum[3][4][2]
+ B2=FE_OFN1719_FE_DBTN71_n4217
XU5382 AOI22S $PINS O=n4768 A1=LLR_sum[0][4][2] A2=FE_OFN1837_n5419
+ B1=LLR_sum[2][4][2] B2=FE_OFN1663_FE_DBTN85_n987
XU5383 AOI22S $PINS O=n4767 A1=LLR_sum[1][4][2] A2=FE_OFN5682_n
+ B1=LLR_sum[4][4][2] B2=FE_OFN1906_n5509
XU5384 AO112 $PINS O=n4870 A1=n4770 B1=n4769 C1=LLR_sum[5][4][2]
+ C2=FE_OFN1509_n1442
XU5385 AO12 $PINS O=n4776 A1=n4772 B1=LLR_sum[3][5][2]
+ B2=FE_OFN1745_FE_DBTN71_n4217
XU5386 AOI22S $PINS O=n4774 A1=LLR_sum[0][5][2] A2=FE_OFN1831_n5419
+ B1=LLR_sum[2][5][2] B2=FE_OFN1680_FE_DBTN85_n987
XU5387 AOI22S $PINS O=n4773 A1=LLR_sum[1][5][2] A2=FE_OFN1641_FE_DBTN86_n985
+ B1=LLR_sum[4][5][2] B2=FE_OFN5592_FE_OFN1915_n5509
XU5388 AO112P $PINS O=n4871 A1=n4776 B1=n4775 C1=LLR_sum[5][5][2]
+ C2=FE_OFN5604_FE_OFN1533_n1442
XU5389 AO12 $PINS O=n4783 A1=n4779 B1=LLR_sum[3][5][1]
+ B2=FE_OFN1733_FE_DBTN71_n4217
XU5390 AOI22S $PINS O=n4781 A1=LLR_sum[0][5][1] A2=FE_OFN5577_n
+ B1=LLR_sum[2][5][1] B2=FE_OFN1687_FE_DBTN85_n987
XU5391 AOI22S $PINS O=n4780 A1=LLR_sum[1][5][1] A2=FE_OFN1650_FE_DBTN86_n985
+ B1=LLR_sum[4][5][1] B2=FE_OFN1919_n5509
XU5392 AO112P $PINS O=n4874 A1=n4783 B1=n4782 C1=LLR_sum[5][5][1]
+ C2=FE_OFN5647_FE_OFN1530_n1442
XU5393 AO12 $PINS O=n4789 A1=n4785 B1=LLR_sum[3][4][1]
+ B2=FE_OFN5630_FE_OFN5539_n
XU5394 AOI22S $PINS O=n4787 A1=LLR_sum[0][4][1] A2=FE_OFN5569_n
+ B1=LLR_sum[2][4][1] B2=FE_OFN5590_FE_OFN5578_n
XU5395 AOI22S $PINS O=n4786 A1=LLR_sum[1][4][1] A2=FE_OFN3103_FE_DBTN86_n985
+ B1=LLR_sum[4][4][1] B2=FE_OFN3102_n5509
XU5396 AO112P $PINS O=n4873 A1=n4789 B1=n4788 C1=LLR_sum[5][4][1]
+ C2=FE_OFN5637_FE_OFN1526_n1442
XU5397 OAI12HS $PINS O=n4810 A1=n4790 B1=n4791 B2=n4873
XU5398 AO12 $PINS O=n4797 A1=n4793 B1=LLR_sum[3][4][0]
+ B2=FE_OFN5630_FE_OFN5539_n
XU5399 AOI22S $PINS O=n4795 A1=LLR_sum[0][4][0] A2=FE_OFN5569_n
+ B1=LLR_sum[2][4][0] B2=FE_OFN5578_n
XU5400 AOI22S $PINS O=n4794 A1=LLR_sum[1][4][0] A2=FE_OFN3103_FE_DBTN86_n985
+ B1=LLR_sum[4][4][0] B2=FE_OFN3102_n5509
XU5401 AO112P $PINS O=n4878 A1=n4797 B1=n4796 C1=LLR_sum[5][4][0]
+ C2=FE_OFN5637_FE_OFN1526_n1442
XU5402 AO12 $PINS O=n4803 A1=n4799 B1=LLR_sum[3][5][0]
+ B2=FE_OFN1744_FE_DBTN71_n4217
XU5403 AOI22S $PINS O=n4801 A1=LLR_sum[0][5][0] A2=FE_OFN1832_n5419
+ B1=LLR_sum[2][5][0] B2=FE_OFN1687_FE_DBTN85_n987
XU5404 AOI22S $PINS O=n4800 A1=LLR_sum[1][5][0] A2=FE_OFN1650_FE_DBTN86_n985
+ B1=LLR_sum[4][5][0] B2=FE_OFN1919_n5509
XU5405 AO112P $PINS O=n4879 A1=n4803 B1=n4802 C1=LLR_sum[5][5][0]
+ C2=FE_OFN1547_n1442
XU5406 OAI22S $PINS O=n4806 A1=n4805 A2=n4879 B1=n4804 B2=n4874
XU5407 OAI12HS $PINS O=n4809 A1=n4806 B1=n4807 B2=n4870
XU5408 OAI222H $PINS O=n4813 A1=n4812 A2=n4811 B1=n4810 B2=n4809 C1=n4808
+ C2=n4863
XU5409 AN2 $PINS O=n4816 I1=n4815 I2=n4859
XU5410 OAI22S $PINS O=n4819 A1=n4818 A2=n4855 B1=n4817 B2=n4816
XU5411 AN2 $PINS O=n4823 I1=n4821 I2=n4851
XU5412 OAI22H $PINS O=n4828 A1=n4824 A2=n4823 B1=n4822 B2=n4839
XU5413 ND2 $PINS O=n4827 I1=n4826 I2=n4825
XU5414 MUX2 $PINS O=n4917 S=FE_OFN516_FE_DBTN77_n4833 A=n4835 B=n4834
XU5415 MUX2 $PINS O=n4920 S=FE_OCPN5687_n5 A=n4837 B=n4836
XU5416 MUX2 $PINS O=n4919 S=FE_OFN516_FE_DBTN77_n4833 A=n4839 B=n4838
XU5417 MUX2 $PINS O=n4916 S=FE_OFN512_FE_DBTN82_n5 A=n4548 B=n4840
XU5418 MUX2 $PINS O=n4915 S=FE_OFN516_FE_DBTN77_n4833 A=n4843 B=n4842
XU5419 OAI22S $PINS O=n4910 A1=n4913 A2=n4849 B1=n4916 B2=n4848
XU5420 MUX2 $PINS O=n4921 S=FE_OFN516_FE_DBTN77_n4833 A=n4851 B=n4850
XU5421 MUX2 $PINS O=n4922 S=FE_OCPN5687_n5 A=n4853 B=n4852
XU5422 MUX2 $PINS O=n4923 S=FE_OFN516_FE_DBTN77_n4833 A=n4855
+ B=FE_OFN5556_n4854
XU5423 MUX2 $PINS O=n4924 S=FE_OCPN5687_n5 A=n4857 B=n4856
XU5424 MUX2 $PINS O=n4925 S=FE_DBTN77_n4833 A=n4859 B=n4858
XU5425 MUX2 $PINS O=n4926 S=FE_OCPN5687_n5 A=n4861 B=n4860
XU5426 MUX2 $PINS O=n4927 S=FE_DBTN77_n4833 A=n4863 B=FE_OFN5573_n4862
XU5427 MUX2 $PINS O=n4928 S=FE_OCPN5687_n5 A=n4865 B=n4864
XU5429 MUX2 $PINS O=n4930 S=FE_OFN512_FE_DBTN82_n5 A=n4867 B=N652
XU5430 MUX2 $PINS O=n4932 S=FE_OFN512_FE_DBTN82_n5 A=n4869 B=n4868
XU5433 MUX2 $PINS O=n4933 S=FE_DBTN77_n4833 A=n4874 B=n4873
XU5434 MUX2 $PINS O=n4934 S=FE_OFN3099_FE_DBTN82_n5 A=n4876 B=n4875
XU5435 MUX2 $PINS O=n4935 S=FE_DBTN77_n4833 A=n4879 B=n4878
XU5436 MUX2 $PINS O=n4880 S=FE_OFN3099_FE_DBTN82_n5 A=n4937 B=n4936
XU5439 OAI12HS $PINS O=n4888 A1=n4885 B1=n4931 B2=n4886
XU5440 AN2 $PINS O=n4896 I1=n4895 I2=n4926
XU5443 AN2 $PINS O=n4904 I1=n4902 I2=n4922
XU5445 ND2 $PINS O=n4908 I1=n4907 I2=n4906
XU5446 MUX2 $PINS O=N2932 S=FE_OFN5684_FE_OFN520_FE_DBTN73_n1452 A=n4914
+ B=n4913
XU5447 MUX2 $PINS O=N2931 S=FE_OFN5684_FE_OFN520_FE_DBTN73_n1452 A=n4916
+ B=n4915
XU5448 MUX2 $PINS O=N2930 S=FE_OFN5684_FE_OFN520_FE_DBTN73_n1452 A=n4918
+ B=n4917
XU5449 MUX2 $PINS O=N2929 S=FE_OFN5684_FE_OFN520_FE_DBTN73_n1452 A=n4920
+ B=n4919
XU5450 MUX2 $PINS O=N2928 S=FE_OFN5684_FE_OFN520_FE_DBTN73_n1452 A=n4922
+ B=n4921
XU5451 MUX2 $PINS O=N2927 S=FE_DBTN73_n1452 A=n4924 B=n4923
XU5452 MUX2 $PINS O=N2926 S=FE_DBTN73_n1452 A=n4926 B=n4925
XU5453 MUX2 $PINS O=N2925 S=FE_DBTN73_n1452 A=n4928 B=n4927
XU5454 MUX2 $PINS O=N2924 S=FE_DBTN73_n1452 A=n4930 B=n4929
XU5456 MUX2 $PINS O=N2922 S=FE_DBTN73_n1452 A=n4934 B=n4933
XU5457 MUX3 $PINS O=N2921 S0=FE_OFN512_FE_DBTN82_n5 S1=FE_DBTN73_n1452 A=n4937
+ B=n4936 C=n4935
XU5458 AO222S $PINS O=n4941 A1=LLR_sum[3][2][11] A2=FE_OFN1747_FE_DBTN71_n4217
+ B1=LLR_sum[4][2][11] B2=FE_OFN1867_n5509 C1=LLR_sum[5][2][11]
+ C2=FE_OFN1515_n1442
XU5460 XOR2HS $PINS O=n4938 I1=n4984 I2=forward_sum[6][2][11]
XU5461 AOI22S $PINS O=n4939 A1=FE_OFN1389_n1441 A2=n4938 B1=LLR_sum[0][2][11]
+ B2=FE_OFN1796_n5419
XU5463 AOI22S $PINS O=n4944 A1=LLR_sum[2][3][11] A2=FE_OFN1682_FE_DBTN85_n987
+ B1=LLR_sum[1][3][11] B2=FE_OFN1591_FE_DBTN86_n985
XU5464 XOR2HS $PINS O=n4942 I1=n4980 I2=forward_sum[6][7][11]
XU5465 AOI22S $PINS O=n4943 A1=FE_OFN1364_n1441 A2=n4942 B1=LLR_sum[0][3][11]
+ B2=FE_OFN1792_n5419
XU5466 OR3B2 $PINS O=n5111 I1=n4945 B1=n4944 B2=n4943
XU5467 AO12 $PINS O=n4951 A1=n4947 B1=LLR_sum[3][0][11]
+ B2=FE_OFN5613_FE_OFN1728_FE_DBTN71_n4217
XU5468 AOI22S $PINS O=n4949 A1=LLR_sum[0][0][11] A2=FE_OFN1794_n5419
+ B1=LLR_sum[2][0][11] B2=FE_OFN1684_FE_DBTN85_n987
XU5469 AOI22S $PINS O=n4948 A1=LLR_sum[1][0][11]
+ A2=FE_OFN5586_FE_OFN1620_FE_DBTN86_n985 B1=LLR_sum[4][0][11] B2=FE_OFN5566_n
XU5470 ND2P $PINS O=n4950 I1=n4949 I2=n4948
XU5472 AO222 $PINS O=n4955 A1=LLR_sum[3][1][11]
+ A2=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217 B1=LLR_sum[4][1][11]
+ B2=FE_OFN1857_n5509 C1=LLR_sum[5][1][11] C2=FE_OFN1488_n1442
XU5473 AOI22S $PINS O=n4954 A1=LLR_sum[2][1][11] A2=FE_OFN5664_n
+ B1=LLR_sum[1][1][11] B2=FE_OFN1594_FE_DBTN86_n985
XU5474 XOR2HS $PINS O=n4952 I1=n5139 I2=forward_sum[6][5][11]
XU5475 AOI22S $PINS O=n4953 A1=FE_OFN1373_n1441 A2=n4952 B1=LLR_sum[0][1][11]
+ B2=FE_OFN1795_n5419
XU5476 OR3B2 $PINS O=n5272 I1=n4955 B1=n4954 B2=n4953
XU5477 AO12 $PINS O=n4961 A1=n4957 B1=LLR_sum[3][3][9]
+ B2=FE_OFN1706_FE_DBTN71_n4217
XU5478 AOI22S $PINS O=n4959 A1=LLR_sum[0][3][9] A2=FE_OFN1806_n5419
+ B1=LLR_sum[2][3][9] B2=FE_OFN1676_FE_DBTN85_n987
XU5479 AOI22S $PINS O=n4958 A1=LLR_sum[1][3][9] A2=FE_OFN1590_FE_DBTN86_n985
+ B1=LLR_sum[4][3][9] B2=FE_OFN1849_n5509
XU5480 AO112 $PINS O=n5114 A1=n4961 B1=n4960 C1=LLR_sum[5][3][9]
+ C2=FE_OFN1489_n1442
XU5481 AO12 $PINS O=n4967 A1=n4963 B1=LLR_sum[3][2][9]
+ B2=FE_OFN1728_FE_DBTN71_n4217
XU5482 AOI22H $PINS O=n4965 A1=LLR_sum[0][2][9] A2=FE_OFN1815_n5419
+ B1=LLR_sum[2][2][9] B2=FE_OFN1690_FE_DBTN85_n987
XU5483 AOI22S $PINS O=n4964 A1=LLR_sum[1][2][9]
+ A2=FE_OFN5586_FE_OFN1620_FE_DBTN86_n985 B1=LLR_sum[4][2][9] B2=FE_OFN1878_n5509
XU5484 ND2 $PINS O=n4966 I1=n4965 I2=n4964
XU5485 AO112 $PINS O=n5113 A1=n4967 B1=n4966 C1=LLR_sum[5][2][9]
+ C2=FE_OFN1508_n1442
XU5486 AO12 $PINS O=n4973 A1=n4969 B1=LLR_sum[3][2][8]
+ B2=FE_OFN1755_FE_DBTN71_n4217
XU5487 AOI22S $PINS O=n4971 A1=LLR_sum[0][2][8] A2=FE_OFN1816_n5419
+ B1=LLR_sum[2][2][8] B2=FE_OFN1698_FE_DBTN85_n987
XU5488 AOI22S $PINS O=n4970 A1=LLR_sum[1][2][8] A2=FE_OFN1604_FE_DBTN86_n985
+ B1=LLR_sum[4][2][8] B2=FE_OFN1895_n5509
XU5489 ND2 $PINS O=n4972 I1=n4971 I2=n4970
XU5490 AO112 $PINS O=n5276 A1=n4973 B1=n4972 C1=LLR_sum[5][2][8]
+ C2=FE_OFN1529_n1442
XU5491 AO12 $PINS O=n4979 A1=n4975 B1=LLR_sum[3][3][8]
+ B2=FE_OFN1715_FE_DBTN71_n4217
XU5492 AOI22S $PINS O=n4977 A1=LLR_sum[0][3][8] A2=FE_OFN5527_n
+ B1=LLR_sum[2][3][8] B2=FE_OFN5619_FE_OFN1672_FE_DBTN85_n987
XU5493 AOI22S $PINS O=n4976 A1=LLR_sum[1][3][8] A2=FE_OFN1454_n985
+ B1=LLR_sum[4][3][8] B2=FE_OFN1865_n5509
XU5494 AO112 $PINS O=n5277 A1=n4979 B1=n4978 C1=LLR_sum[5][3][8]
+ C2=FE_OFN1489_n1442
XU5495 ND2 $PINS O=n4989 I1=n5103 I2=n5277
XU5496 AO222S $PINS O=n4983 A1=FE_OFN1364_n1441 A2=n4980 B1=LLR_sum[3][3][10]
+ B2=FE_OFN1718_FE_DBTN71_n4217 C1=LLR_sum[5][3][10] C2=FE_OFN1484_n1442
XU5497 AOI22S $PINS O=n4982 A1=LLR_sum[1][3][10] A2=FE_OFN1591_FE_DBTN86_n985
+ B1=LLR_sum[4][3][10] B2=FE_OFN1844_n5509
XU5498 AOI22S $PINS O=n4981 A1=LLR_sum[0][3][10] A2=FE_OFN1789_n5419
+ B1=LLR_sum[2][3][10] B2=FE_OFN1682_FE_DBTN85_n987
XU5499 OR3B2 $PINS O=n5281 I1=n4983 B1=n4982 B2=n4981
XU5500 AOI22S $PINS O=n4986 A1=LLR_sum[1][2][10] A2=FE_OFN1596_FE_DBTN86_n985
+ B1=LLR_sum[4][2][10] B2=FE_OFN5644_FE_OFN1878_n5509
XU5501 AOI22S $PINS O=n4985 A1=LLR_sum[0][2][10] A2=FE_OFN1814_n5419
+ B1=LLR_sum[2][2][10] B2=FE_OFN1695_FE_DBTN85_n987
XU5502 OR3B2 $PINS O=n5280 I1=n4987 B1=n4986 B2=n4985
XU5505 AO12 $PINS O=n5000 A1=n4996 B1=LLR_sum[3][3][7] B2=FE_DBTN71_n4217
XU5506 AOI22S $PINS O=n4998 A1=LLR_sum[0][3][7] A2=FE_OFN5527_n
+ B1=LLR_sum[2][3][7] B2=FE_OFN5619_FE_OFN1672_FE_DBTN85_n987
XU5507 AOI22S $PINS O=n4997 A1=LLR_sum[1][3][7] A2=FE_OFN5521_n
+ B1=LLR_sum[4][3][7] B2=FE_OFN1873_n5509
XU5508 AO112 $PINS O=n5293 A1=n5000 B1=n4999 C1=LLR_sum[5][3][7]
+ C2=FE_OFN1498_n1442
XU5509 AO12 $PINS O=n5006 A1=n5002 B1=LLR_sum[3][2][7]
+ B2=FE_OFN1758_FE_DBTN71_n4217
XU5510 AOI22S $PINS O=n5004 A1=LLR_sum[0][2][7] A2=FE_OFN1817_n5419
+ B1=LLR_sum[2][2][7] B2=FE_OFN1694_FE_DBTN85_n987
XU5511 AOI22S $PINS O=n5003 A1=LLR_sum[1][2][7] A2=FE_OFN1628_FE_DBTN86_n985
+ B1=LLR_sum[4][2][7] B2=FE_OFN1903_n5509
XU5512 AO112P $PINS O=n5292 A1=n5006 B1=n5005 C1=LLR_sum[5][2][7]
+ C2=FE_OFN1553_n1442
XU5513 AO12 $PINS O=n5012 A1=n5008 B1=LLR_sum[3][2][6] B2=FE_OFN2195_n4217
XU5514 AOI22S $PINS O=n5010 A1=LLR_sum[0][2][6] A2=FE_OFN1823_n5419
+ B1=LLR_sum[2][2][6] B2=FE_OFN1699_FE_DBTN85_n987
XU5515 AOI22S $PINS O=n5009 A1=LLR_sum[1][2][6] A2=FE_OFN5676_n
+ B1=LLR_sum[4][2][6] B2=FE_OFN1914_n5509
XU5516 AO112 $PINS O=n5296 A1=n5012 B1=n5011 C1=LLR_sum[5][2][6]
+ C2=FE_OFN5562_n
XU5517 AO12 $PINS O=n5018 A1=n5014 B1=LLR_sum[3][3][6]
+ B2=FE_OFN1736_FE_DBTN71_n4217
XU5518 AOI22S $PINS O=n5016 A1=LLR_sum[0][3][6] A2=FE_OFN5527_n
+ B1=LLR_sum[2][3][6] B2=FE_OFN1665_FE_DBTN85_n987
XU5519 AOI22S $PINS O=n5015 A1=LLR_sum[1][3][6] A2=FE_OFN1602_FE_DBTN86_n985
+ B1=LLR_sum[4][3][6] B2=FE_OFN1873_n5509
XU5520 AO112 $PINS O=n5297 A1=n5018 B1=n5017 C1=LLR_sum[5][3][6]
+ C2=FE_OFN1499_n1442
XU5521 AO12 $PINS O=n5024 A1=n5020 B1=LLR_sum[3][3][5]
+ B2=FE_OFN1730_FE_DBTN71_n4217
XU5522 AOI22S $PINS O=n5022 A1=LLR_sum[0][3][5] A2=FE_OFN5527_n
+ B1=LLR_sum[2][3][5] B2=FE_OFN1659_FE_DBTN85_n987
XU5523 AOI22S $PINS O=n5021 A1=LLR_sum[1][3][5] A2=FE_OFN1602_FE_DBTN86_n985
+ B1=LLR_sum[4][3][5] B2=FE_OFN1892_n5509
XU5524 AO112 $PINS O=n5301 A1=n5024 B1=n5023 C1=LLR_sum[5][3][5]
+ C2=FE_OFN1506_n1442
XU5525 AO12 $PINS O=n5030 A1=n5026 B1=LLR_sum[3][2][5]
+ B2=FE_OFN1759_FE_DBTN71_n4217
XU5526 AOI22S $PINS O=n5028 A1=LLR_sum[0][2][5] A2=FE_OFN5611_FE_OFN1828_n5419
+ B1=LLR_sum[2][2][5] B2=FE_OFN5564_n
XU5527 AOI22S $PINS O=n5027 A1=LLR_sum[1][2][5] A2=FE_OFN1640_FE_DBTN86_n985
+ B1=LLR_sum[4][2][5] B2=FE_OFN1911_n5509
XU5528 AO112P $PINS O=n5300 A1=n5030 B1=n5029 C1=LLR_sum[5][2][5]
+ C2=FE_OFN1549_n1442
XU5529 AO12 $PINS O=n5036 A1=n5032 B1=LLR_sum[3][2][4]
+ B2=FE_OFN1757_FE_DBTN71_n4217
XU5530 AOI22S $PINS O=n5034 A1=LLR_sum[0][2][4] A2=FE_OFN1828_n5419
+ B1=LLR_sum[2][2][4] B2=FE_OFN1693_FE_DBTN85_n987
XU5531 AOI22S $PINS O=n5033 A1=LLR_sum[1][2][4]
+ A2=FE_OFN5599_FE_OFN1622_FE_DBTN86_n985 B1=LLR_sum[4][2][4]
+ B2=FE_OFN5631_FE_OFN1905_n5509
XU5532 AO112 $PINS O=n5304 A1=n5036 B1=n5035 C1=LLR_sum[5][2][4]
+ C2=FE_OFN1548_n1442
XU5533 AO12 $PINS O=n5042 A1=n5038 B1=LLR_sum[3][3][4]
+ B2=FE_OFN1730_FE_DBTN71_n4217
XU5534 AOI22S $PINS O=n5040 A1=LLR_sum[0][3][4] A2=FE_OFN1822_n5419
+ B1=LLR_sum[2][3][4] B2=FE_OFN1659_FE_DBTN85_n987
XU5535 AOI22S $PINS O=n5039 A1=LLR_sum[1][3][4] A2=FE_OFN1634_FE_DBTN86_n985
+ B1=LLR_sum[4][3][4] B2=FE_OFN1904_n5509
XU5536 AO112 $PINS O=n5305 A1=n5042 B1=n5041 C1=LLR_sum[5][3][4]
+ C2=FE_OFN1506_n1442
XU5537 ND2 $PINS O=n5069 I1=n5307 I2=n5043
XU5538 AO12 $PINS O=n5049 A1=n5045 B1=LLR_sum[3][2][2]
+ B2=FE_OFN1734_FE_DBTN71_n4217
XU5539 AOI22S $PINS O=n5047 A1=LLR_sum[0][2][2] A2=FE_OFN5577_n
+ B1=LLR_sum[2][2][2] B2=FE_OFN1687_FE_DBTN85_n987
XU5540 AOI22S $PINS O=n5046 A1=LLR_sum[1][2][2] A2=FE_OFN5643_FE_OFN5534_n
+ B1=LLR_sum[4][2][2] B2=FE_OFN5597_FE_OFN1915_n5509
XU5541 AO112 $PINS O=n5308 A1=n5049 B1=n5048 C1=LLR_sum[5][2][2]
+ C2=FE_OFN1531_n1442
XU5542 AO12 $PINS O=n5055 A1=n5051 B1=LLR_sum[3][3][2]
+ B2=FE_OFN1713_FE_DBTN71_n4217
XU5543 AOI22S $PINS O=n5053 A1=LLR_sum[0][3][2] A2=FE_OFN5568_n
+ B1=LLR_sum[2][3][2] B2=FE_OFN1662_FE_DBTN85_n987
XU5544 AOI22S $PINS O=n5052 A1=LLR_sum[1][3][2] A2=FE_OFN5670_n
+ B1=LLR_sum[4][3][2] B2=FE_OFN1883_n5509
XU5545 AO112 $PINS O=n5309 A1=n5055 B1=n5054 C1=LLR_sum[5][3][2]
+ C2=FE_OFN5576_n
XU5546 AO12 $PINS O=n5062 A1=n5058 B1=LLR_sum[3][3][1]
+ B2=FE_OFN1723_FE_DBTN71_n4217
XU5547 AOI22S $PINS O=n5060 A1=LLR_sum[0][3][1] A2=FE_OFN5528_n
+ B1=LLR_sum[2][3][1] B2=FE_OFN1662_FE_DBTN85_n987
XU5548 AOI22S $PINS O=n5059 A1=LLR_sum[1][3][1] A2=FE_OFN5681_n
+ B1=LLR_sum[4][3][1] B2=FE_OFN1879_n5509
XU5549 AO112 $PINS O=n5316 A1=n5062 B1=n5061 C1=LLR_sum[5][3][1]
+ C2=FE_OFN1518_n1442
XU5550 AO12 $PINS O=n5068 A1=n5064 B1=LLR_sum[3][2][1]
+ B2=FE_OFN1733_FE_DBTN71_n4217
XU5551 AOI22S $PINS O=n5066 A1=LLR_sum[0][2][1] A2=FE_OFN1832_n5419
+ B1=LLR_sum[2][2][1] B2=FE_OFN1687_FE_DBTN85_n987
XU5552 AOI22S $PINS O=n5065 A1=LLR_sum[1][2][1] A2=FE_OFN1653_FE_DBTN86_n985
+ B1=LLR_sum[4][2][1] B2=FE_OFN5523_n
XU5553 AO112 $PINS O=n5315 A1=n5068 B1=n5067 C1=LLR_sum[5][2][1]
+ C2=FE_OFN5647_FE_OFN1530_n1442
XU5554 OAI12HS $PINS O=n5089 A1=n5069 B1=n5070 B2=FE_OFN2212_n5315
XU5555 AO12 $PINS O=n5076 A1=n5072 B1=LLR_sum[3][2][0]
+ B2=FE_OFN1744_FE_DBTN71_n4217
XU5556 AOI22S $PINS O=n5074 A1=LLR_sum[0][2][0] A2=FE_OFN1832_n5419
+ B1=LLR_sum[2][2][0] B2=FE_OFN1673_FE_DBTN85_n987
XU5557 AOI22S $PINS O=n5073 A1=LLR_sum[1][2][0] A2=FE_OFN1652_FE_DBTN86_n985
+ B1=LLR_sum[4][2][0] B2=FE_OFN5522_n
XU5558 AO112 $PINS O=n5375 A1=n5076 B1=n5075 C1=LLR_sum[5][2][0]
+ C2=FE_OFN5647_FE_OFN1530_n1442
XU5559 AO12 $PINS O=n5082 A1=n5078 B1=LLR_sum[3][3][0]
+ B2=FE_OFN1723_FE_DBTN71_n4217
XU5560 AOI22S $PINS O=n5080 A1=LLR_sum[0][3][0] A2=FE_OFN5528_n
+ B1=LLR_sum[2][3][0] B2=FE_OFN5578_n
XU5561 AOI22S $PINS O=n5079 A1=LLR_sum[1][3][0] A2=FE_OFN5681_n
+ B1=LLR_sum[4][3][0] B2=FE_OFN1879_n5509
XU5562 AO112 $PINS O=n5376 A1=n5082 B1=n5081 C1=LLR_sum[5][3][0]
+ C2=FE_OFN1518_n1442
XU5563 OAI22S $PINS O=n5085 A1=n5084 A2=n5376 B1=n5083 B2=n5316
XU5564 OAI12HS $PINS O=n5088 A1=n5085 B1=n5086 B2=n5308
XU5565 OAI222S $PINS O=n5092 A1=n5091 A2=n5090 B1=n5089 B2=n5088 C1=n5087
+ C2=n5305
XU5566 AOI22S $PINS O=n5097 A1=n5094 A2=n5300 B1=n5093 B2=n5092
XU5567 AN2 $PINS O=n5096 I1=n5095 I2=n5301
XU5568 OAI22S $PINS O=n5099 A1=n5098 A2=n5297 B1=n5097 B2=n5096
XU5569 AOI22S $PINS O=n5105 A1=n5101 A2=n5292 B1=n5100 B2=n5099
XU5570 AN2 $PINS O=n5104 I1=n5102 I2=n5293
XU5571 OAI22H $PINS O=n5108 A1=n5105 A2=n5104 B1=n5103 B2=n5277
XU5572 AO12 $PINS O=n5120 A1=n5116 B1=LLR_sum[3][1][9]
+ B2=FE_OFN1720_FE_DBTN71_n4217
XU5573 AOI22S $PINS O=n5118 A1=LLR_sum[0][1][9] A2=FE_OFN1806_n5419
+ B1=LLR_sum[2][1][9] B2=FE_OFN1686_FE_DBTN85_n987
XU5574 AOI22S $PINS O=n5117 A1=LLR_sum[1][1][9]
+ A2=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985 B1=LLR_sum[4][1][9] B2=FE_OFN1856_n5509
XU5575 AO112 $PINS O=n5275 A1=n5120 B1=n5119 C1=LLR_sum[5][1][9]
+ C2=FE_OFN1494_n1442
XU5576 AO12 $PINS O=n5126 A1=n5122 B1=LLR_sum[3][0][9]
+ B2=FE_OFN1750_FE_DBTN71_n4217
XU5577 AOI22S $PINS O=n5124 A1=LLR_sum[0][0][9] A2=FE_OFN1815_n5419
+ B1=LLR_sum[2][0][9] B2=FE_OFN1690_FE_DBTN85_n987
XU5578 AOI22S $PINS O=n5123 A1=LLR_sum[1][0][9] A2=FE_OFN1617_FE_DBTN86_n985
+ B1=LLR_sum[4][0][9] B2=FE_OFN1886_n5509
XU5579 ND2 $PINS O=n5125 I1=n5124 I2=n5123
XU5580 AO112 $PINS O=n5274 A1=n5126 B1=n5125 C1=LLR_sum[5][0][9]
+ C2=FE_OFN1516_n1442
XU5581 AO12 $PINS O=n5132 A1=n5128 B1=LLR_sum[3][0][8]
+ B2=FE_OFN1755_FE_DBTN71_n4217
XU5582 AOI22S $PINS O=n5130 A1=LLR_sum[0][0][8] A2=FE_OFN1816_n5419
+ B1=LLR_sum[2][0][8] B2=FE_OFN1698_FE_DBTN85_n987
XU5583 AOI22S $PINS O=n5129 A1=LLR_sum[1][0][8] A2=FE_OFN1623_FE_DBTN86_n985
+ B1=LLR_sum[4][0][8] B2=FE_OFN5680_n
XU5584 ND2 $PINS O=n5131 I1=n5130 I2=n5129
XU5585 AO112 $PINS O=n5278 A1=n5132 B1=n5131 C1=LLR_sum[5][0][8]
+ C2=FE_OFN1543_n1442
XU5586 AO12 $PINS O=n5138 A1=n5134 B1=LLR_sum[3][1][8]
+ B2=FE_OFN1727_FE_DBTN71_n4217
XU5587 AOI22S $PINS O=n5136 A1=LLR_sum[0][1][8] A2=FE_OFN1810_n5419
+ B1=LLR_sum[2][1][8] B2=FE_OFN1672_FE_DBTN85_n987
XU5588 AOI22S $PINS O=n5135 A1=LLR_sum[1][1][8] A2=FE_OFN1600_FE_DBTN86_n985
+ B1=LLR_sum[4][1][8] B2=FE_OFN1870_n5509
XU5589 AO112 $PINS O=n5279 A1=n5138 B1=n5137 C1=LLR_sum[5][1][8]
+ C2=FE_OFN1497_n1442
XU5590 AO222S $PINS O=n5142 A1=FE_OFN1373_n1441 A2=n5139 B1=LLR_sum[3][1][10]
+ B2=FE_OFN5618_FE_OFN1724_FE_DBTN71_n4217 C1=LLR_sum[5][1][10]
+ C2=FE_OFN1488_n1442
XU5591 AOI22S $PINS O=n5141 A1=LLR_sum[1][1][10] A2=FE_OFN1598_FE_DBTN86_n985
+ B1=LLR_sum[4][1][10] B2=FE_OFN1854_n5509
XU5592 AOI22S $PINS O=n5140 A1=LLR_sum[0][1][10] A2=FE_OFN1795_n5419
+ B1=LLR_sum[2][1][10] B2=FE_OFN1686_FE_DBTN85_n987
XU5594 AO12 $PINS O=n5148 A1=n5144 B1=LLR_sum[3][0][10]
+ B2=FE_OFN1728_FE_DBTN71_n4217
XU5595 AOI22H $PINS O=n5146 A1=LLR_sum[0][0][10] A2=FE_OFN1807_n5419
+ B1=LLR_sum[2][0][10] B2=FE_OFN1695_FE_DBTN85_n987
XU5596 AOI22S $PINS O=n5145 A1=LLR_sum[1][0][10]
+ A2=FE_OFN5586_FE_OFN1620_FE_DBTN86_n985 B1=LLR_sum[4][0][10]
+ B2=FE_OFN1875_n5509
XU5597 ND2P $PINS O=n5147 I1=n5146 I2=n5145
XU5598 AO112P $PINS O=n5282 A1=n5148 B1=n5147 C1=LLR_sum[5][0][10]
+ C2=FE_OFN1508_n1442
XU5600 AO12 $PINS O=n5161 A1=n5157 B1=LLR_sum[3][1][7]
+ B2=FE_OFN1727_FE_DBTN71_n4217
XU5601 AOI22S $PINS O=n5159 A1=LLR_sum[0][1][7] A2=FE_OFN1811_n5419
+ B1=LLR_sum[2][1][7] B2=FE_OFN1665_FE_DBTN85_n987
XU5602 AOI22S $PINS O=n5158 A1=LLR_sum[1][1][7] A2=FE_OFN1636_FE_DBTN86_n985
+ B1=LLR_sum[4][1][7] B2=FE_OFN5616_FE_OFN1882_n5509
XU5603 AO112 $PINS O=n5291 A1=n5161 B1=n5160 C1=LLR_sum[5][1][7]
+ C2=FE_OFN1512_n1442
XU5604 AO12 $PINS O=n5167 A1=n5163 B1=LLR_sum[3][0][7]
+ B2=FE_OFN1758_FE_DBTN71_n4217
XU5605 AOI22S $PINS O=n5165 A1=LLR_sum[0][0][7] A2=FE_OFN1820_n5419
+ B1=LLR_sum[2][0][7] B2=FE_OFN1694_FE_DBTN85_n987
XU5606 AOI22S $PINS O=n5164 A1=LLR_sum[1][0][7] A2=FE_OFN1635_FE_DBTN86_n985
+ B1=LLR_sum[4][0][7] B2=FE_OFN1908_n5509
XU5607 ND2 $PINS O=n5166 I1=n5165 I2=n5164
XU5608 AO112P $PINS O=n5290 A1=n5167 B1=n5166 C1=LLR_sum[5][0][7]
+ C2=FE_OFN5561_n
XU5609 AO12 $PINS O=n5173 A1=n5169 B1=LLR_sum[3][0][6] B2=FE_OFN2195_n4217
XU5610 AOI22S $PINS O=n5171 A1=LLR_sum[0][0][6] A2=FE_OFN1823_n5419
+ B1=LLR_sum[2][0][6] B2=FE_OFN1699_FE_DBTN85_n987
XU5611 AOI22S $PINS O=n5170 A1=LLR_sum[1][0][6] A2=FE_OFN1645_FE_DBTN86_n985
+ B1=LLR_sum[4][0][6] B2=FE_OFN1916_n5509
XU5612 AO112 $PINS O=n5294 A1=n5173 B1=n5172 C1=LLR_sum[5][0][6]
+ C2=FE_OFN1561_n1442
XU5613 AO12 $PINS O=n5179 A1=n5175 B1=LLR_sum[3][1][6]
+ B2=FE_OFN1738_FE_DBTN71_n4217
XU5614 AOI22S $PINS O=n5177 A1=LLR_sum[0][1][6] A2=FE_OFN1799_n5419
+ B1=LLR_sum[2][1][6] B2=FE_OFN1689_FE_DBTN85_n987
XU5615 AOI22S $PINS O=n5176 A1=LLR_sum[1][1][6] A2=FE_OFN5673_n
+ B1=LLR_sum[4][1][6] B2=FE_OFN5634_FE_OFN1892_n5509
XU5616 AO112 $PINS O=n5295 A1=n5179 B1=n5178 C1=LLR_sum[5][1][6]
+ C2=FE_OFN1520_n1442
XU5617 AO12 $PINS O=n5185 A1=n5181 B1=LLR_sum[3][1][5]
+ B2=FE_OFN1757_FE_DBTN71_n4217
XU5618 AOI22S $PINS O=n5183 A1=LLR_sum[0][1][5] A2=FE_OFN1818_n5419
+ B1=LLR_sum[2][1][5] B2=FE_OFN1668_FE_DBTN85_n987
XU5619 AOI22S $PINS O=n5182 A1=LLR_sum[1][1][5] A2=FE_OFN1621_FE_DBTN86_n985
+ B1=LLR_sum[4][1][5] B2=FE_OFN1900_n5509
XU5620 AO112 $PINS O=n5299 A1=n5185 B1=n5184 C1=LLR_sum[5][1][5]
+ C2=FE_OFN1537_n1442
XU5621 AO12 $PINS O=n5191 A1=n5187 B1=LLR_sum[3][0][5]
+ B2=FE_OFN1759_FE_DBTN71_n4217
XU5622 AOI22S $PINS O=n5189 A1=LLR_sum[0][0][5] A2=FE_OFN5611_FE_OFN1828_n5419
+ B1=LLR_sum[2][0][5] B2=FE_OFN5564_n
XU5623 AOI22S $PINS O=n5188 A1=LLR_sum[1][0][5] A2=FE_OFN1640_FE_DBTN86_n985
+ B1=LLR_sum[4][0][5] B2=FE_OFN1911_n5509
XU5624 AO112P $PINS O=n5298 A1=n5191 B1=n5190 C1=LLR_sum[5][0][5]
+ C2=FE_OFN1554_n1442
XU5625 AO12 $PINS O=n5197 A1=n5193 B1=LLR_sum[3][0][4]
+ B2=FE_OFN1759_FE_DBTN71_n4217
XU5626 AOI22S $PINS O=n5195 A1=LLR_sum[0][0][4] A2=FE_OFN5611_FE_OFN1828_n5419
+ B1=LLR_sum[2][0][4] B2=FE_OFN1693_FE_DBTN85_n987
XU5627 AOI22S $PINS O=n5194 A1=LLR_sum[1][0][4] A2=FE_OFN1640_FE_DBTN86_n985
+ B1=LLR_sum[4][0][4] B2=FE_OFN1911_n5509
XU5628 AO112 $PINS O=n5302 A1=n5197 B1=n5196 C1=LLR_sum[5][0][4]
+ C2=FE_OFN1548_n1442
XU5629 AO12 $PINS O=n5203 A1=n5199 B1=LLR_sum[3][1][4]
+ B2=FE_OFN1746_FE_DBTN71_n4217
XU5630 AOI22S $PINS O=n5201 A1=LLR_sum[0][1][4] A2=FE_OFN1818_n5419
+ B1=LLR_sum[2][1][4] B2=FE_OFN1668_FE_DBTN85_n987
XU5631 AOI22S $PINS O=n5200 A1=LLR_sum[1][1][4] A2=FE_OFN1610_FE_DBTN86_n985
+ B1=LLR_sum[4][1][4] B2=FE_OFN1884_n5509
XU5632 AO112 $PINS O=n5303 A1=n5203 B1=n5202 C1=LLR_sum[5][1][4]
+ C2=FE_OFN1522_n1442
XU5633 ND2 $PINS O=n5230 I1=n5306 I2=n5204
XU5634 AO12 $PINS O=n5210 A1=n5206 B1=LLR_sum[3][0][2]
+ B2=FE_OFN1745_FE_DBTN71_n4217
XU5635 AOI22S $PINS O=n5208 A1=LLR_sum[0][0][2] A2=FE_OFN1831_n5419
+ B1=LLR_sum[2][0][2] B2=FE_OFN1680_FE_DBTN85_n987
XU5636 AOI22S $PINS O=n5207 A1=LLR_sum[1][0][2] A2=FE_OFN1641_FE_DBTN86_n985
+ B1=LLR_sum[4][0][2] B2=FE_OFN5592_FE_OFN1915_n5509
XU5637 AO112 $PINS O=n5310 A1=n5210 B1=n5209 C1=LLR_sum[5][0][2]
+ C2=FE_OFN5604_FE_OFN1533_n1442
XU5638 AO12 $PINS O=n5216 A1=n5212 B1=LLR_sum[3][1][2]
+ B2=FE_OFN1719_FE_DBTN71_n4217
XU5639 AOI22S $PINS O=n5214 A1=LLR_sum[0][1][2] A2=FE_OFN1837_n5419
+ B1=LLR_sum[2][1][2] B2=FE_OFN1663_FE_DBTN85_n987
XU5640 AOI22S $PINS O=n5213 A1=LLR_sum[1][1][2] A2=FE_OFN1630_FE_DBTN86_n985
+ B1=LLR_sum[4][1][2] B2=FE_OFN1906_n5509
XU5641 AO112 $PINS O=n5311 A1=n5216 B1=n5215 C1=LLR_sum[5][1][2]
+ C2=FE_OFN1509_n1442
XU5642 AO12 $PINS O=n5223 A1=n5219 B1=LLR_sum[3][1][1]
+ B2=FE_OFN5630_FE_OFN5539_n
XU5643 AOI22S $PINS O=n5221 A1=LLR_sum[0][1][1] A2=FE_OFN1813_n5419
+ B1=LLR_sum[2][1][1] B2=FE_OFN5590_FE_OFN5578_n
XU5644 AOI22S $PINS O=n5220 A1=LLR_sum[1][1][1] A2=FE_OFN1643_FE_DBTN86_n985
+ B1=LLR_sum[4][1][1] B2=FE_OFN1913_n5509
XU5645 AO112 $PINS O=n5314 A1=n5223 B1=n5222 C1=LLR_sum[5][1][1]
+ C2=FE_OFN1526_n1442
XU5646 AO12 $PINS O=n5229 A1=n5225 B1=LLR_sum[3][0][1]
+ B2=FE_OFN1733_FE_DBTN71_n4217
XU5647 AOI22S $PINS O=n5227 A1=LLR_sum[0][0][1] A2=FE_OFN5577_n
+ B1=LLR_sum[2][0][1] B2=FE_OFN1687_FE_DBTN85_n987
XU5648 AOI22S $PINS O=n5226 A1=LLR_sum[1][0][1] A2=FE_OFN1653_FE_DBTN86_n985
+ B1=LLR_sum[4][0][1] B2=FE_OFN5523_n
XU5649 AO112 $PINS O=n5313 A1=n5229 B1=n5228 C1=LLR_sum[5][0][1]
+ C2=FE_OFN5647_FE_OFN1530_n1442
XU5650 OAI12HS $PINS O=n5250 A1=n5230 B1=n5231 B2=FE_OFN2208_n5313
XU5651 AO12 $PINS O=n5237 A1=n5233 B1=LLR_sum[3][0][0]
+ B2=FE_OFN1744_FE_DBTN71_n4217
XU5652 AOI22S $PINS O=n5235 A1=LLR_sum[0][0][0] A2=FE_OFN3101_n5419
+ B1=LLR_sum[2][0][0] B2=FE_OFN1673_FE_DBTN85_n987
XU5653 AOI22S $PINS O=n5234 A1=LLR_sum[1][0][0] A2=FE_OFN1653_FE_DBTN86_n985
+ B1=LLR_sum[4][0][0] B2=FE_OFN5523_n
XU5654 AO112 $PINS O=n5317 A1=n5237 B1=n5236 C1=LLR_sum[5][0][0]
+ C2=FE_OFN1547_n1442
XU5655 AO12 $PINS O=n5243 A1=n5239 B1=LLR_sum[3][1][0]
+ B2=FE_OFN5630_FE_OFN5539_n
XU5656 AOI22S $PINS O=n5241 A1=LLR_sum[0][1][0] A2=FE_OFN5569_n
+ B1=LLR_sum[2][1][0] B2=FE_OFN5589_FE_OFN5578_n
XU5657 AOI22S $PINS O=n5240 A1=LLR_sum[1][1][0] A2=FE_OFN1643_FE_DBTN86_n985
+ B1=LLR_sum[4][1][0] B2=FE_OFN1913_n5509
XU5658 AO112 $PINS O=n5318 A1=n5243 B1=n5242 C1=LLR_sum[5][1][0]
+ C2=FE_OFN5637_FE_OFN1526_n1442
XU5659 OAI22H $PINS O=n5246 A1=n5245 A2=n5318 B1=n5244 B2=n5314
XU5660 OAI12HS $PINS O=n5249 A1=n5246 B1=n5247 B2=n5310
XU5661 OAI222H $PINS O=n5253 A1=n5252 A2=n5251 B1=n5250 B2=n5249 C1=n5248
+ C2=n5303
XU5662 AOI22H $PINS O=n5258 A1=n5255 A2=n5298 B1=n5254 B2=n5253
XU5663 AN2 $PINS O=n5257 I1=n5256 I2=n5299
XU5664 OAI22S $PINS O=n5260 A1=n5259 A2=n5295 B1=n5258 B2=n5257
XU5665 AOI22S $PINS O=n5266 A1=n5262 A2=n5290 B1=n5261 B2=n5260
XU5666 AN2 $PINS O=n5265 I1=n5263 I2=n5291
XU5667 OAI22S $PINS O=n5269 A1=n5266 A2=n5265 B1=n5264 B2=n5279
XU5668 ND2 $PINS O=n5285 I1=n5359 I2=n5342
XU5669 OA222 $PINS O=n5350 A1=n5287 A2=n5356 B1=n5286 B2=n5285 C1=n5284
+ C2=n5354
XU5670 OAI22S $PINS O=n5349 A1=n5352 A2=n5289 B1=n5355 B2=n5288
XU5671 MUX2 $PINS O=n5369 S=FE_OFN2059_n1456 A=n5307 B=N604
XU5672 AOI22S $PINS O=n5329 A1=n5368 A2=n5312 B1=n5325 B2=n5370
XU5673 MUX2 $PINS O=n5372 S=FE_OFN2060_n1457 A=n5314 B=FE_OFN2208_n5313
XU5674 MUX2 $PINS O=n5374 S=FE_OFN2060_n1457 A=n5318 B=FE_OFN2211_n5317
XU5675 MUX2 $PINS O=n5319 S=FE_OFN2058_n1456 A=n5376 B=FE_OFN5529_n5375
XU5679 AN2 $PINS O=n5335 I1=n5334 I2=n5365
XU5682 AN2 $PINS O=n5343 I1=n5341 I2=n5361
XU5683 OR3B2 $PINS O=n870 I1=state[0] B1=state[2] B2=n5516
XU5684 MUX2 $PINS O=n2015 S=FE_OFN2048_FE_DBTN74_n1535 A=data_o[24] B=N2975
XU5685 MUX2 $PINS O=n2014 S=FE_OFN2048_FE_DBTN74_n1535 A=data_o[25] B=N2976
XU5686 MUX2 $PINS O=n2013 S=FE_OFN2048_FE_DBTN74_n1535 A=data_o[26] B=N2977
XU5687 MUX2 $PINS O=n2012 S=FE_OFN2048_FE_DBTN74_n1535 A=data_o[27] B=N2978
XU5688 MUX2 $PINS O=n2011 S=FE_OFN2048_FE_DBTN74_n1535 A=data_o[28] B=N2979
XU5689 MUX2 $PINS O=n2010 S=FE_OFN2048_FE_DBTN74_n1535 A=data_o[29] B=N2980
XU5690 MUX2 $PINS O=n2009 S=FE_OFN2047_FE_DBTN74_n1535 A=data_o[30] B=N2981
XU5691 MUX2 $PINS O=n2008 S=FE_OFN2047_FE_DBTN74_n1535 A=data_o[31] B=N2982
XU5692 MUX2 $PINS O=n2007 S=FE_OFN2047_FE_DBTN74_n1535 A=data_o[32] B=N2983
XU5693 MUX2 $PINS O=n2006 S=FE_OFN2047_FE_DBTN74_n1535 A=data_o[33] B=N2984
XU5694 MUX2 $PINS O=n2005 S=FE_OFN2047_FE_DBTN74_n1535 A=data_o[34] B=N2985
XU5695 MUX2 $PINS O=n2004 S=FE_DBTN74_n1535 A=data_o[35] B=N2986
XU5696 MUX2 $PINS O=n2003 S=FE_OFN518_FE_DBTN76_n1536 A=data_o[36] B=N2975
XU5697 MUX2 $PINS O=n2002 S=FE_OFN518_FE_DBTN76_n1536 A=data_o[37] B=N2976
XU5698 MUX2 $PINS O=n2001 S=FE_OFN518_FE_DBTN76_n1536 A=data_o[38] B=N2977
XU5699 MUX2 $PINS O=n2000 S=FE_OFN518_FE_DBTN76_n1536 A=data_o[39] B=N2978
XU5700 MUX2 $PINS O=n1999 S=FE_OFN518_FE_DBTN76_n1536 A=data_o[40] B=N2979
XU5701 MUX2 $PINS O=n1998 S=FE_OFN518_FE_DBTN76_n1536 A=data_o[41] B=N2980
XU5702 MUX2 $PINS O=n1997 S=FE_OFN517_FE_DBTN76_n1536 A=data_o[42] B=N2981
XU5703 MUX2 $PINS O=n1996 S=FE_OFN517_FE_DBTN76_n1536 A=data_o[43] B=N2982
XU5704 MUX2 $PINS O=n1995 S=FE_OFN517_FE_DBTN76_n1536 A=data_o[44] B=N2983
XU5705 MUX2 $PINS O=n1994 S=FE_OFN517_FE_DBTN76_n1536 A=data_o[45] B=N2984
XU5706 MUX2 $PINS O=n1993 S=FE_OFN517_FE_DBTN76_n1536 A=data_o[46] B=N2985
XU5707 MUX2 $PINS O=n1992 S=FE_DBTN76_n1536 A=data_o[47] B=N2986
XU5708 MUX2 $PINS O=n1991 S=FE_OFN2042_n1537 A=data_o[48] B=N2975
XU5709 MUX2 $PINS O=n1990 S=FE_OFN2042_n1537 A=data_o[49] B=N2976
XU5710 MUX2 $PINS O=n1989 S=FE_OFN2042_n1537 A=data_o[50] B=N2977
XU5711 MUX2 $PINS O=n1988 S=FE_OFN2042_n1537 A=data_o[51] B=N2978
XU5712 MUX2 $PINS O=n1987 S=FE_OFN2042_n1537 A=data_o[52] B=N2979
XU5713 MUX2 $PINS O=n1986 S=FE_OFN2042_n1537 A=data_o[53] B=N2980
XU5714 MUX2 $PINS O=n1985 S=FE_OFN2041_n1537 A=data_o[54] B=N2981
XU5715 MUX2 $PINS O=n1984 S=FE_OFN2041_n1537 A=data_o[55] B=N2982
XU5716 MUX2 $PINS O=n1983 S=FE_OFN2041_n1537 A=data_o[56] B=N2983
XU5717 MUX2 $PINS O=n1982 S=FE_OFN2041_n1537 A=data_o[57] B=N2984
XU5718 MUX2 $PINS O=n1981 S=FE_OFN2041_n1537 A=data_o[58] B=N2985
XU5719 MUX2 $PINS O=n1980 S=n1537 A=data_o[59] B=N2986
XU5720 MUX2 $PINS O=n1979 S=FE_OFN2044_n1538 A=data_o[60] B=N2975
XU5721 MUX2 $PINS O=n1978 S=FE_OFN2044_n1538 A=data_o[61] B=N2976
XU5722 MUX2 $PINS O=n1977 S=FE_OFN2044_n1538 A=data_o[62] B=N2977
XU5723 MUX2 $PINS O=n1976 S=FE_OFN2044_n1538 A=data_o[63] B=N2978
XU5724 MUX2 $PINS O=n1975 S=FE_OFN2044_n1538 A=data_o[64] B=N2979
XU5725 MUX2 $PINS O=n1974 S=FE_OFN2044_n1538 A=data_o[65] B=N2980
XU5726 MUX2 $PINS O=n1973 S=FE_OFN2043_n1538 A=data_o[66] B=N2981
XU5727 MUX2 $PINS O=n1972 S=FE_OFN2043_n1538 A=data_o[67] B=N2982
XU5728 MUX2 $PINS O=n1971 S=FE_OFN2043_n1538 A=data_o[68] B=N2983
XU5729 MUX2 $PINS O=n1970 S=FE_OFN2043_n1538 A=data_o[69] B=N2984
XU5730 MUX2 $PINS O=n1969 S=FE_OFN2043_n1538 A=data_o[70] B=N2985
XU5731 MUX2 $PINS O=n1968 S=n1538 A=data_o[71] B=N2986
XU5732 MUX2 $PINS O=n1967 S=FE_OFN2046_n1539 A=data_o[72] B=N2975
XU5733 MUX2 $PINS O=n1966 S=FE_OFN2046_n1539 A=data_o[73] B=N2976
XU5734 MUX2 $PINS O=n1965 S=FE_OFN2046_n1539 A=data_o[74] B=N2977
XU5735 MUX2 $PINS O=n1964 S=FE_OFN2046_n1539 A=data_o[75] B=N2978
XU5736 MUX2 $PINS O=n1963 S=FE_OFN2046_n1539 A=data_o[76] B=N2979
XU5737 MUX2 $PINS O=n1962 S=FE_OFN2046_n1539 A=data_o[77] B=N2980
XU5738 MUX2 $PINS O=n1961 S=FE_OFN2045_n1539 A=data_o[78] B=N2981
XU5739 MUX2 $PINS O=n1960 S=FE_OFN2045_n1539 A=data_o[79] B=N2982
XU5740 MUX2 $PINS O=n1959 S=FE_OFN2045_n1539 A=data_o[80] B=N2983
XU5741 MUX2 $PINS O=n1958 S=FE_OFN2045_n1539 A=data_o[81] B=N2984
XU5742 MUX2 $PINS O=n1957 S=FE_OFN2045_n1539 A=data_o[82] B=N2985
XU5743 MUX2 $PINS O=n1956 S=n1539 A=data_o[83] B=N2986
XU5744 AO222S $PINS O=n1221 A1=backward_sum[2][2][11]
+ A2=FE_OFN1704_FE_DBTN85_n987 B1=backward_sum[0][2][11] B2=FE_OFN1796_n5419
+ C1=backward_sum[1][2][11] C2=FE_OFN1620_FE_DBTN86_n985
XU5745 AOI22S $PINS O=n1222 A1=backward_sum[6][2][11] A2=FE_OFN1402_n1441
+ B1=backward_sum[5][2][11] B2=FE_OFN1523_n1442
XU5746 AOI22S $PINS O=n1223 A1=backward_sum[4][2][11] A2=FE_OFN1864_n5509
+ B1=backward_sum[3][2][11] B2=FE_OFN1743_FE_DBTN71_n4217
XU5747 AO222S $PINS O=n1218 A1=backward_sum[2][2][10]
+ A2=FE_OFN1704_FE_DBTN85_n987 B1=backward_sum[0][2][10] B2=FE_OFN1801_n5419
+ C1=backward_sum[1][2][10] C2=FE_OFN1615_FE_DBTN86_n985
XU5748 AOI22S $PINS O=n1219 A1=backward_sum[6][2][10] A2=FE_OFN1401_n1441
+ B1=backward_sum[5][2][10] B2=FE_OFN1523_n1442
XU5749 AOI22S $PINS O=n1220 A1=backward_sum[4][2][10] A2=FE_OFN1867_n5509
+ B1=backward_sum[3][2][10] B2=FE_OFN1747_FE_DBTN71_n4217
XU5750 AO12 $PINS O=n5378 A1=n1658 B1=backward_sum[2][2][9]
+ B2=FE_OFN5645_FE_OFN1690_FE_DBTN85_n987
XU5751 AOI22S $PINS O=n1216 A1=backward_sum[6][2][9] A2=FE_OFN1382_n1441
+ B1=backward_sum[5][2][9] B2=FE_OFN1528_n1442
XU5752 AOI22S $PINS O=n1217 A1=backward_sum[4][2][9] A2=FE_OFN1886_n5509
+ B1=backward_sum[3][2][9] B2=FE_OFN1753_FE_DBTN71_n4217
XU5753 AO12 $PINS O=n5379 A1=n1653 B1=backward_sum[2][2][8]
+ B2=FE_OFN1685_FE_DBTN85_n987
XU5754 AOI22S $PINS O=n1213 A1=backward_sum[6][2][8] A2=FE_OFN1410_n1441
+ B1=backward_sum[5][2][8] B2=FE_OFN1544_n1442
XU5755 AOI22S $PINS O=n1214 A1=backward_sum[4][2][8] A2=FE_OFN1902_n5509
+ B1=backward_sum[3][2][8] B2=FE_OFN1749_FE_DBTN71_n4217
XU5756 AO12 $PINS O=n5380 A1=n1656 B1=backward_sum[2][2][7]
+ B2=FE_OFN1694_FE_DBTN85_n987
XU5757 AO12 $PINS O=n1209 A1=n5380 B1=backward_sum[1][2][7]
+ B2=FE_OFN5655_FE_OFN1628_FE_DBTN86_n985
XU5758 AOI22S $PINS O=n1210 A1=backward_sum[6][2][7] A2=FE_OFN1420_n1441
+ B1=backward_sum[5][2][7] B2=FE_OFN1556_n1442
XU5759 AOI22S $PINS O=n1211 A1=backward_sum[4][2][7] A2=FE_OFN1908_n5509
+ B1=backward_sum[3][2][7] B2=FE_OFN2194_n4217
XU5760 AO12 $PINS O=n5381 A1=n1646 B1=backward_sum[2][2][6]
+ B2=FE_OFN1697_FE_DBTN85_n987
XU5761 AO12 $PINS O=n1206 A1=n5381 B1=backward_sum[1][2][6]
+ B2=FE_OFN1645_FE_DBTN86_n985
XU5762 AOI22S $PINS O=n1207 A1=backward_sum[6][2][6] A2=FE_OFN1424_n1441
+ B1=backward_sum[5][2][6] B2=FE_OFN1560_n1442
XU5763 AOI22S $PINS O=n1208 A1=backward_sum[4][2][6] A2=FE_OFN1916_n5509
+ B1=backward_sum[3][2][6] B2=FE_OFN2196_n4217
XU5764 AO12 $PINS O=n5382 A1=n1651 B1=backward_sum[2][2][5] B2=FE_OFN5565_n
XU5765 AO12 $PINS O=n1203 A1=n5382 B1=backward_sum[1][2][5]
+ B2=FE_OFN1639_FE_DBTN86_n985
XU5766 AOI22S $PINS O=n1204 A1=backward_sum[6][2][5] A2=FE_OFN1423_n1441
+ B1=backward_sum[5][2][5] B2=FE_OFN1561_n1442
XU5767 AOI22S $PINS O=n1205 A1=backward_sum[4][2][5] A2=FE_OFN1898_n5509
+ B1=backward_sum[3][2][5] B2=FE_OFN2197_n4217
XU5768 AO12 $PINS O=n5383 A1=n1652 B1=backward_sum[2][2][4]
+ B2=FE_OFN1688_FE_DBTN85_n987
XU5769 AO12 $PINS O=n1200 A1=n5383 B1=backward_sum[1][2][4]
+ B2=FE_OFN1622_FE_DBTN86_n985
XU5770 AOI22S $PINS O=n1201 A1=backward_sum[6][2][4] A2=FE_OFN1422_n1441
+ B1=backward_sum[5][2][4] B2=FE_OFN1555_n1442
XU5771 AOI22S $PINS O=n1202 A1=backward_sum[4][2][4] A2=FE_OFN1905_n5509
+ B1=backward_sum[3][2][4] B2=FE_OFN1752_FE_DBTN71_n4217
XU5772 AO12 $PINS O=n5384 A1=n1644 B1=backward_sum[2][2][3]
+ B2=FE_OFN1669_FE_DBTN85_n987
XU5773 AO12 $PINS O=n1197 A1=n5384 B1=backward_sum[1][2][3]
+ B2=FE_OFN1626_FE_DBTN86_n985
XU5774 AOI22S $PINS O=n1198 A1=backward_sum[6][2][3] A2=FE_OFN1421_n1441
+ B1=backward_sum[5][2][3] B2=FE_OFN1539_n1442
XU5775 AOI22S $PINS O=n1199 A1=backward_sum[4][2][3] A2=FE_OFN1866_n5509
+ B1=backward_sum[3][2][3] B2=FE_OFN1756_FE_DBTN71_n4217
XU5776 AO12 $PINS O=n5385 A1=n1645 B1=backward_sum[2][2][2]
+ B2=FE_OFN1669_FE_DBTN85_n987
XU5777 AO12 $PINS O=n1194 A1=n5385 B1=backward_sum[1][2][2] B2=FE_OFN5534_n
XU5778 AOI22S $PINS O=n1195 A1=backward_sum[6][2][2] A2=FE_OFN1407_n1441
+ B1=backward_sum[5][2][2] B2=FE_OFN1531_n1442
XU5779 AOI22S $PINS O=n1196 A1=backward_sum[4][2][2]
+ A2=FE_OFN5594_FE_OFN1915_n5509 B1=backward_sum[3][2][2]
+ B2=FE_OFN1741_FE_DBTN71_n4217
XU5780 AO12 $PINS O=n5387 A1=n7 B1=backward_sum[2][3][11]
+ B2=FE_OFN1696_FE_DBTN85_n987
XU5781 AO12 $PINS O=n1185 A1=n5387 B1=backward_sum[1][3][11]
+ B2=FE_OFN1598_FE_DBTN86_n985
XU5782 AOI22S $PINS O=n1186 A1=backward_sum[6][3][11] A2=FE_OFN1367_n1441
+ B1=backward_sum[5][3][11] B2=FE_OFN1484_n1442
XU5783 AOI22S $PINS O=n1187 A1=backward_sum[4][3][11] A2=FE_OFN1857_n5509
+ B1=backward_sum[3][3][11] B2=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217
XU5784 AO12 $PINS O=n5388 A1=n1660 B1=backward_sum[2][3][10]
+ B2=FE_OFN1696_FE_DBTN85_n987
XU5785 AO12 $PINS O=n1182 A1=n5388 B1=backward_sum[1][3][10]
+ B2=FE_OFN1605_FE_DBTN86_n985
XU5786 AOI22S $PINS O=n1183 A1=backward_sum[6][3][10] A2=FE_OFN1367_n1441
+ B1=backward_sum[5][3][10] B2=FE_OFN1484_n1442
XU5787 AOI22S $PINS O=n1184 A1=backward_sum[4][3][10] A2=FE_OFN1857_n5509
+ B1=backward_sum[3][3][10] B2=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217
XU5788 AO12 $PINS O=n5389 A1=n1654 B1=backward_sum[2][3][9]
+ B2=FE_OFN1678_FE_DBTN85_n987
XU5789 AO12 $PINS O=n1179 A1=n5389 B1=backward_sum[1][3][9] B2=FE_OFN5678_n
XU5790 AOI22S $PINS O=n1180 A1=backward_sum[6][3][9] A2=FE_OFN1370_n1441
+ B1=backward_sum[5][3][9] B2=FE_OFN1490_n1442
XU5791 AOI22S $PINS O=n1181 A1=backward_sum[4][3][9] A2=FE_OFN5566_n
+ B1=backward_sum[3][3][9] B2=FE_OFN1720_FE_DBTN71_n4217
XU5792 AO12 $PINS O=n5390 A1=n1655 B1=backward_sum[2][3][8]
+ B2=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987
XU5793 AO12 $PINS O=n1176 A1=n5390 B1=backward_sum[1][3][8] B2=FE_OFN5678_n
XU5794 AOI22S $PINS O=n1177 A1=backward_sum[6][3][8] A2=FE_OFN1377_n1441
+ B1=backward_sum[5][3][8] B2=FE_OFN1497_n1442
XU5795 AOI22S $PINS O=n1178 A1=backward_sum[4][3][8] A2=FE_OFN1870_n5509
+ B1=backward_sum[3][3][8] B2=FE_OFN1715_FE_DBTN71_n4217
XU5796 AO12 $PINS O=n5391 A1=n1649 B1=backward_sum[2][3][7]
+ B2=FE_OFN1671_FE_DBTN85_n987
XU5797 AO12 $PINS O=n1173 A1=n5391 B1=backward_sum[1][3][7]
+ B2=FE_OFN1636_FE_DBTN86_n985
XU5798 AOI22S $PINS O=n1174 A1=backward_sum[6][3][7] A2=FE_OFN1385_n1441
+ B1=backward_sum[5][3][7] B2=FE_OFN1512_n1442
XU5799 AOI22S $PINS O=n1175 A1=backward_sum[4][3][7]
+ A2=FE_OFN5616_FE_OFN1882_n5509 B1=backward_sum[3][3][7]
+ B2=FE_OFN1727_FE_DBTN71_n4217
XU5800 AO12 $PINS O=n5392 A1=n1650 B1=backward_sum[2][3][6]
+ B2=FE_OFN1683_FE_DBTN85_n987
XU5801 AO12 $PINS O=n1170 A1=n5392 B1=backward_sum[1][3][6]
+ B2=FE_OFN1607_FE_DBTN86_n985
XU5802 AOI22S $PINS O=n1171 A1=backward_sum[6][3][6] A2=FE_OFN1396_n1441
+ B1=backward_sum[5][3][6] B2=FE_OFN1520_n1442
XU5803 AOI22S $PINS O=n1172 A1=backward_sum[4][3][6]
+ A2=FE_OFN5634_FE_OFN1892_n5509 B1=backward_sum[3][3][6]
+ B2=FE_OFN1738_FE_DBTN71_n4217
XU5804 AO12 $PINS O=n5393 A1=n1647 B1=backward_sum[2][3][5]
+ B2=FE_OFN1689_FE_DBTN85_n987
XU5805 AO12 $PINS O=n1167 A1=n5393 B1=backward_sum[1][3][5] B2=FE_OFN5672_n
XU5806 AOI22S $PINS O=n1168 A1=backward_sum[6][3][5] A2=FE_OFN1398_n1441
+ B1=backward_sum[5][3][5] B2=FE_OFN5544_n
XU5807 AOI22S $PINS O=n1169 A1=backward_sum[4][3][5] A2=FE_OFN1892_n5509
+ B1=backward_sum[3][3][5] B2=FE_OFN1746_FE_DBTN71_n4217
XU5808 AO12 $PINS O=n5394 A1=n1657 B1=backward_sum[2][3][4]
+ B2=FE_OFN5636_FE_OFN1664_FE_DBTN85_n987
XU5809 AO12 $PINS O=n1164 A1=n5394 B1=backward_sum[1][3][4]
+ B2=FE_OFN1610_FE_DBTN86_n985
XU5810 AOI22S $PINS O=n1165 A1=backward_sum[6][3][4] A2=FE_OFN1398_n1441
+ B1=backward_sum[5][3][4] B2=FE_OFN1522_n1442
XU5811 AOI22S $PINS O=n1166 A1=backward_sum[4][3][4] A2=FE_OFN1884_n5509
+ B1=backward_sum[3][3][4] B2=FE_OFN1726_FE_DBTN71_n4217
XU5812 AO12 $PINS O=n5395 A1=n1562 B1=backward_sum[2][3][3]
+ B2=FE_OFN5635_FE_OFN1664_FE_DBTN85_n987
XU5813 AO12 $PINS O=n1161 A1=n5395 B1=backward_sum[1][3][3]
+ B2=FE_OFN1611_FE_DBTN86_n985
XU5814 AOI22S $PINS O=n1162 A1=backward_sum[6][3][3] A2=FE_OFN1386_n1441
+ B1=backward_sum[5][3][3] B2=FE_OFN1511_n1442
XU5815 AOI22S $PINS O=n1163 A1=backward_sum[4][3][3] A2=FE_OFN5510_n
+ B1=backward_sum[3][3][3] B2=FE_OFN1729_FE_DBTN71_n4217
XU5816 AO12 $PINS O=n5396 A1=n1648 B1=backward_sum[2][3][2]
+ B2=FE_OFN1663_FE_DBTN85_n987
XU5817 AO12 $PINS O=n1158 A1=n5396 B1=backward_sum[1][3][2]
+ B2=FE_OFN1630_FE_DBTN86_n985
XU5818 AOI22S $PINS O=n1159 A1=backward_sum[6][3][2]
+ A2=FE_OFN5581_FE_OFN1388_n1441 B1=backward_sum[5][3][2] B2=FE_OFN1519_n1442
XU5819 AOI22S $PINS O=n1160 A1=backward_sum[4][3][2] A2=FE_OFN1906_n5509
+ B1=backward_sum[3][3][2] B2=FE_OFN1719_FE_DBTN71_n4217
XU5820 AO222 $PINS O=n1149 A1=backward_sum[2][4][11]
+ A2=FE_OFN1705_FE_DBTN85_n987 B1=n5397 B2=FE_OFN1801_n5419
+ C1=backward_sum[1][4][11] C2=FE_OFN1615_FE_DBTN86_n985
XU5821 AOI22S $PINS O=n1150 A1=backward_sum[6][4][11] A2=FE_OFN1402_n1441
+ B1=backward_sum[5][4][11] B2=FE_OFN1523_n1442
XU5822 AOI22S $PINS O=n1151 A1=backward_sum[4][4][11] A2=FE_OFN1864_n5509
+ B1=backward_sum[3][4][11] B2=FE_OFN1743_FE_DBTN71_n4217
XU5823 AO222S $PINS O=n1146 A1=backward_sum[2][4][10]
+ A2=FE_OFN1704_FE_DBTN85_n987 B1=FE_OFN1796_n5419 B2=n5398
+ C1=backward_sum[1][4][10] C2=FE_OFN1615_FE_DBTN86_n985
XU5824 AOI22S $PINS O=n1147 A1=backward_sum[6][4][10] A2=FE_OFN1401_n1441
+ B1=backward_sum[5][4][10] B2=FE_OFN1523_n1442
XU5825 AOI22S $PINS O=n1148 A1=backward_sum[4][4][10] A2=FE_OFN1864_n5509
+ B1=backward_sum[3][4][10] B2=FE_OFN1743_FE_DBTN71_n4217
XU5826 AO12 $PINS O=n5399 A1=n1580 B1=backward_sum[2][4][9]
+ B2=FE_OFN5645_FE_OFN1690_FE_DBTN85_n987
XU5827 AO12 $PINS O=n1143 A1=n5399 B1=backward_sum[1][4][9]
+ B2=FE_OFN1618_FE_DBTN86_n985
XU5828 AOI22S $PINS O=n1144 A1=backward_sum[6][4][9] A2=FE_OFN1382_n1441
+ B1=backward_sum[5][4][9] B2=FE_OFN1528_n1442
XU5829 AOI22S $PINS O=n1145 A1=backward_sum[4][4][9] A2=FE_OFN1886_n5509
+ B1=backward_sum[3][4][9] B2=FE_OFN1753_FE_DBTN71_n4217
XU5830 AO12 $PINS O=n5400 A1=n1581 B1=backward_sum[2][4][8]
+ B2=FE_OFN1691_FE_DBTN85_n987
XU5831 AO12 $PINS O=n1140 A1=n5400 B1=backward_sum[1][4][8]
+ B2=FE_OFN1629_FE_DBTN86_n985
XU5832 AOI22S $PINS O=n1141 A1=backward_sum[6][4][8] A2=FE_OFN1410_n1441
+ B1=backward_sum[5][4][8] B2=FE_OFN1544_n1442
XU5833 AOI22S $PINS O=n1142 A1=backward_sum[4][4][8] A2=FE_OFN1902_n5509
+ B1=backward_sum[3][4][8] B2=FE_OFN1749_FE_DBTN71_n4217
XU5834 AO12 $PINS O=n5401 A1=n1579 B1=backward_sum[2][4][7]
+ B2=FE_OFN1698_FE_DBTN85_n987
XU5835 AO12 $PINS O=n1137 A1=n5401 B1=backward_sum[1][4][7]
+ B2=FE_OFN5655_FE_OFN1628_FE_DBTN86_n985
XU5836 AOI22S $PINS O=n1138 A1=backward_sum[6][4][7] A2=FE_OFN1420_n1441
+ B1=backward_sum[5][4][7] B2=FE_OFN1556_n1442
XU5837 AOI22S $PINS O=n1139 A1=backward_sum[4][4][7] A2=FE_OFN1908_n5509
+ B1=backward_sum[3][4][7] B2=FE_OFN2194_n4217
XU5838 AO12 $PINS O=n5402 A1=n1573 B1=backward_sum[2][4][6]
+ B2=FE_OFN1697_FE_DBTN85_n987
XU5839 AO12 $PINS O=n1134 A1=n5402 B1=backward_sum[1][4][6] B2=FE_OFN5677_n
XU5840 AOI22S $PINS O=n1135 A1=backward_sum[6][4][6] A2=FE_OFN1424_n1441
+ B1=backward_sum[5][4][6] B2=FE_OFN1560_n1442
XU5841 AOI22S $PINS O=n1136 A1=backward_sum[4][4][6] A2=FE_OFN1914_n5509
+ B1=backward_sum[3][4][6] B2=FE_OFN2196_n4217
XU5842 AO12 $PINS O=n5403 A1=n1566 B1=backward_sum[2][4][5] B2=FE_OFN5565_n
XU5843 AO12 $PINS O=n1131 A1=n5403 B1=backward_sum[1][4][5]
+ B2=FE_OFN1639_FE_DBTN86_n985
XU5844 AOI22S $PINS O=n1132 A1=backward_sum[6][4][5] A2=FE_OFN1423_n1441
+ B1=backward_sum[5][4][5] B2=FE_OFN1561_n1442
XU5845 AOI22S $PINS O=n1133 A1=backward_sum[4][4][5] A2=FE_OFN1898_n5509
+ B1=backward_sum[3][4][5] B2=FE_OFN2197_n4217
XU5846 AO12 $PINS O=n5404 A1=n1567 B1=backward_sum[2][4][4]
+ B2=FE_OFN1688_FE_DBTN85_n987
XU5847 AO12 $PINS O=n1128 A1=n5404 B1=backward_sum[1][4][4]
+ B2=FE_OFN5598_FE_OFN1622_FE_DBTN86_n985
XU5848 AOI22S $PINS O=n1129 A1=backward_sum[6][4][4] A2=FE_OFN1422_n1441
+ B1=backward_sum[5][4][4] B2=FE_OFN1555_n1442
XU5849 AOI22S $PINS O=n1130 A1=backward_sum[4][4][4] A2=FE_OFN1910_n5509
+ B1=backward_sum[3][4][4] B2=FE_OFN1752_FE_DBTN71_n4217
XU5850 AO12 $PINS O=n5405 A1=n1568 B1=backward_sum[2][4][3]
+ B2=FE_OFN1681_FE_DBTN85_n987
XU5851 AO12 $PINS O=n1125 A1=n5405 B1=backward_sum[1][4][3]
+ B2=FE_OFN1626_FE_DBTN86_n985
XU5852 AOI22S $PINS O=n1126 A1=backward_sum[6][4][3] A2=FE_OFN1421_n1441
+ B1=backward_sum[5][4][3] B2=FE_OFN1539_n1442
XU5853 AOI22S $PINS O=n1127 A1=backward_sum[4][4][3] A2=FE_OFN1866_n5509
+ B1=backward_sum[3][4][3] B2=FE_OFN1752_FE_DBTN71_n4217
XU5854 AO12 $PINS O=n5406 A1=n1565 B1=backward_sum[2][4][2]
+ B2=FE_OFN1680_FE_DBTN85_n987
XU5855 AO12 $PINS O=n1122 A1=n5406 B1=backward_sum[1][4][2] B2=FE_OFN5534_n
XU5856 AOI22S $PINS O=n1123 A1=backward_sum[6][4][2] A2=FE_OFN1406_n1441
+ B1=backward_sum[5][4][2] B2=FE_OFN1531_n1442
XU5857 AOI22S $PINS O=n1124 A1=backward_sum[4][4][2] A2=FE_OFN1918_n5509
+ B1=backward_sum[3][4][2] B2=FE_OFN1740_FE_DBTN71_n4217
XU5858 AO12 $PINS O=n5407 A1=n6 B1=backward_sum[2][5][11] B2=FE_OFN5665_n
XU5859 AO12 $PINS O=n1113 A1=n5407 B1=backward_sum[1][5][11]
+ B2=FE_OFN1605_FE_DBTN86_n985
XU5860 AOI22S $PINS O=n1114 A1=backward_sum[6][5][11] A2=FE_OFN1367_n1441
+ B1=backward_sum[5][5][11] B2=FE_OFN1487_n1442
XU5861 AOI22S $PINS O=n1115 A1=backward_sum[4][5][11] A2=FE_OFN1846_n5509
+ B1=backward_sum[3][5][11] B2=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217
XU5862 AO12 $PINS O=n5408 A1=n1659 B1=backward_sum[2][5][10]
+ B2=FE_OFN1696_FE_DBTN85_n987
XU5863 AO12 $PINS O=n1110 A1=n5408 B1=backward_sum[1][5][10]
+ B2=FE_OFN1605_FE_DBTN86_n985
XU5864 AOI22S $PINS O=n1111 A1=backward_sum[6][5][10] A2=FE_OFN1367_n1441
+ B1=backward_sum[5][5][10] B2=FE_OFN1487_n1442
XU5865 AOI22S $PINS O=n1112 A1=backward_sum[4][5][10] A2=FE_OFN1854_n5509
+ B1=backward_sum[3][5][10] B2=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217
XU5866 AO12 $PINS O=n5409 A1=n1577 B1=backward_sum[2][5][9]
+ B2=FE_OFN1678_FE_DBTN85_n987
XU5867 AO12 $PINS O=n1107 A1=n5409 B1=backward_sum[1][5][9]
+ B2=FE_OFN5623_FE_OFN1634_FE_DBTN86_n985
XU5868 AOI22S $PINS O=n1108 A1=backward_sum[6][5][9] A2=FE_OFN1369_n1441
+ B1=backward_sum[5][5][9] B2=FE_OFN1485_n1442
XU5869 AOI22S $PINS O=n1109 A1=backward_sum[4][5][9] A2=FE_OFN1856_n5509
+ B1=backward_sum[3][5][9] B2=FE_OFN1720_FE_DBTN71_n4217
XU5870 AO12 $PINS O=n5410 A1=n1578 B1=backward_sum[2][5][8]
+ B2=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987
XU5871 AO12 $PINS O=n1104 A1=n5410 B1=backward_sum[1][5][8]
+ B2=FE_OFN1600_FE_DBTN86_n985
XU5872 AOI22S $PINS O=n1105 A1=backward_sum[6][5][8] A2=FE_OFN1369_n1441
+ B1=backward_sum[5][5][8] B2=FE_OFN1492_n1442
XU5873 AOI22S $PINS O=n1106 A1=backward_sum[4][5][8] A2=FE_OFN1872_n5509
+ B1=backward_sum[3][5][8] B2=FE_OFN1715_FE_DBTN71_n4217
XU5874 AO12 $PINS O=n5411 A1=n1575 B1=backward_sum[2][5][7]
+ B2=FE_OFN1671_FE_DBTN85_n987
XU5875 AO12 $PINS O=n1101 A1=n5411 B1=backward_sum[1][5][7]
+ B2=FE_OFN1636_FE_DBTN86_n985
XU5876 AOI22S $PINS O=n1102 A1=backward_sum[6][5][7] A2=FE_OFN1385_n1441
+ B1=backward_sum[5][5][7] B2=FE_OFN1498_n1442
XU5877 AOI22S $PINS O=n1103 A1=backward_sum[4][5][7] A2=FE_OFN1882_n5509
+ B1=backward_sum[3][5][7] B2=FE_DBTN71_n4217
XU5878 AO12 $PINS O=n5412 A1=n1582 B1=backward_sum[2][5][6]
+ B2=FE_OFN1683_FE_DBTN85_n987
XU5879 AO12 $PINS O=n1098 A1=n5412 B1=backward_sum[1][5][6]
+ B2=FE_OFN1607_FE_DBTN86_n985
XU5880 AOI22S $PINS O=n1099 A1=backward_sum[6][5][6] A2=FE_OFN1385_n1441
+ B1=backward_sum[5][5][6] B2=FE_OFN5545_n
XU5881 AOI22S $PINS O=n1100 A1=backward_sum[4][5][6] A2=FE_OFN1892_n5509
+ B1=backward_sum[3][5][6] B2=FE_OFN1746_FE_DBTN71_n4217
XU5882 AO12 $PINS O=n5413 A1=n1574 B1=backward_sum[2][5][5]
+ B2=FE_OFN1689_FE_DBTN85_n987
XU5883 AO12 $PINS O=n1095 A1=n5413 B1=backward_sum[1][5][5] B2=FE_OFN5672_n
XU5884 AOI22S $PINS O=n1096 A1=backward_sum[6][5][5] A2=FE_OFN1384_n1441
+ B1=backward_sum[5][5][5] B2=FE_OFN5545_n
XU5885 AOI22S $PINS O=n1097 A1=backward_sum[4][5][5] A2=FE_OFN1892_n5509
+ B1=backward_sum[3][5][5] B2=FE_OFN1746_FE_DBTN71_n4217
XU5886 AO12 $PINS O=n5414 A1=n1583 B1=backward_sum[2][5][4]
+ B2=FE_OFN5636_FE_OFN1664_FE_DBTN85_n987
XU5887 AO12 $PINS O=n1092 A1=n5414 B1=backward_sum[1][5][4] B2=FE_OFN5550_n
XU5888 AOI22S $PINS O=n1093 A1=backward_sum[6][5][4] A2=FE_OFN1384_n1441
+ B1=backward_sum[5][5][4] B2=FE_OFN1506_n1442
XU5889 AOI22S $PINS O=n1094 A1=backward_sum[4][5][4] A2=FE_OFN1874_n5509
+ B1=backward_sum[3][5][4] B2=FE_OFN1726_FE_DBTN71_n4217
XU5890 AO12 $PINS O=n5415 A1=n1561 B1=backward_sum[2][5][3]
+ B2=FE_OFN5635_FE_OFN1664_FE_DBTN85_n987
XU5891 AO12 $PINS O=n1089 A1=n5415 B1=backward_sum[1][5][3]
+ B2=FE_OFN5625_FE_OFN1634_FE_DBTN86_n985
XU5892 AOI22S $PINS O=n1090 A1=backward_sum[6][5][3] A2=FE_OFN5551_n
+ B1=backward_sum[5][5][3] B2=FE_OFN1503_n1442
XU5893 AOI22S $PINS O=n1091 A1=backward_sum[4][5][3] A2=FE_OFN1888_n5509
+ B1=backward_sum[3][5][3] B2=FE_OFN1729_FE_DBTN71_n4217
XU5894 AO12 $PINS O=n5416 A1=n1576 B1=backward_sum[2][5][2]
+ B2=FE_OFN1663_FE_DBTN85_n987
XU5895 AO12 $PINS O=n1086 A1=n5416 B1=backward_sum[1][5][2]
+ B2=FE_OFN1630_FE_DBTN86_n985
XU5896 AOI22S $PINS O=n1087 A1=backward_sum[6][5][2]
+ A2=FE_OFN5581_FE_OFN1388_n1441 B1=backward_sum[5][5][2] B2=FE_OFN1517_n1442
XU5897 AOI22S $PINS O=n1088 A1=backward_sum[4][5][2] A2=FE_OFN1883_n5509
+ B1=backward_sum[3][5][2] B2=FE_OFN1719_FE_DBTN71_n4217
XU5898 AO222 $PINS O=n1077 A1=backward_sum[2][6][11]
+ A2=FE_OFN1705_FE_DBTN85_n987 B1=n5417 B2=FE_OFN1801_n5419
+ C1=backward_sum[1][6][11] C2=FE_OFN1615_FE_DBTN86_n985
XU5899 AOI22S $PINS O=n1078 A1=backward_sum[6][6][11] A2=FE_OFN1402_n1441
+ B1=backward_sum[5][6][11] B2=FE_OFN1523_n1442
XU5900 AOI22S $PINS O=n1079 A1=backward_sum[4][6][11] A2=FE_OFN1864_n5509
+ B1=backward_sum[3][6][11] B2=FE_OFN1743_FE_DBTN71_n4217
XU5901 AO222S $PINS O=n1074 A1=backward_sum[2][6][10]
+ A2=FE_OFN1704_FE_DBTN85_n987 B1=FE_OFN1801_n5419 B2=n5418
+ C1=backward_sum[1][6][10] C2=FE_OFN1615_FE_DBTN86_n985
XU5902 AOI22S $PINS O=n1075 A1=backward_sum[6][6][10] A2=FE_OFN1401_n1441
+ B1=backward_sum[5][6][10] B2=FE_OFN1523_n1442
XU5903 AOI22S $PINS O=n1076 A1=backward_sum[4][6][10] A2=FE_OFN1867_n5509
+ B1=backward_sum[3][6][10] B2=FE_OFN1747_FE_DBTN71_n4217
XU5904 AO12 $PINS O=n5420 A1=n1658 B1=backward_sum[2][6][9]
+ B2=FE_OFN5645_FE_OFN1690_FE_DBTN85_n987
XU5905 AO12 $PINS O=n1071 A1=n5420 B1=backward_sum[1][6][9]
+ B2=FE_OFN1618_FE_DBTN86_n985
XU5906 AOI22S $PINS O=n1072 A1=backward_sum[6][6][9] A2=FE_OFN1382_n1441
+ B1=backward_sum[5][6][9] B2=FE_OFN1528_n1442
XU5907 AOI22S $PINS O=n1073 A1=backward_sum[4][6][9] A2=FE_OFN1886_n5509
+ B1=backward_sum[3][6][9] B2=FE_OFN1753_FE_DBTN71_n4217
XU5908 AO12 $PINS O=n5421 A1=n1653 B1=backward_sum[2][6][8]
+ B2=FE_OFN1685_FE_DBTN85_n987
XU5909 AO12 $PINS O=n1068 A1=n5421 B1=backward_sum[1][6][8]
+ B2=FE_OFN1629_FE_DBTN86_n985
XU5910 AOI22S $PINS O=n1069 A1=backward_sum[6][6][8] A2=FE_OFN1410_n1441
+ B1=backward_sum[5][6][8] B2=FE_OFN1544_n1442
XU5911 AOI22S $PINS O=n1070 A1=backward_sum[4][6][8] A2=FE_OFN1902_n5509
+ B1=backward_sum[3][6][8] B2=FE_OFN1749_FE_DBTN71_n4217
XU5912 AO12 $PINS O=n5422 A1=n1656 B1=backward_sum[2][6][7]
+ B2=FE_OFN1698_FE_DBTN85_n987
XU5913 AO12 $PINS O=n1065 A1=n5422 B1=backward_sum[1][6][7]
+ B2=FE_OFN5655_FE_OFN1628_FE_DBTN86_n985
XU5914 AOI22S $PINS O=n1066 A1=backward_sum[6][6][7] A2=FE_OFN1420_n1441
+ B1=backward_sum[5][6][7] B2=FE_OFN1556_n1442
XU5915 AOI22S $PINS O=n1067 A1=backward_sum[4][6][7] A2=FE_OFN1908_n5509
+ B1=backward_sum[3][6][7] B2=FE_OFN2194_n4217
XU5916 AO12 $PINS O=n5423 A1=n1646 B1=backward_sum[2][6][6]
+ B2=FE_OFN1697_FE_DBTN85_n987
XU5917 AO12 $PINS O=n1062 A1=n5423 B1=backward_sum[1][6][6] B2=FE_OFN5677_n
XU5918 AOI22S $PINS O=n1063 A1=backward_sum[6][6][6] A2=FE_OFN1424_n1441
+ B1=backward_sum[5][6][6] B2=FE_OFN1560_n1442
XU5919 AOI22S $PINS O=n1064 A1=backward_sum[4][6][6] A2=FE_OFN1914_n5509
+ B1=backward_sum[3][6][6] B2=FE_OFN2196_n4217
XU5920 AO12 $PINS O=n5424 A1=n1651 B1=backward_sum[2][6][5] B2=FE_OFN5565_n
XU5921 AO12 $PINS O=n1059 A1=n5424 B1=backward_sum[1][6][5]
+ B2=FE_OFN1639_FE_DBTN86_n985
XU5922 AOI22S $PINS O=n1060 A1=backward_sum[6][6][5] A2=FE_OFN1423_n1441
+ B1=backward_sum[5][6][5] B2=FE_OFN1561_n1442
XU5923 AOI22S $PINS O=n1061 A1=backward_sum[4][6][5] A2=FE_OFN1898_n5509
+ B1=backward_sum[3][6][5] B2=FE_OFN2197_n4217
XU5924 AO12 $PINS O=n5425 A1=n1652 B1=backward_sum[2][6][4]
+ B2=FE_OFN1688_FE_DBTN85_n987
XU5925 AO12 $PINS O=n1056 A1=n5425 B1=backward_sum[1][6][4]
+ B2=FE_OFN1622_FE_DBTN86_n985
XU5926 AOI22S $PINS O=n1057 A1=backward_sum[6][6][4] A2=FE_OFN1422_n1441
+ B1=backward_sum[5][6][4] B2=FE_OFN1555_n1442
XU5927 AOI22S $PINS O=n1058 A1=backward_sum[4][6][4] A2=FE_OFN1866_n5509
+ B1=backward_sum[3][6][4] B2=FE_OFN1752_FE_DBTN71_n4217
XU5928 AO12 $PINS O=n5426 A1=n1644 B1=backward_sum[2][6][3]
+ B2=FE_OFN1669_FE_DBTN85_n987
XU5929 AO12 $PINS O=n1053 A1=n5426 B1=backward_sum[1][6][3]
+ B2=FE_OFN1624_FE_DBTN86_n985
XU5930 AOI22S $PINS O=n1054 A1=backward_sum[6][6][3] A2=FE_OFN1421_n1441
+ B1=backward_sum[5][6][3] B2=FE_OFN1539_n1442
XU5931 AOI22S $PINS O=n1055 A1=backward_sum[4][6][3] A2=FE_OFN1866_n5509
+ B1=backward_sum[3][6][3] B2=FE_OFN1752_FE_DBTN71_n4217
XU5932 AO12 $PINS O=n5427 A1=n1645 B1=backward_sum[2][6][2]
+ B2=FE_OFN1680_FE_DBTN85_n987
XU5933 AO12 $PINS O=n1050 A1=n5427 B1=backward_sum[1][6][2] B2=FE_OFN5534_n
XU5934 AOI22S $PINS O=n1051 A1=backward_sum[6][6][2] A2=FE_OFN1407_n1441
+ B1=backward_sum[5][6][2] B2=FE_OFN1531_n1442
XU5935 AOI22S $PINS O=n1052 A1=backward_sum[4][6][2]
+ A2=FE_OFN5594_FE_OFN1915_n5509 B1=backward_sum[3][6][2]
+ B2=FE_OFN1741_FE_DBTN71_n4217
XU5936 AO12 $PINS O=n5428 A1=n7 B1=backward_sum[2][7][11] B2=FE_OFN5665_n
XU5937 AO12 $PINS O=n1041 A1=n5428 B1=backward_sum[1][7][11]
+ B2=FE_OFN1598_FE_DBTN86_n985
XU5938 AOI22S $PINS O=n1042 A1=backward_sum[6][7][11] A2=FE_OFN1367_n1441
+ B1=backward_sum[5][7][11] B2=FE_OFN1487_n1442
XU5939 AOI22S $PINS O=n1043 A1=backward_sum[4][7][11] A2=FE_OFN1846_n5509
+ B1=backward_sum[3][7][11] B2=FE_OFN5617_FE_OFN1724_FE_DBTN71_n4217
XU5940 AO12 $PINS O=n5429 A1=n1660 B1=backward_sum[2][7][10] B2=FE_OFN5665_n
XU5941 AO12 $PINS O=n1038 A1=n5429 B1=backward_sum[1][7][10]
+ B2=FE_OFN1605_FE_DBTN86_n985
XU5942 AOI22S $PINS O=n1039 A1=backward_sum[6][7][10] A2=FE_OFN1364_n1441
+ B1=backward_sum[5][7][10] B2=FE_OFN1487_n1442
XU5943 AOI22S $PINS O=n1040 A1=backward_sum[4][7][10] A2=FE_OFN1846_n5509
+ B1=backward_sum[3][7][10] B2=FE_OFN1724_FE_DBTN71_n4217
XU5944 AO12 $PINS O=n5430 A1=n1654 B1=backward_sum[2][7][9]
+ B2=FE_OFN1678_FE_DBTN85_n987
XU5945 AO12 $PINS O=n1035 A1=n5430 B1=backward_sum[1][7][9] B2=FE_OFN5678_n
XU5946 AOI22S $PINS O=n1036 A1=backward_sum[6][7][9] A2=n1441
+ B1=backward_sum[5][7][9] B2=FE_OFN1485_n1442
XU5947 AOI22S $PINS O=n1037 A1=backward_sum[4][7][9] A2=FE_OFN5511_n
+ B1=backward_sum[3][7][9] B2=FE_OFN1706_FE_DBTN71_n4217
XU5948 AO12 $PINS O=n5431 A1=n1655 B1=backward_sum[2][7][8]
+ B2=FE_OFN5620_FE_OFN1672_FE_DBTN85_n987
XU5949 AO12 $PINS O=n1032 A1=n5431 B1=backward_sum[1][7][8] B2=FE_OFN5678_n
XU5950 AOI22S $PINS O=n1033 A1=backward_sum[6][7][8] A2=FE_OFN1371_n1441
+ B1=backward_sum[5][7][8] B2=FE_OFN1489_n1442
XU5951 AOI22S $PINS O=n1034 A1=backward_sum[4][7][8] A2=FE_OFN5511_n
+ B1=backward_sum[3][7][8] B2=FE_OFN1715_FE_DBTN71_n4217
XU5952 AO12 $PINS O=n5432 A1=n1649 B1=backward_sum[2][7][7]
+ B2=FE_OFN1671_FE_DBTN85_n987
XU5953 AO12 $PINS O=n1029 A1=n5432 B1=backward_sum[1][7][7]
+ B2=FE_OFN1636_FE_DBTN86_n985
XU5954 AOI22S $PINS O=n1030 A1=backward_sum[6][7][7] A2=FE_OFN1369_n1441
+ B1=backward_sum[5][7][7] B2=FE_OFN1498_n1442
XU5955 AOI22S $PINS O=n1031 A1=backward_sum[4][7][7] A2=FE_OFN1861_n5509
+ B1=backward_sum[3][7][7] B2=FE_DBTN71_n4217
XU5956 AO12 $PINS O=n5433 A1=n1650 B1=backward_sum[2][7][6]
+ B2=FE_OFN1683_FE_DBTN85_n987
XU5957 AO12 $PINS O=n1026 A1=n5433 B1=backward_sum[1][7][6]
+ B2=FE_OFN1607_FE_DBTN86_n985
XU5958 AOI22S $PINS O=n1027 A1=backward_sum[6][7][6] A2=FE_OFN1384_n1441
+ B1=backward_sum[5][7][6] B2=FE_OFN5545_n
XU5959 AOI22S $PINS O=n1028 A1=backward_sum[4][7][6]
+ A2=FE_OFN5615_FE_OFN1882_n5509 B1=backward_sum[3][7][6]
+ B2=FE_OFN1736_FE_DBTN71_n4217
XU5960 AO12 $PINS O=n5434 A1=n1647 B1=backward_sum[2][7][5]
+ B2=FE_OFN1689_FE_DBTN85_n987
XU5961 AO12 $PINS O=n1023 A1=n5434 B1=backward_sum[1][7][5] B2=FE_OFN5672_n
XU5962 AOI22S $PINS O=n1024 A1=backward_sum[6][7][5] A2=FE_OFN1384_n1441
+ B1=backward_sum[5][7][5] B2=FE_OFN5545_n
XU5963 AOI22S $PINS O=n1025 A1=backward_sum[4][7][5]
+ A2=FE_OFN5615_FE_OFN1882_n5509 B1=backward_sum[3][7][5]
+ B2=FE_OFN1736_FE_DBTN71_n4217
XU5964 AO12 $PINS O=n5435 A1=n1657 B1=backward_sum[2][7][4]
+ B2=FE_OFN1664_FE_DBTN85_n987
XU5965 AOI22S $PINS O=n1021 A1=backward_sum[6][7][4] A2=FE_OFN1384_n1441
+ B1=backward_sum[5][7][4] B2=FE_OFN1506_n1442
XU5966 AOI22S $PINS O=n1022 A1=backward_sum[4][7][4] A2=FE_OFN1874_n5509
+ B1=backward_sum[3][7][4] B2=FE_OFN1726_FE_DBTN71_n4217
XU5967 AO12 $PINS O=n5436 A1=n1562 B1=backward_sum[2][7][3]
+ B2=FE_OFN5635_FE_OFN1664_FE_DBTN85_n987
XU5968 AOI22S $PINS O=n1018 A1=backward_sum[6][7][3] A2=FE_OFN5551_n
+ B1=backward_sum[5][7][3] B2=FE_OFN1503_n1442
XU5969 AOI22S $PINS O=n1019 A1=backward_sum[4][7][3] A2=FE_OFN1888_n5509
+ B1=backward_sum[3][7][3] B2=FE_OFN1729_FE_DBTN71_n4217
XU5970 AO12 $PINS O=n5437 A1=n1648 B1=backward_sum[2][7][2]
+ B2=FE_OFN1663_FE_DBTN85_n987
XU5971 AOI22S $PINS O=n1015 A1=backward_sum[6][7][2]
+ A2=FE_OFN5581_FE_OFN1388_n1441 B1=backward_sum[5][7][2] B2=FE_OFN1517_n1442
XU5972 AOI22S $PINS O=n1016 A1=backward_sum[4][7][2] A2=FE_OFN1883_n5509
+ B1=backward_sum[3][7][2] B2=FE_OFN1734_FE_DBTN71_n4217
XU5975 AN2 $PINS O=add_1_root_sub_0_root_add_184/carry[1] I1=N689 I2=N358
XU5976 XOR2HS $PINS O=sub_0_root_sub_0_root_add_184/A[0] I1=FE_OFN2056_N689
+ I2=N358
XU5977 AN2 $PINS O=add_0_root_add_183_2/carry[1] I1=N358 I2=N810
XU5978 AN2 $PINS O=add_1_root_add_183_2/carry[1] I1=N689 I2=N339
XU5979 XOR2HS $PINS O=N810 I1=N339 I2=FE_OFN2056_N689
XU5980 OR2 $PINS O=sub_1_root_sub_182_3/carry[1] I1=n5512 I2=N689
XU5981 XNR2HS $PINS O=N694 I1=FE_OFN2056_N689 I2=n5512
XU5982 XOR2HS $PINS O=N692 I1=n5528 I2=sub_182/carry[3]
XU5983 AN2 $PINS O=sub_182/carry[3] I1=sub_182/carry[2] I2=n5527
XU5984 XOR2HS $PINS O=N691 I1=n5527 I2=sub_182/carry[2]
XU5985 AN2 $PINS O=sub_182/carry[2] I1=n5525 I2=n5526
XU5986 XOR2HS $PINS O=N690 I1=n5526 I2=n5525
XU5987 ND2 $PINS O=n5532 I1=N368 I2=n5486
XU5988 ND2 $PINS O=n5531 I1=N378 I2=n5461
XU5989 ND2 $PINS O=n5529 I1=N369 I2=n5487
XU5990 AN2 $PINS O=n5530 I1=N367 I2=n5483
XU5991 AN4B1S $PINS O=n5552 I1=n5532 I2=n5531 I3=n5529 B1=n5530
XU5992 AN2B1S $PINS O=n5535 I1=n5531 B1=n5530
XU5993 OR2B1S $PINS O=n5533 I1=N369 B1=n5532
XU5994 OAI222S $PINS O=n5534 A1=n5487 A2=n5533 B1=N368 B2=n5486 C1=N367
+ C2=n5483
XU5995 MOAI1S $PINS O=n5551 A1=N378 A2=n5461 B1=n5535 B2=n5534
XU5996 ND2 $PINS O=n5543 I1=N370 I2=n5490
XU5997 OA12 $PINS O=n5549 A1=n5543 B1=N383 B2=n5491
XU5998 MOAI1S $PINS O=n5536 A1=N389 A2=n5496 B1=n5497 B2=N376
XU5999 ND2 $PINS O=n5537 I1=N374 I2=n5498
XU6000 OAI112HS $PINS O=n5548 A1=n5536 B1=n5539 C1=N376 C2=n5497
XU6001 ND2 $PINS O=n5542 I1=N372 I2=n5499
XU6002 OAI12HS $PINS O=n5538 A1=n5537 B1=N387 B2=n5495
XU6003 ND2 $PINS O=n5540 I1=n5539 I2=n5538
XU6004 OA112 $PINS O=n5547 A1=n5542 B1=n5540 C1=N385 C2=n5494
XU6005 NR2 $PINS O=n5541 I1=N372 I2=n5499
XU6006 AOI13HS $PINS O=n5545 A1=n5541 B1=n5542 B2=n5494 B3=N385
XU6007 AOI22S $PINS O=n5546 A1=n5545 A2=n5544 B1=n5544 B2=n5553
XU6008 AO13S $PINS O=n5550 A1=n5546 B1=n5549 B2=n5548 B3=n5547
XU6009 ND2 $PINS O=n5557 I1=N392 I2=n5473
XU6010 ND2 $PINS O=n5556 I1=N402 I2=n5462
XU6011 ND2 $PINS O=n5554 I1=N393 I2=n5475
XU6012 AN2 $PINS O=n5555 I1=N391 I2=n5470
XU6013 AN4B1S $PINS O=n5577 I1=n5557 I2=n5556 I3=n5554 B1=n5555
XU6014 AN2B1S $PINS O=n5560 I1=n5556 B1=n5555
XU6015 OR2B1S $PINS O=n5558 I1=N393 B1=n5557
XU6016 OAI222S $PINS O=n5559 A1=n5475 A2=n5558 B1=N392 B2=n5473 C1=N391
+ C2=n5470
XU6017 MOAI1S $PINS O=n5576 A1=N402 A2=n5462 B1=n5560 B2=n5559
XU6018 ND2 $PINS O=n5568 I1=N394 I2=n5478
XU6019 OA12 $PINS O=n5574 A1=n5568 B1=N407 B2=n5480
XU6020 MOAI1S $PINS O=n5561 A1=N413 A2=n5492 B1=n5501 B2=N400
XU6021 ND2 $PINS O=n5562 I1=N398 I2=n5503
XU6022 OAI112HS $PINS O=n5573 A1=n5561 B1=n5564 C1=N400 C2=n5501
XU6023 ND2 $PINS O=n5567 I1=N396 I2=n5505
XU6024 OAI12HS $PINS O=n5563 A1=n5562 B1=N411 B2=n5488
XU6025 ND2 $PINS O=n5565 I1=n5564 I2=n5563
XU6026 OA112 $PINS O=n5572 A1=n5567 B1=n5565 C1=N409 C2=n5484
XU6027 NR2 $PINS O=n5566 I1=N396 I2=n5505
XU6028 AOI13HS $PINS O=n5570 A1=n5566 B1=n5567 B2=n5484 B3=N409
XU6029 AOI22S $PINS O=n5571 A1=n5570 A2=n5569 B1=n5569 B2=n5578
XU6030 AO13S $PINS O=n5575 A1=n5571 B1=n5574 B2=n5573 B3=n5572
XU6031 ND2 $PINS O=n5582 I1=N416 I2=n5474
XU6032 ND2 $PINS O=n5581 I1=N426 I2=n5469
XU6033 ND2 $PINS O=n5579 I1=N417 I2=n5477
XU6034 AN2 $PINS O=n5580 I1=N415 I2=n5472
XU6035 AN4B1S $PINS O=n5602 I1=n5582 I2=n5581 I3=n5579 B1=n5580
XU6036 AN2B1S $PINS O=n5585 I1=n5581 B1=n5580
XU6037 OR2B1S $PINS O=n5583 I1=N417 B1=n5582
XU6038 OAI222S $PINS O=n5584 A1=n5477 A2=n5583 B1=N416 B2=n5474 C1=N415
+ C2=n5472
XU6039 MOAI1S $PINS O=n5601 A1=N426 A2=n5469 B1=n5585 B2=n5584
XU6040 ND2 $PINS O=n5593 I1=N418 I2=n5479
XU6041 OA12 $PINS O=n5599 A1=n5593 B1=N431 B2=n5482
XU6042 MOAI1S $PINS O=n5586 A1=N437 A2=n5493 B1=n5500 B2=N424
XU6043 ND2 $PINS O=n5587 I1=N422 I2=n5502
XU6044 OAI112HS $PINS O=n5598 A1=n5586 B1=n5589 C1=N424 C2=n5500
XU6045 ND2 $PINS O=n5592 I1=N420 I2=n5504
XU6046 OAI12HS $PINS O=n5588 A1=n5587 B1=N435 B2=n5489
XU6047 ND2 $PINS O=n5590 I1=n5589 I2=n5588
XU6048 OA112 $PINS O=n5597 A1=n5592 B1=n5590 C1=N433 C2=n5485
XU6049 NR2 $PINS O=n5591 I1=N420 I2=n5504
XU6050 AOI13HS $PINS O=n5595 A1=n5591 B1=n5592 B2=n5485 B3=N433
XU6051 AOI22S $PINS O=n5596 A1=n5595 A2=n5594 B1=n5594 B2=n5603
XU6052 AO13S $PINS O=n5600 A1=n5596 B1=n5599 B2=n5598 B3=n5597
XU6053 ND2 $PINS O=n5607 I1=N440 I2=n5465
XU6054 ND2 $PINS O=n5606 I1=N450 I2=n5463
XU6055 ND2 $PINS O=n5604 I1=N441 I2=n5466
XU6056 AN2 $PINS O=n5605 I1=N439 I2=n5464
XU6057 AN4B1S $PINS O=n5627 I1=n5607 I2=n5606 I3=n5604 B1=n5605
XU6058 AN2B1S $PINS O=n5610 I1=n5606 B1=n5605
XU6059 OR2B1S $PINS O=n5608 I1=N441 B1=n5607
XU6060 OAI222S $PINS O=n5609 A1=n5466 A2=n5608 B1=N440 B2=n5465 C1=N439
+ C2=n5464
XU6061 MOAI1S $PINS O=n5626 A1=N450 A2=n5463 B1=n5610 B2=n5609
XU6062 ND2 $PINS O=n5618 I1=N442 I2=n5467
XU6063 OA12 $PINS O=n5624 A1=n5618 B1=N455 B2=n5468
XU6064 MOAI1S $PINS O=n5611 A1=N461 A2=n5481 B1=n5506 B2=N448
XU6065 ND2 $PINS O=n5612 I1=N446 I2=n5507
XU6066 OAI112HS $PINS O=n5623 A1=n5611 B1=n5614 C1=N448 C2=n5506
XU6067 ND2 $PINS O=n5617 I1=N444 I2=n5508
XU6068 OAI12HS $PINS O=n5613 A1=n5612 B1=N459 B2=n5476
XU6069 ND2 $PINS O=n5615 I1=n5614 I2=n5613
XU6070 OA112 $PINS O=n5622 A1=n5617 B1=n5615 C1=N457 C2=n5471
XU6071 NR2 $PINS O=n5616 I1=N444 I2=n5508
XU6072 AOI13HS $PINS O=n5620 A1=n5616 B1=n5617 B2=n5471 B3=N457
XU6073 AOI22S $PINS O=n5621 A1=n5620 A2=n5619 B1=n5619 B2=n5628
XU6074 AO13S $PINS O=n5625 A1=n5621 B1=n5624 B2=n5623 B3=n5622
XU6075 ND2 $PINS O=n5632 I1=N471 I2=n5459
XU6076 ND2 $PINS O=n5631 I1=N481 I2=n5442
XU6077 ND2 $PINS O=n5629 I1=N472 I2=n5458
XU6078 AN2 $PINS O=n5630 I1=N470 I2=n5460
XU6079 AN4B1S $PINS O=n5651 I1=n5632 I2=n5631 I3=n5629 B1=n5630
XU6080 AN2B1S $PINS O=n5635 I1=n5631 B1=n5630
XU6081 OR2B1S $PINS O=n5633 I1=N472 B1=n5632
XU6082 OAI222S $PINS O=n5634 A1=n5458 A2=n5633 B1=N471 B2=n5459 C1=N470
+ C2=n5460
XU6084 ND2 $PINS O=n5643 I1=N473 I2=n5457
XU6085 OA12 $PINS O=n5648 A1=n5643 B1=N486 B2=n5449
XU6086 MOAI1S $PINS O=n5636 A1=N492 A2=n5450 B1=n5451 B2=N479
XU6087 ND2 $PINS O=n5637 I1=N477 I2=n5453
XU6088 OAI112HS $PINS O=n5647 A1=n5636 B1=n5639 C1=N479 C2=n5451
XU6089 ND2 $PINS O=n5642 I1=N475 I2=n5455
XU6090 OAI12HS $PINS O=n5638 A1=n5637 B1=N490 B2=n5452
XU6091 ND2 $PINS O=n5640 I1=n5639 I2=n5638
XU6092 OA112 $PINS O=n5646 A1=n5642 B1=n5640 C1=N488 C2=n5454
XU6093 NR2 $PINS O=n5641 I1=N475 I2=n5455
XU6094 ND2 $PINS O=n5644 I1=n5643 I2=n5449
XU6095 AO13S $PINS O=n5649 A1=n5645 B1=n5648 B2=n5647 B3=n5646
XU6096 ND2 $PINS O=n5655 I1=N495 I2=n5684
XU6097 ND2S $PINS O=n5654 I1=N505 I2=n5678
XU6098 ND2 $PINS O=n5652 I1=N496 I2=n5683
XU6099 AN2 $PINS O=n5653 I1=N494 I2=n5685
XU6100 AN4B1S $PINS O=n5674 I1=n5655 I2=n5654 I3=n5652 B1=n5653
XU6101 AN2B1S $PINS O=n5658 I1=n5654 B1=n5653
XU6102 OR2B1S $PINS O=n5656 I1=N496 B1=n5655
XU6103 OAI222S $PINS O=n5657 A1=n5683 A2=n5656 B1=N495 B2=n5684 C1=N494
+ C2=n5685
XU6105 ND2 $PINS O=n5666 I1=N497 I2=n5682
XU6106 OA12 $PINS O=n5671 A1=n5666 B1=N510 B2=n5677
XU6107 MOAI1S $PINS O=n5659 A1=N516 A2=n5448 B1=n5446 B2=N503
XU6108 ND2 $PINS O=n5660 I1=N501 I2=n5679
XU6109 OAI112HS $PINS O=n5670 A1=n5659 B1=n5662 C1=N503 C2=n5446
XU6110 ND2 $PINS O=n5665 I1=N499 I2=n5680
XU6111 OAI12HS $PINS O=n5661 A1=n5660 B1=N514 B2=n5675
XU6112 ND2 $PINS O=n5663 I1=n5662 I2=n5661
XU6113 OA112 $PINS O=n5669 A1=n5665 B1=n5663 C1=N512 C2=n5676
XU6114 NR2 $PINS O=n5664 I1=N499 I2=n5680
XU6115 ND2 $PINS O=n5667 I1=n5666 I2=n5677
XU6116 AO13 $PINS O=n5672 A1=n5668 B1=n5671 B2=n5670 B3=n5669
XU6118 ND2 $PINS O=n5689 I1=N519 I2=n5718
XU6119 ND2P $PINS O=n5688 I1=N529 I2=n5712
XU6120 ND2 $PINS O=n5686 I1=N520 I2=n5717
XU6121 AN2 $PINS O=n5687 I1=N518 I2=n5719
XU6122 AN4B1S $PINS O=n5708 I1=n5689 I2=n5688 I3=n5686 B1=n5687
XU6123 AN2B1S $PINS O=n5692 I1=n5688 B1=n5687
XU6124 OR2B1S $PINS O=n5690 I1=N520 B1=n5689
XU6125 OAI222S $PINS O=n5691 A1=n5717 A2=n5690 B1=N519 B2=n5718 C1=N518
+ C2=n5719
XU6126 MOAI1S $PINS O=n5707 A1=N529 A2=n5712 B1=n5692 B2=n5691
XU6127 ND2 $PINS O=n5700 I1=N521 I2=n5716
XU6128 OA12 $PINS O=n5705 A1=n5700 B1=N534 B2=n5711
XU6129 MOAI1S $PINS O=n5693 A1=N540 A2=n5447 B1=n5443 B2=N527
XU6130 ND2 $PINS O=n5694 I1=N525 I2=n5713
XU6131 OAI112HS $PINS O=n5704 A1=n5693 B1=n5696 C1=N527 C2=n5443
XU6132 ND2 $PINS O=n5699 I1=N523 I2=n5714
XU6133 OAI12HS $PINS O=n5695 A1=n5694 B1=N538 B2=n5709
XU6134 ND2 $PINS O=n5697 I1=n5696 I2=n5695
XU6135 OA112 $PINS O=n5703 A1=n5699 B1=n5697 C1=N536 C2=n5710
XU6136 NR2 $PINS O=n5698 I1=N523 I2=n5714
XU6137 ND2 $PINS O=n5701 I1=n5700 I2=n5711
XU6138 AO13S $PINS O=n5706 A1=n5702 B1=n5705 B2=n5704 B3=n5703
XU6139 ND2 $PINS O=n5723 I1=N543 I2=n5752
XU6140 ND2 $PINS O=n5722 I1=N553 I2=n5746
XU6141 ND2 $PINS O=n5720 I1=N544 I2=n5751
XU6142 AN2 $PINS O=n5721 I1=N542 I2=n5753
XU6143 AN4B1S $PINS O=n5742 I1=n5723 I2=n5722 I3=n5720 B1=n5721
XU6144 AN2B1S $PINS O=n5726 I1=n5722 B1=n5721
XU6145 OR2B1S $PINS O=n5724 I1=N544 B1=n5723
XU6146 OAI222S $PINS O=n5725 A1=n5751 A2=n5724 B1=N543 B2=n5752 C1=N542
+ C2=n5753
XU6148 ND2 $PINS O=n5734 I1=N545 I2=n5750
XU6149 OA12 $PINS O=n5739 A1=n5734 B1=N558 B2=n5745
XU6150 MOAI1S $PINS O=n5727 A1=N564 A2=n5445 B1=n5444 B2=N551
XU6151 ND2 $PINS O=n5728 I1=N549 I2=n5747
XU6152 OAI112HS $PINS O=n5738 A1=n5727 B1=n5730 C1=N551 C2=n5444
XU6153 ND2 $PINS O=n5733 I1=N547 I2=n5748
XU6154 OAI12HS $PINS O=n5729 A1=n5728 B1=N562 B2=n5743
XU6155 ND2 $PINS O=n5731 I1=n5730 I2=n5729
XU6156 OA112 $PINS O=n5737 A1=n5733 B1=n5731 C1=N560 C2=n5744
XU6157 NR2 $PINS O=n5732 I1=N547 I2=n5748
XU6158 ND2 $PINS O=n5735 I1=n5734 I2=n5745
XU6159 AO13S $PINS O=n5740 A1=n5736 B1=n5739 B2=n5738 B3=n5737
XU6160 ND2 $PINS O=n5754 I1=N628 I2=n5441
XU6161 ND2 $PINS O=n5755 I1=N652 I2=n5440
XU6162 ND2 $PINS O=n5756 I1=N580 I2=n5439
XU6163 ND2 $PINS O=n5757 I1=N604 I2=n5438
.ENDS

.SUBCKT Deco_DW01_sub_15 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=n12 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n11 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=n10 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=n9 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=n8 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n7 CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n6 CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n4 CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n3 CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n13 I3=carry[11]
XU1 INV1S $PINS O=n13 I=B[11]
XU2 INV1S $PINS O=n3 I=B[1]
XU3 INV1S $PINS O=n4 I=B[2]
XU4 INV1S $PINS O=n5 I=B[3]
XU5 INV1S $PINS O=n6 I=B[4]
XU6 INV1S $PINS O=n7 I=B[5]
XU7 INV1S $PINS O=n8 I=B[6]
XU8 INV1S $PINS O=n9 I=B[7]
XU9 INV1S $PINS O=n10 I=B[8]
XU10 INV1S $PINS O=n11 I=B[9]
XU11 INV1S $PINS O=n12 I=B[10]
XU12 INV1S $PINS O=n2 I=B[0]
XU13 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=n2 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_14 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO FE_OFN146_n713 FE_OFN144_n713
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n6 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n7 CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN146_n713 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN146_n713 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN146_n713 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=FE_OFN144_n713 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=FE_OFN144_n713 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[7] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[7] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[7] CI=carry[4]
XU3 INV1S $PINS O=n3 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=n8 I2=A[1]
XU5 INV1S $PINS O=n7 I=B[2]
XU7 INV1S $PINS O=n6 I=B[3]
XU8 INV1S $PINS O=n8 I=B[1]
XU10 ND2 $PINS O=carry[2] I1=B[1] I2=n3
.ENDS

.SUBCKT Deco_DW01_sub_3 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=n12 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n11 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=n10 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=n9 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=n8 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n7 CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n6 CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n4 CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n3 CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n13 I3=carry[11]
XU1 INV1S $PINS O=n13 I=B[11]
XU2 INV1S $PINS O=n3 I=B[1]
XU3 INV1S $PINS O=n4 I=B[2]
XU4 INV1S $PINS O=n5 I=B[3]
XU5 INV1S $PINS O=n6 I=B[4]
XU6 INV1S $PINS O=n7 I=B[5]
XU7 INV1S $PINS O=n8 I=B[6]
XU8 INV1S $PINS O=n9 I=B[7]
XU9 INV1S $PINS O=n10 I=B[8]
XU10 INV1S $PINS O=n11 I=B[9]
XU11 INV1S $PINS O=n12 I=B[10]
XU12 INV1S $PINS O=n2 I=B[0]
XU13 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=n2 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_2 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
*.CONNECT DIFF[0] A[0]
XFE_OFC368_FE_DBTN97_N613 BUF1 $PINS O=FE_RN_1 I=B[6]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n6 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n7 CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_RN_1 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_RN_1 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_RN_1 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=FE_RN_1 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=FE_RN_1 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=FE_RN_1 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[6] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[6] CI=carry[4]
XU3 INV1S $PINS O=n3 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=n8 I2=A[1]
XU5 INV1S $PINS O=n7 I=B[2]
XU7 INV1S $PINS O=n6 I=B[3]
XU8 INV1S $PINS O=n8 I=B[1]
XU10 ND2 $PINS O=carry[2] I1=B[1] I2=n3
.ENDS

.SUBCKT Deco_DW01_sub_11 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=n12 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n11 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=n10 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=n9 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=n8 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n7 CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n6 CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n4 CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n3 CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n13 I3=carry[11]
XU1 INV1S $PINS O=n13 I=B[11]
XU2 INV1S $PINS O=n3 I=B[1]
XU3 INV1S $PINS O=n4 I=B[2]
XU4 INV1S $PINS O=n5 I=B[3]
XU5 INV1S $PINS O=n6 I=B[4]
XU6 INV1S $PINS O=n7 I=B[5]
XU7 INV1S $PINS O=n8 I=B[6]
XU8 INV1S $PINS O=n9 I=B[7]
XU9 INV1S $PINS O=n10 I=B[8]
XU10 INV1S $PINS O=n11 I=B[9]
XU11 INV1S $PINS O=n12 I=B[10]
XU12 INV1S $PINS O=n2 I=B[0]
XU13 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=n2 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_10 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1 FE_OFN138_FE_DBTN10_N923
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN138_FE_DBTN10_N923 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN138_FE_DBTN10_N923
+ CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN138_FE_DBTN10_N923
+ CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[9] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[9] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[9] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[7] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[7] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=p1 I2=A[1]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco_DW01_sub_7 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=n12 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n11 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=n10 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=n9 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=n8 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n7 CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n6 CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n4 CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n3 CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n13 I3=carry[11]
XU1 INV1S $PINS O=n13 I=B[11]
XU2 INV1S $PINS O=n3 I=B[1]
XU3 INV1S $PINS O=n4 I=B[2]
XU4 INV1S $PINS O=n5 I=B[3]
XU5 INV1S $PINS O=n6 I=B[4]
XU6 INV1S $PINS O=n7 I=B[5]
XU7 INV1S $PINS O=n8 I=B[6]
XU8 INV1S $PINS O=n9 I=B[7]
XU9 INV1S $PINS O=n10 I=B[8]
XU10 INV1S $PINS O=n11 I=B[9]
XU11 INV1S $PINS O=n12 I=B[10]
XU12 INV1S $PINS O=n2 I=B[0]
XU13 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=n2 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_6 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO FE_OFN141_FE_DBTN3_N577 FE_OFN142_N567
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n6 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n7 CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN141_FE_DBTN3_N577 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN141_FE_DBTN3_N577
+ CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN141_FE_DBTN3_N577
+ CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[5] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[5] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[4] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[4] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU3 INV1S $PINS O=n3 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=n8 I2=A[1]
XU5 INV1S $PINS O=n7 I=B[2]
XU7 INV1S $PINS O=n6 I=B[3]
XU8 INV1S $PINS O=n8 I=B[1]
XU10 ND2 $PINS O=carry[2] I1=FE_OFN142_N567 I2=n3
.ENDS

.SUBCKT Deco_DW01_sub_19 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=n13 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n12 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=n11 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=n10 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=n9 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n8 CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n7 CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n6 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n5 CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n4 CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n2 I3=carry[11]
XU1 INV1S $PINS O=n2 I=B[11]
XU2 INV1S $PINS O=n4 I=B[1]
XU3 INV1S $PINS O=n5 I=B[2]
XU4 INV1S $PINS O=n6 I=B[3]
XU5 INV1S $PINS O=n7 I=B[4]
XU6 INV1S $PINS O=n8 I=B[5]
XU7 INV1S $PINS O=n9 I=B[6]
XU8 INV1S $PINS O=n10 I=B[7]
XU9 INV1S $PINS O=n11 I=B[8]
XU10 INV1S $PINS O=n12 I=B[9]
XU11 INV1S $PINS O=n13 I=B[10]
XU12 INV1S $PINS O=n3 I=B[0]
XU13 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=n3 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_18 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1 FE_OFN150_n717 FE_OFN147_n717
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN150_n717 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN150_n717 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN147_n717 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=FE_OFN147_n717 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=FE_OFN147_n717 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=FE_OFN147_n717 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[10] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[10] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=p1 I2=A[1]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco_DW01_sub_5 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=B[11] I3=carry[11]
XU3 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=p1 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_4 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO
*.CONNECT DIFF[0] A[0]
XFE_OFC369_FE_DBTN96_N613 BUF1 $PINS O=FE_RN_1 I=B[6]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n6 CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_RN_1 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_RN_1 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_RN_1 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=FE_RN_1 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=FE_RN_1 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=FE_RN_1 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[6] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[6] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=n7 I2=A[1]
XU5 INV1S $PINS O=n7 I=B[1]
XU6 INV1S $PINS O=n6 I=B[2]
XU7 INV1S $PINS O=n5 I=B[3]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco_DW01_sub_13 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=B[11] I3=carry[11]
XU3 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=p1 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_12 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO FE_OFN140_FE_DBTN3_N577
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n6 CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN140_FE_DBTN3_N577 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN140_FE_DBTN3_N577
+ CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN140_FE_DBTN3_N577
+ CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[8] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[8] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[5] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=n7 I2=A[1]
XU5 INV1S $PINS O=n7 I=B[1]
XU6 INV1S $PINS O=n6 I=B[2]
XU7 INV1S $PINS O=n5 I=B[3]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco_DW01_sub_9 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=B[11] I3=carry[11]
XU3 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=p1 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_8 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1 FE_OFN139_FE_DBTN10_N923
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN139_FE_DBTN10_N923 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN139_FE_DBTN10_N923
+ CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN139_FE_DBTN10_N923
+ CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[7] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[4] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[4] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=p1 I2=A[1]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco_DW01_sub_1 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=B[11] I3=carry[11]
XU3 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=p1 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_0 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO FE_OFN145_n713 FE_OFN143_n713
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n5 CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n6 CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN145_n713 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN145_n713 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN145_n713 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=FE_OFN143_n713 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=FE_OFN143_n713 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=FE_OFN143_n713 CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[7] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[7] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=n7 I2=A[1]
XU5 INV1S $PINS O=n7 I=B[1]
XU6 INV1S $PINS O=n6 I=B[2]
XU7 INV1S $PINS O=n5 I=B[3]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco_DW01_sub_17 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=B[7] CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1S $PINS S=DIFF[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=B[11] I3=carry[11]
XU3 INV1S $PINS O=n1 I=A[0]
XU14 XNR2HS $PINS O=DIFF[0] I1=p1 I2=A[0]
XU15 ND2 $PINS O=carry[1] I1=B[0] I2=n1
.ENDS

.SUBCKT Deco_DW01_sub_16 A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI
+ DIFF[11] DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3]
+ DIFF[2] DIFF[1] DIFF[0] CO p1 FE_OFN149_n717 FE_OFN148_n717
*.CONNECT DIFF[0] A[0]
XU2_3 FA1S $PINS S=DIFF[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU2_2 FA1S $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_11 XOR3 $PINS O=DIFF[11] I1=A[11] I2=FE_OFN149_n717 I3=carry[11]
XU2_10 FA1S $PINS S=DIFF[10] CO=carry[11] A=A[10] B=FE_OFN149_n717 CI=carry[10]
XU2_9 FA1S $PINS S=DIFF[9] CO=carry[10] A=A[9] B=FE_OFN149_n717 CI=carry[9]
XU2_8 FA1S $PINS S=DIFF[8] CO=carry[9] A=A[8] B=FE_OFN149_n717 CI=carry[8]
XU2_7 FA1S $PINS S=DIFF[7] CO=carry[8] A=A[7] B=FE_OFN148_n717 CI=carry[7]
XU2_6 FA1S $PINS S=DIFF[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU2_5 FA1S $PINS S=DIFF[5] CO=carry[6] A=A[5] B=B[6] CI=carry[5]
XU2_4 FA1S $PINS S=DIFF[4] CO=carry[5] A=A[4] B=B[6] CI=carry[4]
XU3 INV1S $PINS O=n2 I=A[1]
XU4 XNR2HS $PINS O=DIFF[1] I1=p1 I2=A[1]
XU9 ND2 $PINS O=carry[2] I1=B[1] I2=n2
.ENDS

.SUBCKT Deco clk_p_i reset_n_i data_i[20] data_i[19] data_i[18] data_i[17]
+ data_i[16] data_i[15] data_i[14] data_i[13] data_i[12] data_i[11] data_i[10]
+ data_i[9] data_i[8] data_i[7] data_i[6] data_i[5] data_i[4] data_i[3]
+ data_i[2] data_i[1] data_i[0] data_o[4] data_o[3] data_o[2] data_o[1]
+ data_o[0] start_i done_o
XCTS_ccl_a_INV_clk_p_i_G0_L7_30 INV12CK $PINS O=CTS_147 I=CTS_148
XCTS_ccl_a_INV_clk_p_i_G0_L7_29 INV12CK $PINS O=CTS_146 I=CTS_148
XCTS_ccl_a_INV_clk_p_i_G0_L6_11 INV12CK $PINS O=CTS_148 I=CTS_149
XCTS_ccl_a_INV_clk_p_i_G0_L7_26 INV12CK $PINS O=CTS_144 I=CTS_145
XCTS_ccl_a_INV_clk_p_i_G0_L6_10 INV12CK $PINS O=CTS_145 I=CTS_149
XCTS_ccl_a_INV_clk_p_i_G0_L5_5 INV12CK $PINS O=CTS_149 I=CTS_150
XCTS_ccl_a_INV_clk_p_i_G0_L7_23 INV12CK $PINS O=CTS_141 I=CTS_142
XCTS_ccl_a_INV_clk_p_i_G0_L6_9 INV12CK $PINS O=CTS_142 I=CTS_143
XCTS_ccl_a_INV_clk_p_i_G0_L7_21 INV12CK $PINS O=CTS_139 I=CTS_140
XCTS_ccl_a_INV_clk_p_i_G0_L7_20 INV12CK $PINS O=CTS_138 I=CTS_140
XCTS_ccl_a_INV_clk_p_i_G0_L7_19 INV12CK $PINS O=CTS_137 I=CTS_140
XCTS_ccl_a_INV_clk_p_i_G0_L6_8 INV12CK $PINS O=CTS_140 I=CTS_143
XCTS_ccl_a_INV_clk_p_i_G0_L5_4 INV12CK $PINS O=CTS_143 I=CTS_150
XCTS_ccl_a_INV_clk_p_i_G0_L4_3 INV12CK $PINS O=CTS_150 I=CTS_151
XCTS_ccl_a_INV_clk_p_i_G0_L7_18 INV12CK $PINS O=CTS_133 I=CTS_134
XCTS_ccl_a_INV_clk_p_i_G0_L7_16 INV12CK $PINS O=CTS_132 I=CTS_134
XCTS_ccl_a_INV_clk_p_i_G0_L6_7 INV12CK $PINS O=CTS_134 I=CTS_135
XCTS_ccl_a_INV_clk_p_i_G0_L7_15 INV8CK $PINS O=CTS_130 I=CTS_131
XCTS_ccl_a_INV_clk_p_i_G0_L6_6 INV8CK $PINS O=CTS_131 I=CTS_135
XCTS_ccl_a_INV_clk_p_i_G0_L5_3 INV12CK $PINS O=CTS_135 I=CTS_136
XCTS_ccl_a_INV_clk_p_i_G0_L4_2 INV8CK $PINS O=CTS_136 I=CTS_151
XCTS_ccl_a_INV_clk_p_i_G0_L7_10 INV12CK $PINS O=CTS_126 I=CTS_127
XCTS_ccl_a_INV_clk_p_i_G0_L7_9 INV12CK $PINS O=CTS_125 I=CTS_127
XCTS_ccl_a_INV_clk_p_i_G0_L6_4 INV8CK $PINS O=CTS_127 I=CTS_128
XCTS_ccl_a_INV_clk_p_i_G0_L5_2 INV12CK $PINS O=CTS_128 I=CTS_129
XCTS_ccl_a_INV_clk_p_i_G0_L7_6 INV12CK $PINS O=CTS_122 I=CTS_123
XCTS_ccl_a_INV_clk_p_i_G0_L7_5 INV12CK $PINS O=CTS_121 I=CTS_123
XCTS_ccl_a_INV_clk_p_i_G0_L7_4 INV12CK $PINS O=CTS_120 I=CTS_123
XCTS_ccl_a_INV_clk_p_i_G0_L6_2 INV12CK $PINS O=CTS_123 I=CTS_124
XCTS_ccl_a_INV_clk_p_i_G0_L7_3 INV12CK $PINS O=CTS_118 I=CTS_119
XCTS_ccl_a_INV_clk_p_i_G0_L7_2 INV12CK $PINS O=CTS_117 I=CTS_119
XCTS_ccl_a_INV_clk_p_i_G0_L7_1 INV12CK $PINS O=CTS_116 I=CTS_119
XCTS_ccl_a_INV_clk_p_i_G0_L6_1 INV12CK $PINS O=CTS_119 I=CTS_124
XCTS_ccl_a_INV_clk_p_i_G0_L5_1 INV12CK $PINS O=CTS_124 I=CTS_129
XCTS_ccl_a_INV_clk_p_i_G0_L4_1 INV12CK $PINS O=CTS_129 I=CTS_151
XCTS_ccl_INV_clk_p_i_G0_L3_1 INV12CK $PINS O=CTS_151 I=CTS_152
XCTS_ccl_INV_clk_p_i_G0_L2_1 INV6CK $PINS O=CTS_152 I=clk_p_i
XFE_OFC1628_n270 BUF1 $PINS O=FE_OFN1760_n270 I=n270
XFE_OFC1314_n275 BUF1 $PINS O=FE_OFN1446_n275 I=FE_OFN1445_n275
XFE_OFC1313_n275 BUF1 $PINS O=FE_OFN1445_n275 I=FE_OFN1444_n275
XFE_OFC1312_n275 BUF1 $PINS O=FE_OFN1444_n275 I=FE_OFN1443_n275
XFE_OFC1311_n275 BUF1 $PINS O=FE_OFN1443_n275 I=FE_OFN1442_n275
XFE_OFC1310_n275 BUF1 $PINS O=FE_OFN1442_n275 I=FE_OFN1441_n275
XFE_OFC1309_n275 INV1S $PINS O=FE_OFN1441_n275 I=FE_OFN1437_n275
XFE_OFC1308_n275 INV1S $PINS O=FE_OFN1440_n275 I=FE_OFN1437_n275
XFE_OFC1307_n275 BUF1 $PINS O=FE_OFN1439_n275 I=n275
XFE_OFC1306_n275 BUF1 $PINS O=FE_OFN1438_n275 I=n275
XFE_OFC1305_n275 INV1S $PINS O=FE_OFN1437_n275 I=n275
XFE_OFC596_n717 BUF1 $PINS O=FE_OFN728_n717 I=FE_OFN727_n717
XFE_OFC595_n717 BUF1 $PINS O=FE_OFN727_n717 I=FE_OFN726_n717
XFE_OFC594_n717 BUF1 $PINS O=FE_OFN726_n717 I=n717
XFE_OFC593_n713 BUF1 $PINS O=FE_OFN725_n713 I=FE_OFN724_n713
XFE_OFC592_n713 BUF1 $PINS O=FE_OFN724_n713 I=n713
XFE_OFC591_N567 BUF1 $PINS O=FE_OFN723_N567 I=N567
XFE_OFC590_N603 BUF1 $PINS O=FE_OFN722_N603 I=N603
XFE_OFC589_N985 BUF1 $PINS O=FE_OFN721_N985 I=N985
XFE_OFC588_n312 BUF1 $PINS O=FE_OFN720_n312 I=FE_OFN718_n312
XFE_OFC587_n312 BUF1 $PINS O=FE_OFN719_n312 I=FE_OFN715_n312
XFE_OFC586_n312 INV1S $PINS O=FE_OFN718_n312 I=FE_OFN714_n312
XFE_OFC585_n312 INV1S $PINS O=FE_OFN717_n312 I=FE_OFN714_n312
XFE_OFC584_n312 BUF1 $PINS O=FE_OFN716_n312 I=FE_OFN713_n312
XFE_OFC583_n312 BUF1 $PINS O=FE_OFN715_n312 I=FE_OFN712_n312
XFE_OFC582_n312 INV1S $PINS O=FE_OFN714_n312 I=FE_OFN711_n312
XFE_OFC581_n312 BUF1 $PINS O=FE_OFN713_n312 I=FE_OFN710_n312
XFE_OFC580_n312 BUF1 $PINS O=FE_OFN712_n312 I=FE_OFN709_n312
XFE_OFC579_n312 BUF1 $PINS O=FE_OFN711_n312 I=FE_OFN709_n312
XFE_OFC578_n312 BUF1 $PINS O=FE_OFN710_n312 I=n312
XFE_OFC577_n312 BUF1 $PINS O=FE_OFN709_n312 I=n312
XFE_OFC576_n284 BUF1 $PINS O=FE_OFN708_n284 I=FE_OFN706_n284
XFE_OFC575_n284 BUF1 $PINS O=FE_OFN707_n284 I=FE_OFN705_n284
XFE_OFC574_n284 BUF1 $PINS O=FE_OFN706_n284 I=FE_OFN704_n284
XFE_OFC573_n284 BUF1 $PINS O=FE_OFN705_n284 I=FE_OFN703_n284
XFE_OFC572_n284 BUF1 $PINS O=FE_OFN704_n284 I=FE_OFN702_n284
XFE_OFC571_n284 BUF1 $PINS O=FE_OFN703_n284 I=FE_OFN701_n284
XFE_OFC570_n284 BUF1 $PINS O=FE_OFN702_n284 I=n284
XFE_OFC569_n284 BUF1 $PINS O=FE_OFN701_n284 I=n284
XFE_OFC568_n283 BUF1 $PINS O=FE_OFN700_n283 I=FE_OFN698_n283
XFE_OFC567_n283 BUF1 $PINS O=FE_OFN699_n283 I=FE_OFN697_n283
XFE_OFC566_n283 BUF1 $PINS O=FE_OFN698_n283 I=FE_OFN696_n283
XFE_OFC565_n283 BUF1 $PINS O=FE_OFN697_n283 I=FE_OFN695_n283
XFE_OFC564_n283 BUF1 $PINS O=FE_OFN696_n283 I=FE_OFN694_n283
XFE_OFC563_n283 INV1S $PINS O=FE_OFN695_n283 I=FE_OFN693_n283
XFE_OFC562_n283 INV1S $PINS O=FE_OFN694_n283 I=FE_OFN693_n283
XFE_OFC561_n283 INV1S $PINS O=FE_OFN693_n283 I=n283
XFE_OFC560_n283 BUF1 $PINS O=FE_OFN692_n283 I=n283
XFE_OFC559_n282 BUF1 $PINS O=FE_OFN691_n282 I=FE_OFN690_n282
XFE_OFC558_n282 BUF1 $PINS O=FE_OFN690_n282 I=FE_OFN688_n282
XFE_OFC557_n282 BUF1 $PINS O=FE_OFN689_n282 I=FE_OFN687_n282
XFE_OFC556_n282 BUF1 $PINS O=FE_OFN688_n282 I=FE_OFN686_n282
XFE_OFC555_n282 INV1S $PINS O=FE_OFN687_n282 I=FE_OFN684_n282
XFE_OFC554_n282 INV1S $PINS O=FE_OFN686_n282 I=FE_OFN684_n282
XFE_OFC553_n282 INV1S $PINS O=FE_OFN685_n282 I=FE_OFN684_n282
XFE_OFC552_n282 INV1S $PINS O=FE_OFN684_n282 I=n282
XFE_OFC551_n282 BUF1 $PINS O=FE_OFN683_n282 I=n282
XFE_OFC550_n280 BUF1 $PINS O=FE_OFN682_n280 I=FE_OFN681_n280
XFE_OFC549_n280 BUF1 $PINS O=FE_OFN681_n280 I=FE_OFN680_n280
XFE_OFC548_n280 BUF1 $PINS O=FE_OFN680_n280 I=FE_OFN678_n280
XFE_OFC547_n280 BUF1 $PINS O=FE_OFN679_n280 I=FE_OFN677_n280
XFE_OFC546_n280 BUF1 $PINS O=FE_OFN678_n280 I=FE_OFN676_n280
XFE_OFC545_n280 BUF1 $PINS O=FE_OFN677_n280 I=FE_OFN676_n280
XFE_OFC544_n280 BUF1 $PINS O=FE_OFN676_n280 I=n280
XFE_OFC543_n280 BUF1 $PINS O=FE_OFN675_n280 I=n280
XFE_OFC542_n205 BUF1 $PINS O=FE_OFN674_n205 I=FE_OFN673_n205
XFE_OFC541_n205 BUF1 $PINS O=FE_OFN673_n205 I=FE_OFN671_n205
XFE_OFC540_n205 BUF1 $PINS O=FE_OFN672_n205 I=FE_OFN668_n205
XFE_OFC539_n205 BUF1 $PINS O=FE_OFN671_n205 I=FE_OFN665_n205
XFE_OFC538_n205 INV1S $PINS O=FE_OFN670_n205 I=FE_OFN664_n205
XFE_OFC537_n205 INV1S $PINS O=FE_OFN669_n205 I=FE_OFN664_n205
XFE_OFC536_n205 INV1S $PINS O=FE_OFN668_n205 I=FE_OFN663_n205
XFE_OFC535_n205 INV1S $PINS O=FE_OFN667_n205 I=FE_OFN663_n205
XFE_OFC534_n205 BUF1 $PINS O=FE_OFN666_n205 I=FE_OFN662_n205
XFE_OFC533_n205 BUF1 $PINS O=FE_OFN665_n205 I=FE_OFN661_n205
XFE_OFC532_n205 INV1S $PINS O=FE_OFN664_n205 I=FE_OFN661_n205
XFE_OFC531_n205 INV1S $PINS O=FE_OFN663_n205 I=FE_OFN660_n205
XFE_OFC530_n205 BUF1 $PINS O=FE_OFN662_n205 I=n205
XFE_OFC529_n205 BUF1 $PINS O=FE_OFN661_n205 I=n205
XFE_OFC528_n205 BUF1 $PINS O=FE_OFN660_n205 I=n205
XFE_OFC527_n86 BUF1 $PINS O=FE_OFN659_n86 I=FE_OFN657_n86
XFE_OFC526_n86 BUF1 $PINS O=FE_OFN658_n86 I=FE_OFN656_n86
XFE_OFC525_n86 BUF1 $PINS O=FE_OFN657_n86 I=FE_OFN655_n86
XFE_OFC524_n86 BUF1 $PINS O=FE_OFN656_n86 I=FE_OFN654_n86
XFE_OFC523_n86 BUF1 $PINS O=FE_OFN655_n86 I=FE_OFN653_n86
XFE_OFC522_n86 BUF1 $PINS O=FE_OFN654_n86 I=FE_OFN651_n86
XFE_OFC521_n86 BUF1 $PINS O=FE_OFN653_n86 I=FE_OFN649_n86
XFE_OFC520_n86 BUF1 $PINS O=FE_OFN652_n86 I=FE_OFN646_n86
XFE_OFC519_n86 BUF1 $PINS O=FE_OFN651_n86 I=FE_OFN644_n86
XFE_OFC518_n86 BUF1 $PINS O=FE_OFN650_n86 I=FE_OFN643_n86
XFE_OFC517_n86 BUF1 $PINS O=FE_OFN649_n86 I=FE_OFN643_n86
XFE_OFC516_n86 BUF1 $PINS O=FE_OFN648_n86 I=FE_OFN642_n86
XFE_OFC515_n86 BUF1 $PINS O=FE_OFN647_n86 I=FE_OFN641_n86
XFE_OFC514_n86 BUF1 $PINS O=FE_OFN646_n86 I=FE_OFN641_n86
XFE_OFC513_n86 BUF1 $PINS O=FE_OFN645_n86 I=FE_OFN640_n86
XFE_OFC512_n86 INV1S $PINS O=FE_OFN644_n86 I=FE_OFN639_n86
XFE_OFC511_n86 INV1S $PINS O=FE_OFN643_n86 I=FE_OFN639_n86
XFE_OFC510_n86 BUF1 $PINS O=FE_OFN642_n86 I=FE_OFN638_n86
XFE_OFC509_n86 BUF1 $PINS O=FE_OFN641_n86 I=FE_OFN638_n86
XFE_OFC508_n86 BUF1 $PINS O=FE_OFN640_n86 I=FE_OFN637_n86
XFE_OFC507_n86 INV1S $PINS O=FE_OFN639_n86 I=FE_OFN636_n86
XFE_OFC506_n86 BUF1 $PINS O=FE_OFN638_n86 I=FE_OFN636_n86
XFE_OFC505_n86 BUF1 $PINS O=FE_OFN637_n86 I=n86
XFE_OFC504_n86 BUF1 $PINS O=FE_OFN636_n86 I=n86
XFE_OFC503_n85 BUF1 $PINS O=FE_OFN635_n85 I=FE_OFN633_n85
XFE_OFC502_n85 BUF1 $PINS O=FE_OFN634_n85 I=FE_OFN632_n85
XFE_OFC501_n85 BUF1 $PINS O=FE_OFN633_n85 I=FE_OFN630_n85
XFE_OFC500_n85 INV1S $PINS O=FE_OFN632_n85 I=n710
XFE_OFC499_n85 INV1S $PINS O=FE_OFN631_n85 I=n710
XFE_OFC498_n85 BUF1 $PINS O=FE_OFN630_n85 I=FE_OFN626_n85
XFE_OFC497_n85 INV1S $PINS O=FE_OFN629_n85 I=FE_OFN624_n85
XFE_OFC496_n85 INV1S $PINS O=FE_OFN628_n85 I=FE_OFN624_n85
XFE_OFC494_n85 BUF1 $PINS O=FE_OFN626_n85 I=FE_OFN622_n85
XFE_OFC492_n85 INV1S $PINS O=FE_OFN624_n85 I=FE_OFN621_n85
XFE_OFC491_n85 BUF1 $PINS O=FE_OFN623_n85 I=FE_OFN621_n85
XFE_OFC490_n85 BUF1 $PINS O=FE_OFN622_n85 I=n85
XFE_OFC489_n85 BUF1 $PINS O=FE_OFN621_n85 I=n85
XFE_OFC466_i_reset_n_i BUF1 $PINS O=FE_OFN598_i_reset_n_i I=reset_n_i
XFE_OFC465_FE_DBTN0_n712 INV1S $PINS O=FE_OFN597_FE_DBTN0_n712
+ I=FE_OFN595_FE_DBTN0_n712
XFE_OFC464_FE_DBTN0_n712 INV1S $PINS O=FE_OFN596_FE_DBTN0_n712
+ I=FE_OFN595_FE_DBTN0_n712
XFE_OFC463_FE_DBTN0_n712 INV1S $PINS O=FE_OFN595_FE_DBTN0_n712
+ I=FE_OFN594_FE_DBTN0_n712
XFE_OFC462_FE_DBTN0_n712 INV1S $PINS O=FE_OFN594_FE_DBTN0_n712
+ I=FE_OFN590_FE_DBTN0_n712
XFE_OFC461_FE_DBTN0_n712 INV1S $PINS O=FE_OFN593_FE_DBTN0_n712
+ I=FE_OFN590_FE_DBTN0_n712
XFE_OFC460_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN592_FE_DBTN0_n712
+ I=FE_OFN588_FE_DBTN0_n712
XFE_OFC459_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN591_FE_DBTN0_n712
+ I=FE_OFN587_FE_DBTN0_n712
XFE_OFC458_FE_DBTN0_n712 INV1S $PINS O=FE_OFN590_FE_DBTN0_n712
+ I=FE_OFN586_FE_DBTN0_n712
XFE_OFC457_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN589_FE_DBTN0_n712
+ I=FE_OFN584_FE_DBTN0_n712
XFE_OFC456_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN588_FE_DBTN0_n712
+ I=FE_OFN582_FE_DBTN0_n712
XFE_OFC455_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN587_FE_DBTN0_n712
+ I=FE_OFN581_FE_DBTN0_n712
XFE_OFC454_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN586_FE_DBTN0_n712
+ I=FE_OFN580_FE_DBTN0_n712
XFE_OFC453_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN585_FE_DBTN0_n712
+ I=FE_OFN579_FE_DBTN0_n712
XFE_OFC452_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN584_FE_DBTN0_n712
+ I=FE_OFN578_FE_DBTN0_n712
XFE_OFC451_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN583_FE_DBTN0_n712
+ I=FE_OFN577_FE_DBTN0_n712
XFE_OFC450_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN582_FE_DBTN0_n712
+ I=FE_OFN576_FE_DBTN0_n712
XFE_OFC449_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN581_FE_DBTN0_n712
+ I=FE_OFN574_FE_DBTN0_n712
XFE_OFC448_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN580_FE_DBTN0_n712
+ I=FE_OFN573_FE_DBTN0_n712
XFE_OFC447_FE_DBTN0_n712 INV1S $PINS O=FE_OFN579_FE_DBTN0_n712
+ I=FE_OFN572_FE_DBTN0_n712
XFE_OFC446_FE_DBTN0_n712 INV1S $PINS O=FE_OFN578_FE_DBTN0_n712
+ I=FE_OFN572_FE_DBTN0_n712
XFE_OFC445_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN577_FE_DBTN0_n712
+ I=FE_OFN571_FE_DBTN0_n712
XFE_OFC444_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN576_FE_DBTN0_n712
+ I=FE_OFN570_FE_DBTN0_n712
XFE_OFC443_FE_DBTN0_n712 INV1S $PINS O=FE_OFN575_FE_DBTN0_n712
+ I=FE_OFN569_FE_DBTN0_n712
XFE_OFC442_FE_DBTN0_n712 INV1S $PINS O=FE_OFN574_FE_DBTN0_n712
+ I=FE_OFN569_FE_DBTN0_n712
XFE_OFC441_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN573_FE_DBTN0_n712
+ I=FE_OFN568_FE_DBTN0_n712
XFE_OFC440_FE_DBTN0_n712 INV1S $PINS O=FE_OFN572_FE_DBTN0_n712
+ I=FE_OFN567_FE_DBTN0_n712
XFE_OFC439_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN571_FE_DBTN0_n712
+ I=FE_OFN566_FE_DBTN0_n712
XFE_OFC438_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN570_FE_DBTN0_n712
+ I=FE_OFN566_FE_DBTN0_n712
XFE_OFC437_FE_DBTN0_n712 INV1S $PINS O=FE_OFN569_FE_DBTN0_n712
+ I=FE_OFN565_FE_DBTN0_n712
XFE_OFC436_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN568_FE_DBTN0_n712
+ I=FE_OFN564_FE_DBTN0_n712
XFE_OFC435_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN567_FE_DBTN0_n712
+ I=FE_OFN564_FE_DBTN0_n712
XFE_OFC434_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN566_FE_DBTN0_n712
+ I=FE_OFN563_FE_DBTN0_n712
XFE_OFC433_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN565_FE_DBTN0_n712
+ I=FE_OFN562_FE_DBTN0_n712
XFE_OFC432_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN564_FE_DBTN0_n712
+ I=FE_OFN561_FE_DBTN0_n712
XFE_OFC431_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN563_FE_DBTN0_n712
+ I=FE_OFN561_FE_DBTN0_n712
XFE_OFC430_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN562_FE_DBTN0_n712
+ I=FE_OFN560_FE_DBTN0_n712
XFE_OFC429_FE_DBTN0_n712 BUF1 $PINS O=FE_OFN561_FE_DBTN0_n712
+ I=FE_OFN559_FE_DBTN0_n712
XFE_OFC428_FE_DBTN0_n712 INV1S $PINS O=FE_OFN560_FE_DBTN0_n712
+ I=FE_OFN558_FE_DBTN0_n712
XFE_OFC427_FE_DBTN0_n712 INV1S $PINS O=FE_OFN559_FE_DBTN0_n712
+ I=FE_OFN558_FE_DBTN0_n712
XFE_OFC426_FE_DBTN0_n712 INV1S $PINS O=FE_OFN558_FE_DBTN0_n712 I=FE_DBTN0_n712
XFE_OFC425_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN557_FE_DBTN1_n711
+ I=FE_OFN556_FE_DBTN1_n711
XFE_OFC424_FE_DBTN1_n711 INV1S $PINS O=FE_OFN556_FE_DBTN1_n711
+ I=FE_OFN552_FE_DBTN1_n711
XFE_OFC423_FE_DBTN1_n711 INV1S $PINS O=FE_OFN555_FE_DBTN1_n711
+ I=FE_OFN552_FE_DBTN1_n711
XFE_OFC422_FE_DBTN1_n711 INV1S $PINS O=FE_OFN554_FE_DBTN1_n711
+ I=FE_OFN551_FE_DBTN1_n711
XFE_OFC421_FE_DBTN1_n711 INV1S $PINS O=FE_OFN553_FE_DBTN1_n711
+ I=FE_OFN551_FE_DBTN1_n711
XFE_OFC420_FE_DBTN1_n711 INV1S $PINS O=FE_OFN552_FE_DBTN1_n711
+ I=FE_OFN550_FE_DBTN1_n711
XFE_OFC419_FE_DBTN1_n711 INV1S $PINS O=FE_OFN551_FE_DBTN1_n711
+ I=FE_OFN549_FE_DBTN1_n711
XFE_OFC418_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN550_FE_DBTN1_n711
+ I=FE_OFN548_FE_DBTN1_n711
XFE_OFC417_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN549_FE_DBTN1_n711
+ I=FE_OFN547_FE_DBTN1_n711
XFE_OFC416_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN548_FE_DBTN1_n711
+ I=FE_OFN546_FE_DBTN1_n711
XFE_OFC415_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN547_FE_DBTN1_n711
+ I=FE_OFN544_FE_DBTN1_n711
XFE_OFC414_FE_DBTN1_n711 INV1S $PINS O=FE_OFN546_FE_DBTN1_n711
+ I=FE_OFN543_FE_DBTN1_n711
XFE_OFC413_FE_DBTN1_n711 INV1S $PINS O=FE_OFN545_FE_DBTN1_n711
+ I=FE_OFN543_FE_DBTN1_n711
XFE_OFC412_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN544_FE_DBTN1_n711
+ I=FE_OFN541_FE_DBTN1_n711
XFE_OFC411_FE_DBTN1_n711 INV1S $PINS O=FE_OFN543_FE_DBTN1_n711
+ I=FE_OFN540_FE_DBTN1_n711
XFE_OFC410_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN542_FE_DBTN1_n711
+ I=FE_OFN539_FE_DBTN1_n711
XFE_OFC409_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN541_FE_DBTN1_n711
+ I=FE_OFN538_FE_DBTN1_n711
XFE_OFC408_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN540_FE_DBTN1_n711
+ I=FE_OFN536_FE_DBTN1_n711
XFE_OFC407_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN539_FE_DBTN1_n711
+ I=FE_OFN535_FE_DBTN1_n711
XFE_OFC406_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN538_FE_DBTN1_n711
+ I=FE_OFN534_FE_DBTN1_n711
XFE_OFC405_FE_DBTN1_n711 INV1S $PINS O=FE_OFN537_FE_DBTN1_n711
+ I=FE_OFN533_FE_DBTN1_n711
XFE_OFC404_FE_DBTN1_n711 INV1S $PINS O=FE_OFN536_FE_DBTN1_n711
+ I=FE_OFN533_FE_DBTN1_n711
XFE_OFC403_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN535_FE_DBTN1_n711
+ I=FE_OFN532_FE_DBTN1_n711
XFE_OFC402_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN534_FE_DBTN1_n711
+ I=FE_OFN532_FE_DBTN1_n711
XFE_OFC401_FE_DBTN1_n711 INV1S $PINS O=FE_OFN533_FE_DBTN1_n711
+ I=FE_OFN531_FE_DBTN1_n711
XFE_OFC400_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN532_FE_DBTN1_n711
+ I=FE_OFN529_FE_DBTN1_n711
XFE_OFC399_FE_DBTN1_n711 INV1S $PINS O=FE_OFN531_FE_DBTN1_n711
+ I=FE_OFN528_FE_DBTN1_n711
XFE_OFC398_FE_DBTN1_n711 INV1S $PINS O=FE_OFN530_FE_DBTN1_n711
+ I=FE_OFN528_FE_DBTN1_n711
XFE_OFC397_FE_DBTN1_n711 BUF1 $PINS O=FE_OFN529_FE_DBTN1_n711 I=FE_DBTN1_n711
XFE_OFC396_FE_DBTN1_n711 INV1S $PINS O=FE_OFN528_FE_DBTN1_n711 I=FE_DBTN1_n711
XFE_OFC395_FE_DBTN2_n694 BUF1 $PINS O=FE_OFN527_FE_DBTN2_n694 I=FE_DBTN2_n694
XFE_OFC394_FE_DBTN3_N577 BUF1 $PINS O=FE_OFN526_FE_DBTN3_N577
+ I=FE_OFN525_FE_DBTN3_N577
XFE_OFC393_FE_DBTN3_N577 BUF1 $PINS O=FE_OFN525_FE_DBTN3_N577 I=FE_DBTN3_N577
XFE_OFC392_FE_DBTN10_N923 BUF1 $PINS O=FE_OFN524_FE_DBTN10_N923
+ I=FE_OFN523_FE_DBTN10_N923
XFE_OFC391_FE_DBTN10_N923 BUF1 $PINS O=FE_OFN523_FE_DBTN10_N923
+ I=FE_OFN522_FE_DBTN10_N923
XFE_OFC390_FE_DBTN10_N923 BUF1 $PINS O=FE_OFN522_FE_DBTN10_N923
+ I=FE_DBTN10_N923
XFE_OFC362_i_reset_n_i BUF1 $PINS O=FE_OFN494_i_reset_n_i
+ I=FE_OFN477_i_reset_n_i
XFE_OFC361_i_reset_n_i BUF1 $PINS O=FE_OFN493_i_reset_n_i
+ I=FE_OFN477_i_reset_n_i
XFE_OFC360_i_reset_n_i BUF1 $PINS O=FE_OFN492_i_reset_n_i
+ I=FE_OFN476_i_reset_n_i
XFE_OFC359_i_reset_n_i BUF1 $PINS O=FE_OFN491_i_reset_n_i
+ I=FE_OFN475_i_reset_n_i
XFE_OFC358_i_reset_n_i BUF1 $PINS O=FE_OFN490_i_reset_n_i
+ I=FE_OFN473_i_reset_n_i
XFE_OFC357_i_reset_n_i BUF1 $PINS O=FE_OFN489_i_reset_n_i
+ I=FE_OFN473_i_reset_n_i
XFE_OFC353_i_reset_n_i BUF1 $PINS O=FE_OFN485_i_reset_n_i
+ I=FE_OFN460_i_reset_n_i
XFE_OFC345_i_reset_n_i BUF1 $PINS O=FE_OFN477_i_reset_n_i
+ I=FE_OFN439_i_reset_n_i
XFE_OFC344_i_reset_n_i BUF1 $PINS O=FE_OFN476_i_reset_n_i
+ I=FE_OFN439_i_reset_n_i
XFE_OFC343_i_reset_n_i BUF1 $PINS O=FE_OFN475_i_reset_n_i
+ I=FE_OFN432_i_reset_n_i
XFE_OFC342_i_reset_n_i BUF1 $PINS O=FE_OFN474_i_reset_n_i
+ I=FE_OFN431_i_reset_n_i
XFE_OFC341_i_reset_n_i BUF1 $PINS O=FE_OFN473_i_reset_n_i
+ I=FE_OFN430_i_reset_n_i
XFE_OFC340_i_reset_n_i BUF1 $PINS O=FE_OFN472_i_reset_n_i
+ I=FE_OFN429_i_reset_n_i
XFE_OFC339_i_reset_n_i BUF1 $PINS O=FE_OFN471_i_reset_n_i
+ I=FE_OFN428_i_reset_n_i
XFE_OFC332_i_reset_n_i BUF1 $PINS O=FE_OFN464_i_reset_n_i
+ I=FE_OFN402_i_reset_n_i
XFE_OFC328_i_reset_n_i BUF1 $PINS O=FE_OFN460_i_reset_n_i
+ I=FE_OFN397_i_reset_n_i
XFE_OFC315_i_reset_n_i BUF1 $PINS O=FE_OFN447_i_reset_n_i
+ I=FE_OFN388_i_reset_n_i
XFE_OFC314_i_reset_n_i BUF1 $PINS O=FE_OFN446_i_reset_n_i
+ I=FE_OFN387_i_reset_n_i
XFE_OFC313_i_reset_n_i BUF1 $PINS O=FE_OFN445_i_reset_n_i
+ I=FE_OFN387_i_reset_n_i
XFE_OFC308_i_reset_n_i BUF1 $PINS O=FE_OFN440_i_reset_n_i
+ I=FE_OFN378_i_reset_n_i
XFE_OFC307_i_reset_n_i BUF1 $PINS O=FE_OFN439_i_reset_n_i
+ I=FE_OFN375_i_reset_n_i
XFE_OFC306_i_reset_n_i BUF1 $PINS O=FE_OFN438_i_reset_n_i
+ I=FE_OFN375_i_reset_n_i
XFE_OFC305_i_reset_n_i BUF1 $PINS O=FE_OFN437_i_reset_n_i
+ I=FE_OFN371_i_reset_n_i
XFE_OFC304_i_reset_n_i BUF1 $PINS O=FE_OFN436_i_reset_n_i
+ I=FE_OFN368_i_reset_n_i
XFE_OFC303_i_reset_n_i BUF1 $PINS O=FE_OFN435_i_reset_n_i
+ I=FE_OFN368_i_reset_n_i
XFE_OFC301_i_reset_n_i BUF1 $PINS O=FE_OFN433_i_reset_n_i
+ I=FE_OFN366_i_reset_n_i
XFE_OFC300_i_reset_n_i BUF1 $PINS O=FE_OFN432_i_reset_n_i
+ I=FE_OFN365_i_reset_n_i
XFE_OFC299_i_reset_n_i BUF1 $PINS O=FE_OFN431_i_reset_n_i
+ I=FE_OFN365_i_reset_n_i
XFE_OFC298_i_reset_n_i BUF1 $PINS O=FE_OFN430_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC297_i_reset_n_i BUF1 $PINS O=FE_OFN429_i_reset_n_i
+ I=FE_OFN361_i_reset_n_i
XFE_OFC296_i_reset_n_i BUF1 $PINS O=FE_OFN428_i_reset_n_i
+ I=FE_OFN361_i_reset_n_i
XFE_OFC295_i_reset_n_i BUF1 $PINS O=FE_OFN427_i_reset_n_i
+ I=FE_OFN361_i_reset_n_i
XFE_OFC294_i_reset_n_i BUF1 $PINS O=FE_OFN426_i_reset_n_i
+ I=FE_OFN360_i_reset_n_i
XFE_OFC293_i_reset_n_i BUF1 $PINS O=FE_OFN425_i_reset_n_i
+ I=FE_OFN360_i_reset_n_i
XFE_OFC292_i_reset_n_i BUF1 $PINS O=FE_OFN424_i_reset_n_i
+ I=FE_OFN359_i_reset_n_i
XFE_OFC291_i_reset_n_i BUF1 $PINS O=FE_OFN423_i_reset_n_i
+ I=FE_OFN359_i_reset_n_i
XFE_OFC290_i_reset_n_i BUF1 $PINS O=FE_OFN422_i_reset_n_i
+ I=FE_OFN358_i_reset_n_i
XFE_OFC286_i_reset_n_i BUF1 $PINS O=FE_OFN418_i_reset_n_i
+ I=FE_OFN356_i_reset_n_i
XFE_OFC285_i_reset_n_i BUF1 $PINS O=FE_OFN417_i_reset_n_i
+ I=FE_OFN355_i_reset_n_i
XFE_OFC284_i_reset_n_i BUF1 $PINS O=FE_OFN416_i_reset_n_i
+ I=FE_OFN354_i_reset_n_i
XFE_OFC270_i_reset_n_i BUF1 $PINS O=FE_OFN402_i_reset_n_i
+ I=FE_OFN344_i_reset_n_i
XFE_OFC265_i_reset_n_i BUF1 $PINS O=FE_OFN397_i_reset_n_i
+ I=FE_OFN338_i_reset_n_i
XFE_OFC256_i_reset_n_i BUF1 $PINS O=FE_OFN388_i_reset_n_i
+ I=FE_OFN329_i_reset_n_i
XFE_OFC255_i_reset_n_i BUF1 $PINS O=FE_OFN387_i_reset_n_i
+ I=FE_OFN327_i_reset_n_i
XFE_OFC246_i_reset_n_i BUF1 $PINS O=FE_OFN378_i_reset_n_i
+ I=FE_OFN319_i_reset_n_i
XFE_OFC245_i_reset_n_i BUF1 $PINS O=FE_OFN377_i_reset_n_i
+ I=FE_OFN317_i_reset_n_i
XFE_OFC244_i_reset_n_i BUF1 $PINS O=FE_OFN376_i_reset_n_i
+ I=FE_OFN316_i_reset_n_i
XFE_OFC243_i_reset_n_i BUF1 $PINS O=FE_OFN375_i_reset_n_i
+ I=FE_OFN312_i_reset_n_i
XFE_OFC242_i_reset_n_i BUF1 $PINS O=FE_OFN374_i_reset_n_i
+ I=FE_OFN312_i_reset_n_i
XFE_OFC241_i_reset_n_i BUF1 $PINS O=FE_OFN373_i_reset_n_i
+ I=FE_OFN312_i_reset_n_i
XFE_OFC240_i_reset_n_i BUF1 $PINS O=FE_OFN372_i_reset_n_i
+ I=FE_OFN311_i_reset_n_i
XFE_OFC239_i_reset_n_i BUF1 $PINS O=FE_OFN371_i_reset_n_i
+ I=FE_OFN310_i_reset_n_i
XFE_OFC236_i_reset_n_i BUF1 $PINS O=FE_OFN368_i_reset_n_i
+ I=FE_OFN308_i_reset_n_i
XFE_OFC235_i_reset_n_i BUF1 $PINS O=FE_OFN367_i_reset_n_i
+ I=FE_OFN308_i_reset_n_i
XFE_OFC234_i_reset_n_i BUF1 $PINS O=FE_OFN366_i_reset_n_i
+ I=FE_OFN308_i_reset_n_i
XFE_OFC233_i_reset_n_i BUF1 $PINS O=FE_OFN365_i_reset_n_i
+ I=FE_OFN305_i_reset_n_i
XFE_OFC232_i_reset_n_i BUF1 $PINS O=FE_OFN364_i_reset_n_i
+ I=FE_OFN305_i_reset_n_i
XFE_OFC231_i_reset_n_i BUF1 $PINS O=FE_OFN363_i_reset_n_i
+ I=FE_OFN305_i_reset_n_i
XFE_OFC230_i_reset_n_i BUF1 $PINS O=FE_OFN362_i_reset_n_i
+ I=FE_OFN305_i_reset_n_i
XFE_OFC229_i_reset_n_i BUF1 $PINS O=FE_OFN361_i_reset_n_i
+ I=FE_OFN303_i_reset_n_i
XFE_OFC228_i_reset_n_i BUF1 $PINS O=FE_OFN360_i_reset_n_i
+ I=FE_OFN302_i_reset_n_i
XFE_OFC227_i_reset_n_i BUF1 $PINS O=FE_OFN359_i_reset_n_i
+ I=FE_OFN301_i_reset_n_i
XFE_OFC226_i_reset_n_i BUF1 $PINS O=FE_OFN358_i_reset_n_i
+ I=FE_OFN301_i_reset_n_i
XFE_OFC225_i_reset_n_i BUF1 $PINS O=FE_OFN357_i_reset_n_i
+ I=FE_OFN300_i_reset_n_i
XFE_OFC224_i_reset_n_i BUF1 $PINS O=FE_OFN356_i_reset_n_i
+ I=FE_OFN299_i_reset_n_i
XFE_OFC223_i_reset_n_i BUF1 $PINS O=FE_OFN355_i_reset_n_i
+ I=FE_OFN299_i_reset_n_i
XFE_OFC222_i_reset_n_i BUF1 $PINS O=FE_OFN354_i_reset_n_i
+ I=FE_OFN299_i_reset_n_i
XFE_OFC212_i_reset_n_i BUF1 $PINS O=FE_OFN344_i_reset_n_i
+ I=FE_OFN286_i_reset_n_i
XFE_OFC206_i_reset_n_i BUF1 $PINS O=FE_OFN338_i_reset_n_i
+ I=FE_OFN282_i_reset_n_i
XFE_OFC197_i_reset_n_i BUF1 $PINS O=FE_OFN329_i_reset_n_i
+ I=FE_OFN272_i_reset_n_i
XFE_OFC196_i_reset_n_i BUF1 $PINS O=FE_OFN328_i_reset_n_i
+ I=FE_OFN272_i_reset_n_i
XFE_OFC195_i_reset_n_i BUF1 $PINS O=FE_OFN327_i_reset_n_i
+ I=FE_OFN270_i_reset_n_i
XFE_OFC194_i_reset_n_i BUF1 $PINS O=FE_OFN326_i_reset_n_i
+ I=FE_OFN270_i_reset_n_i
XFE_OFC193_i_reset_n_i BUF1 $PINS O=FE_OFN325_i_reset_n_i
+ I=FE_OFN269_i_reset_n_i
XFE_OFC192_i_reset_n_i BUF1 $PINS O=FE_OFN324_i_reset_n_i
+ I=FE_OFN268_i_reset_n_i
XFE_OFC187_i_reset_n_i BUF1 $PINS O=FE_OFN319_i_reset_n_i
+ I=FE_OFN264_i_reset_n_i
XFE_OFC185_i_reset_n_i BUF1 $PINS O=FE_OFN317_i_reset_n_i
+ I=FE_OFN262_i_reset_n_i
XFE_OFC184_i_reset_n_i BUF1 $PINS O=FE_OFN316_i_reset_n_i
+ I=FE_OFN262_i_reset_n_i
XFE_OFC183_i_reset_n_i BUF1 $PINS O=FE_OFN315_i_reset_n_i
+ I=FE_OFN261_i_reset_n_i
XFE_OFC182_i_reset_n_i BUF1 $PINS O=FE_OFN314_i_reset_n_i
+ I=FE_OFN261_i_reset_n_i
XFE_OFC181_i_reset_n_i BUF1 $PINS O=FE_OFN313_i_reset_n_i
+ I=FE_OFN261_i_reset_n_i
XFE_OFC180_i_reset_n_i BUF1 $PINS O=FE_OFN312_i_reset_n_i
+ I=FE_OFN259_i_reset_n_i
XFE_OFC179_i_reset_n_i BUF1 $PINS O=FE_OFN311_i_reset_n_i
+ I=FE_OFN259_i_reset_n_i
XFE_OFC178_i_reset_n_i BUF1 $PINS O=FE_OFN310_i_reset_n_i
+ I=FE_OFN258_i_reset_n_i
XFE_OFC177_i_reset_n_i BUF1 $PINS O=FE_OFN309_i_reset_n_i
+ I=FE_OFN258_i_reset_n_i
XFE_OFC176_i_reset_n_i BUF1 $PINS O=FE_OFN308_i_reset_n_i
+ I=FE_OFN256_i_reset_n_i
XFE_OFC174_i_reset_n_i BUF1 $PINS O=FE_OFN306_i_reset_n_i
+ I=FE_OFN256_i_reset_n_i
XFE_OFC173_i_reset_n_i BUF1 $PINS O=FE_OFN305_i_reset_n_i
+ I=FE_OFN253_i_reset_n_i
XFE_OFC171_i_reset_n_i BUF1 $PINS O=FE_OFN303_i_reset_n_i
+ I=FE_OFN250_i_reset_n_i
XFE_OFC170_i_reset_n_i BUF1 $PINS O=FE_OFN302_i_reset_n_i
+ I=FE_OFN248_i_reset_n_i
XFE_OFC169_i_reset_n_i BUF1 $PINS O=FE_OFN301_i_reset_n_i
+ I=FE_OFN248_i_reset_n_i
XFE_OFC168_i_reset_n_i BUF1 $PINS O=FE_OFN300_i_reset_n_i
+ I=FE_OFN246_i_reset_n_i
XFE_OFC167_i_reset_n_i BUF1 $PINS O=FE_OFN299_i_reset_n_i
+ I=FE_OFN246_i_reset_n_i
XFE_OFC161_i_reset_n_i BUF1 $PINS O=FE_OFN293_i_reset_n_i
+ I=FE_OFN240_i_reset_n_i
XFE_OFC154_i_reset_n_i BUF1 $PINS O=FE_OFN286_i_reset_n_i
+ I=FE_OFN234_i_reset_n_i
XFE_OFC153_i_reset_n_i BUF1 $PINS O=FE_OFN285_i_reset_n_i
+ I=FE_OFN234_i_reset_n_i
XFE_OFC150_i_reset_n_i BUF1 $PINS O=FE_OFN282_i_reset_n_i
+ I=FE_OFN231_i_reset_n_i
XFE_OFC148_i_reset_n_i BUF1 $PINS O=FE_OFN280_i_reset_n_i
+ I=FE_OFN229_i_reset_n_i
XFE_OFC144_i_reset_n_i BUF1 $PINS O=FE_OFN276_i_reset_n_i
+ I=FE_OFN225_i_reset_n_i
XFE_OFC140_i_reset_n_i BUF1 $PINS O=FE_OFN272_i_reset_n_i
+ I=FE_OFN221_i_reset_n_i
XFE_OFC139_i_reset_n_i BUF1 $PINS O=FE_OFN271_i_reset_n_i
+ I=FE_OFN220_i_reset_n_i
XFE_OFC138_i_reset_n_i BUF1 $PINS O=FE_OFN270_i_reset_n_i
+ I=FE_OFN219_i_reset_n_i
XFE_OFC137_i_reset_n_i BUF1 $PINS O=FE_OFN269_i_reset_n_i
+ I=FE_OFN219_i_reset_n_i
XFE_OFC136_i_reset_n_i BUF1 $PINS O=FE_OFN268_i_reset_n_i
+ I=FE_OFN219_i_reset_n_i
XFE_OFC132_i_reset_n_i BUF1 $PINS O=FE_OFN264_i_reset_n_i
+ I=FE_OFN213_i_reset_n_i
XFE_OFC130_i_reset_n_i BUF1 $PINS O=FE_OFN262_i_reset_n_i
+ I=FE_OFN212_i_reset_n_i
XFE_OFC129_i_reset_n_i BUF1 $PINS O=FE_OFN261_i_reset_n_i
+ I=FE_OFN212_i_reset_n_i
XFE_OFC128_i_reset_n_i BUF1 $PINS O=FE_OFN260_i_reset_n_i
+ I=FE_OFN212_i_reset_n_i
XFE_OFC127_i_reset_n_i BUF1 $PINS O=FE_OFN259_i_reset_n_i
+ I=FE_OFN211_i_reset_n_i
XFE_OFC126_i_reset_n_i BUF1 $PINS O=FE_OFN258_i_reset_n_i
+ I=FE_OFN210_i_reset_n_i
XFE_OFC124_i_reset_n_i BUF1 $PINS O=FE_OFN256_i_reset_n_i
+ I=FE_OFN208_i_reset_n_i
XFE_OFC123_i_reset_n_i BUF1 $PINS O=FE_OFN255_i_reset_n_i
+ I=FE_OFN208_i_reset_n_i
XFE_OFC122_i_reset_n_i BUF1 $PINS O=FE_OFN254_i_reset_n_i
+ I=FE_OFN207_i_reset_n_i
XFE_OFC121_i_reset_n_i BUF1 $PINS O=FE_OFN253_i_reset_n_i
+ I=FE_OFN206_i_reset_n_i
XFE_OFC120_i_reset_n_i BUF1 $PINS O=FE_OFN252_i_reset_n_i
+ I=FE_OFN206_i_reset_n_i
XFE_OFC119_i_reset_n_i BUF1 $PINS O=FE_OFN251_i_reset_n_i
+ I=FE_OFN206_i_reset_n_i
XFE_OFC118_i_reset_n_i BUF1 $PINS O=FE_OFN250_i_reset_n_i
+ I=FE_OFN205_i_reset_n_i
XFE_OFC116_i_reset_n_i BUF1 $PINS O=FE_OFN248_i_reset_n_i
+ I=FE_OFN204_i_reset_n_i
XFE_OFC115_i_reset_n_i BUF1 $PINS O=FE_OFN247_i_reset_n_i
+ I=FE_OFN204_i_reset_n_i
XFE_OFC114_i_reset_n_i BUF1 $PINS O=FE_OFN246_i_reset_n_i
+ I=FE_OFN203_i_reset_n_i
XFE_OFC109_i_reset_n_i BUF1 $PINS O=FE_OFN241_i_reset_n_i
+ I=FE_OFN200_i_reset_n_i
XFE_OFC108_i_reset_n_i BUF1 $PINS O=FE_OFN240_i_reset_n_i
+ I=FE_OFN200_i_reset_n_i
XFE_OFC102_i_reset_n_i BUF1 $PINS O=FE_OFN234_i_reset_n_i
+ I=FE_OFN195_i_reset_n_i
XFE_OFC99_i_reset_n_i BUF1 $PINS O=FE_OFN231_i_reset_n_i
+ I=FE_OFN191_i_reset_n_i
XFE_OFC97_i_reset_n_i BUF1 $PINS O=FE_OFN229_i_reset_n_i
+ I=FE_OFN189_i_reset_n_i
XFE_OFC95_i_reset_n_i BUF1 $PINS O=FE_OFN227_i_reset_n_i
+ I=FE_OFN186_i_reset_n_i
XFE_OFC93_i_reset_n_i BUF1 $PINS O=FE_OFN225_i_reset_n_i
+ I=FE_OFN185_i_reset_n_i
XFE_OFC89_i_reset_n_i BUF1 $PINS O=FE_OFN221_i_reset_n_i
+ I=FE_OFN181_i_reset_n_i
XFE_OFC88_i_reset_n_i BUF1 $PINS O=FE_OFN220_i_reset_n_i
+ I=FE_OFN180_i_reset_n_i
XFE_OFC87_i_reset_n_i BUF1 $PINS O=FE_OFN219_i_reset_n_i
+ I=FE_OFN179_i_reset_n_i
XFE_OFC81_i_reset_n_i BUF1 $PINS O=FE_OFN213_i_reset_n_i
+ I=FE_OFN175_i_reset_n_i
XFE_OFC80_i_reset_n_i BUF1 $PINS O=FE_OFN212_i_reset_n_i
+ I=FE_OFN174_i_reset_n_i
XFE_OFC79_i_reset_n_i BUF1 $PINS O=FE_OFN211_i_reset_n_i
+ I=FE_OFN171_i_reset_n_i
XFE_OFC78_i_reset_n_i BUF1 $PINS O=FE_OFN210_i_reset_n_i
+ I=FE_OFN170_i_reset_n_i
XFE_OFC77_i_reset_n_i BUF1 $PINS O=FE_OFN209_i_reset_n_i
+ I=FE_OFN170_i_reset_n_i
XFE_OFC76_i_reset_n_i BUF1 $PINS O=FE_OFN208_i_reset_n_i
+ I=FE_OFN169_i_reset_n_i
XFE_OFC75_i_reset_n_i BUF1 $PINS O=FE_OFN207_i_reset_n_i
+ I=FE_OFN169_i_reset_n_i
XFE_OFC74_i_reset_n_i BUF1 $PINS O=FE_OFN206_i_reset_n_i
+ I=FE_OFN168_i_reset_n_i
XFE_OFC73_i_reset_n_i BUF1 $PINS O=FE_OFN205_i_reset_n_i
+ I=FE_OFN167_i_reset_n_i
XFE_OFC72_i_reset_n_i BUF1 $PINS O=FE_OFN204_i_reset_n_i
+ I=FE_OFN165_i_reset_n_i
XFE_OFC71_i_reset_n_i BUF1 $PINS O=FE_OFN203_i_reset_n_i
+ I=FE_OFN164_i_reset_n_i
XFE_OFC68_i_reset_n_i BUF1 $PINS O=FE_OFN200_i_reset_n_i
+ I=FE_OFN160_i_reset_n_i
XFE_OFC63_i_reset_n_i BUF1 $PINS O=FE_OFN195_i_reset_n_i
+ I=FE_OFN158_i_reset_n_i
XFE_OFC59_i_reset_n_i BUF1 $PINS O=FE_OFN191_i_reset_n_i
+ I=FE_OFN156_i_reset_n_i
XFE_OFC57_i_reset_n_i BUF1 $PINS O=FE_OFN189_i_reset_n_i
+ I=FE_OFN154_i_reset_n_i
XFE_OFC54_i_reset_n_i BUF1 $PINS O=FE_OFN186_i_reset_n_i
+ I=FE_OFN152_i_reset_n_i
XFE_OFC53_i_reset_n_i BUF1 $PINS O=FE_OFN185_i_reset_n_i
+ I=FE_OFN151_i_reset_n_i
XFE_OFC49_i_reset_n_i INV1S $PINS O=FE_OFN181_i_reset_n_i
+ I=FE_OFN148_i_reset_n_i
XFE_OFC48_i_reset_n_i INV1S $PINS O=FE_OFN180_i_reset_n_i
+ I=FE_OFN148_i_reset_n_i
XFE_OFC47_i_reset_n_i INV1S $PINS O=FE_OFN179_i_reset_n_i
+ I=FE_OFN148_i_reset_n_i
XFE_OFC43_i_reset_n_i BUF1 $PINS O=FE_OFN175_i_reset_n_i
+ I=FE_OFN145_i_reset_n_i
XFE_OFC42_i_reset_n_i BUF1 $PINS O=FE_OFN174_i_reset_n_i
+ I=FE_OFN144_i_reset_n_i
XFE_OFC41_i_reset_n_i BUF1 $PINS O=FE_OFN173_i_reset_n_i
+ I=FE_OFN144_i_reset_n_i
XFE_OFC40_i_reset_n_i BUF1 $PINS O=FE_OFN172_i_reset_n_i
+ I=FE_OFN144_i_reset_n_i
XFE_OFC39_i_reset_n_i BUF1 $PINS O=FE_OFN171_i_reset_n_i
+ I=FE_OFN143_i_reset_n_i
XFE_OFC38_i_reset_n_i BUF1 $PINS O=FE_OFN170_i_reset_n_i
+ I=FE_OFN142_i_reset_n_i
XFE_OFC37_i_reset_n_i BUF1 $PINS O=FE_OFN169_i_reset_n_i
+ I=FE_OFN142_i_reset_n_i
XFE_OFC36_i_reset_n_i BUF1 $PINS O=FE_OFN168_i_reset_n_i
+ I=FE_OFN141_i_reset_n_i
XFE_OFC35_i_reset_n_i BUF1 $PINS O=FE_OFN167_i_reset_n_i
+ I=FE_OFN140_i_reset_n_i
XFE_OFC33_i_reset_n_i INV1S $PINS O=FE_OFN165_i_reset_n_i
+ I=FE_OFN139_i_reset_n_i
XFE_OFC32_i_reset_n_i INV1S $PINS O=FE_OFN164_i_reset_n_i
+ I=FE_OFN139_i_reset_n_i
XFE_OFC28_i_reset_n_i BUF1 $PINS O=FE_OFN160_i_reset_n_i I=FE_OFN5_i_reset_n_i
XFE_OFC26_i_reset_n_i BUF1 $PINS O=FE_OFN158_i_reset_n_i I=FE_OFN5_i_reset_n_i
XFE_OFC24_i_reset_n_i BUF1 $PINS O=FE_OFN156_i_reset_n_i I=FE_OFN5_i_reset_n_i
XFE_OFC22_i_reset_n_i BUF1 $PINS O=FE_OFN154_i_reset_n_i I=FE_OFN4_i_reset_n_i
XFE_OFC20_i_reset_n_i BUF1 $PINS O=FE_OFN152_i_reset_n_i I=FE_OFN3_i_reset_n_i
XFE_OFC19_i_reset_n_i BUF1 $PINS O=FE_OFN151_i_reset_n_i I=FE_OFN2_i_reset_n_i
XFE_OFC16_i_reset_n_i BUF1 $PINS O=FE_OFN148_i_reset_n_i I=FE_OFN1_i_reset_n_i
XFE_OFC13_i_reset_n_i INV1S $PINS O=FE_OFN145_i_reset_n_i I=FE_OFN1_i_reset_n_i
XFE_OFC12_i_reset_n_i INV1S $PINS O=FE_OFN144_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC11_i_reset_n_i INV1S $PINS O=FE_OFN143_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC10_i_reset_n_i INV1S $PINS O=FE_OFN142_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC9_i_reset_n_i INV1S $PINS O=FE_OFN141_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC8_i_reset_n_i INV1S $PINS O=FE_OFN140_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC7_i_reset_n_i BUF1 $PINS O=FE_OFN139_i_reset_n_i I=FE_OFN0_i_reset_n_i
XFE_OFC5_i_reset_n_i BUF1 $PINS O=FE_OFN5_i_reset_n_i I=FE_OFN598_i_reset_n_i
XFE_OFC4_i_reset_n_i BUF1 $PINS O=FE_OFN4_i_reset_n_i I=reset_n_i
XFE_OFC3_i_reset_n_i BUF1 $PINS O=FE_OFN3_i_reset_n_i I=reset_n_i
XFE_OFC2_i_reset_n_i BUF1 $PINS O=FE_OFN2_i_reset_n_i I=reset_n_i
XFE_OFC1_i_reset_n_i INV1S $PINS O=FE_OFN1_i_reset_n_i I=FE_OFN598_i_reset_n_i
XFE_OFC0_i_reset_n_i INV2 $PINS O=FE_OFN0_i_reset_n_i I=reset_n_i
XFE_DBTC97_N613 INV1S $PINS O=FE_DBTN97_N613 I=N613
XFE_DBTC70_temp_LLR_0_11 INV1S $PINS O=FE_DBTN70_temp_LLR_0_11
+ I=temp_LLR[0][11]
XFE_DBTC69_temp_LLR_0_10 INV1S $PINS O=FE_DBTN69_temp_LLR_0_10
+ I=temp_LLR[0][10]
XFE_DBTC68_temp_LLR_0_9 INV1S $PINS O=FE_DBTN68_temp_LLR_0_9 I=temp_LLR[0][9]
XFE_DBTC67_temp_LLR_0_8 INV1S $PINS O=FE_DBTN67_temp_LLR_0_8 I=temp_LLR[0][8]
XFE_DBTC66_temp_LLR_0_7 INV1S $PINS O=FE_DBTN66_temp_LLR_0_7 I=temp_LLR[0][7]
XFE_DBTC65_temp_LLR_0_6 INV1S $PINS O=FE_DBTN65_temp_LLR_0_6 I=temp_LLR[0][6]
XFE_DBTC64_temp_LLR_0_5 INV1S $PINS O=FE_DBTN64_temp_LLR_0_5 I=temp_LLR[0][5]
XFE_DBTC63_temp_LLR_0_4 INV1S $PINS O=FE_DBTN63_temp_LLR_0_4 I=temp_LLR[0][4]
XFE_DBTC62_temp_LLR_0_3 INV1S $PINS O=FE_DBTN62_temp_LLR_0_3 I=temp_LLR[0][3]
XFE_DBTC61_temp_LLR_0_2 INV1S $PINS O=FE_DBTN61_temp_LLR_0_2 I=temp_LLR[0][2]
XFE_DBTC60_temp_LLR_0_1 INV1S $PINS O=FE_DBTN60_temp_LLR_0_1 I=temp_LLR[0][1]
XFE_DBTC59_temp_LLR_0_0 INV1S $PINS O=FE_DBTN59_temp_LLR_0_0 I=temp_LLR[0][0]
XFE_DBTC58_temp_LLR_1_11 INV1S $PINS O=FE_DBTN58_temp_LLR_1_11
+ I=temp_LLR[1][11]
XFE_DBTC57_temp_LLR_1_10 INV1S $PINS O=FE_DBTN57_temp_LLR_1_10
+ I=temp_LLR[1][10]
XFE_DBTC56_temp_LLR_1_9 INV1S $PINS O=FE_DBTN56_temp_LLR_1_9 I=temp_LLR[1][9]
XFE_DBTC55_temp_LLR_1_8 INV1S $PINS O=FE_DBTN55_temp_LLR_1_8 I=temp_LLR[1][8]
XFE_DBTC54_temp_LLR_1_7 INV1S $PINS O=FE_DBTN54_temp_LLR_1_7 I=temp_LLR[1][7]
XFE_DBTC53_temp_LLR_1_6 INV1S $PINS O=FE_DBTN53_temp_LLR_1_6 I=temp_LLR[1][6]
XFE_DBTC52_temp_LLR_1_5 INV1S $PINS O=FE_DBTN52_temp_LLR_1_5 I=temp_LLR[1][5]
XFE_DBTC51_temp_LLR_1_4 INV1S $PINS O=FE_DBTN51_temp_LLR_1_4 I=temp_LLR[1][4]
XFE_DBTC50_temp_LLR_1_3 INV1S $PINS O=FE_DBTN50_temp_LLR_1_3 I=temp_LLR[1][3]
XFE_DBTC49_temp_LLR_1_2 INV1S $PINS O=FE_DBTN49_temp_LLR_1_2 I=temp_LLR[1][2]
XFE_DBTC48_temp_LLR_1_1 INV1S $PINS O=FE_DBTN48_temp_LLR_1_1 I=temp_LLR[1][1]
XFE_DBTC47_temp_LLR_1_0 INV1S $PINS O=FE_DBTN47_temp_LLR_1_0 I=temp_LLR[1][0]
XFE_DBTC46_temp_LLR_2_11 INV1S $PINS O=FE_DBTN46_temp_LLR_2_11
+ I=temp_LLR[2][11]
XFE_DBTC45_temp_LLR_2_10 INV1S $PINS O=FE_DBTN45_temp_LLR_2_10
+ I=temp_LLR[2][10]
XFE_DBTC44_temp_LLR_2_9 INV1S $PINS O=FE_DBTN44_temp_LLR_2_9 I=temp_LLR[2][9]
XFE_DBTC43_temp_LLR_2_8 INV1S $PINS O=FE_DBTN43_temp_LLR_2_8 I=temp_LLR[2][8]
XFE_DBTC42_temp_LLR_2_7 INV1S $PINS O=FE_DBTN42_temp_LLR_2_7 I=temp_LLR[2][7]
XFE_DBTC41_temp_LLR_2_6 INV1S $PINS O=FE_DBTN41_temp_LLR_2_6 I=temp_LLR[2][6]
XFE_DBTC40_temp_LLR_2_5 INV1S $PINS O=FE_DBTN40_temp_LLR_2_5 I=temp_LLR[2][5]
XFE_DBTC39_temp_LLR_2_4 INV1S $PINS O=FE_DBTN39_temp_LLR_2_4 I=temp_LLR[2][4]
XFE_DBTC38_temp_LLR_2_3 INV1S $PINS O=FE_DBTN38_temp_LLR_2_3 I=temp_LLR[2][3]
XFE_DBTC37_temp_LLR_2_2 INV1S $PINS O=FE_DBTN37_temp_LLR_2_2 I=temp_LLR[2][2]
XFE_DBTC36_temp_LLR_2_1 INV1S $PINS O=FE_DBTN36_temp_LLR_2_1 I=temp_LLR[2][1]
XFE_DBTC35_temp_LLR_2_0 INV1S $PINS O=FE_DBTN35_temp_LLR_2_0 I=temp_LLR[2][0]
XFE_DBTC34_temp_LLR_3_11 INV1S $PINS O=FE_DBTN34_temp_LLR_3_11
+ I=temp_LLR[3][11]
XFE_DBTC33_temp_LLR_3_10 INV1S $PINS O=FE_DBTN33_temp_LLR_3_10
+ I=temp_LLR[3][10]
XFE_DBTC32_temp_LLR_3_9 INV1S $PINS O=FE_DBTN32_temp_LLR_3_9 I=temp_LLR[3][9]
XFE_DBTC31_temp_LLR_3_8 INV1S $PINS O=FE_DBTN31_temp_LLR_3_8 I=temp_LLR[3][8]
XFE_DBTC30_temp_LLR_3_7 INV1S $PINS O=FE_DBTN30_temp_LLR_3_7 I=temp_LLR[3][7]
XFE_DBTC29_temp_LLR_3_6 INV1S $PINS O=FE_DBTN29_temp_LLR_3_6 I=temp_LLR[3][6]
XFE_DBTC28_temp_LLR_3_5 INV1S $PINS O=FE_DBTN28_temp_LLR_3_5 I=temp_LLR[3][5]
XFE_DBTC27_temp_LLR_3_4 INV1S $PINS O=FE_DBTN27_temp_LLR_3_4 I=temp_LLR[3][4]
XFE_DBTC26_temp_LLR_3_3 INV1S $PINS O=FE_DBTN26_temp_LLR_3_3 I=temp_LLR[3][3]
XFE_DBTC25_temp_LLR_3_2 INV1S $PINS O=FE_DBTN25_temp_LLR_3_2 I=temp_LLR[3][2]
XFE_DBTC24_temp_LLR_3_1 INV1S $PINS O=FE_DBTN24_temp_LLR_3_1 I=temp_LLR[3][1]
XFE_DBTC23_temp_LLR_3_0 INV1S $PINS O=FE_DBTN23_temp_LLR_3_0 I=temp_LLR[3][0]
XFE_DBTC22_temp_LLR_4_11 INV1S $PINS O=FE_DBTN22_temp_LLR_4_11
+ I=temp_LLR[4][11]
XFE_DBTC21_temp_LLR_4_10 INV1S $PINS O=FE_DBTN21_temp_LLR_4_10
+ I=temp_LLR[4][10]
XFE_DBTC20_temp_LLR_4_9 INV1S $PINS O=FE_DBTN20_temp_LLR_4_9 I=temp_LLR[4][9]
XFE_DBTC19_temp_LLR_4_8 INV1S $PINS O=FE_DBTN19_temp_LLR_4_8 I=temp_LLR[4][8]
XFE_DBTC18_temp_LLR_4_7 INV1S $PINS O=FE_DBTN18_temp_LLR_4_7 I=temp_LLR[4][7]
XFE_DBTC17_temp_LLR_4_6 INV1S $PINS O=FE_DBTN17_temp_LLR_4_6 I=temp_LLR[4][6]
XFE_DBTC16_temp_LLR_4_5 INV1S $PINS O=FE_DBTN16_temp_LLR_4_5 I=temp_LLR[4][5]
XFE_DBTC15_temp_LLR_4_4 INV1S $PINS O=FE_DBTN15_temp_LLR_4_4 I=temp_LLR[4][4]
XFE_DBTC14_temp_LLR_4_3 INV1S $PINS O=FE_DBTN14_temp_LLR_4_3 I=temp_LLR[4][3]
XFE_DBTC13_temp_LLR_4_2 INV1S $PINS O=FE_DBTN13_temp_LLR_4_2 I=temp_LLR[4][2]
XFE_DBTC12_temp_LLR_4_1 INV1S $PINS O=FE_DBTN12_temp_LLR_4_1 I=temp_LLR[4][1]
XFE_DBTC11_temp_LLR_4_0 INV1S $PINS O=FE_DBTN11_temp_LLR_4_0 I=temp_LLR[4][0]
XFE_DBTC10_N923 INV1S $PINS O=FE_DBTN10_N923 I=N923
XFE_DBTC9_N915 INV1S $PINS O=FE_DBTN9_N915 I=N915
XFE_DBTC8_N914 INV1S $PINS O=FE_DBTN8_N914 I=N914
XFE_DBTC7_N913 INV1S $PINS O=FE_DBTN7_N913 I=N913
XFE_DBTC6_N843 INV1S $PINS O=FE_DBTN6_N843 I=N843
XFE_DBTC5_N842 INV1S $PINS O=FE_DBTN5_N842 I=N842
XFE_DBTC4_N841 INV1S $PINS O=FE_DBTN4_N841 I=N841
XFE_DBTC3_N577 INV1S $PINS O=FE_DBTN3_N577 I=N577
XFE_DBTC2_n694 INV1S $PINS O=FE_DBTN2_n694 I=n694
XFE_DBTC1_n711 INV1S $PINS O=FE_DBTN1_n711 I=n711
XFE_DBTC0_n712 INV1S $PINS O=FE_DBTN0_n712 I=n712
XU7 OR3B2 $PINS O=n68 I1=read_counter[2] B1=n71 B2=start_reg
XU8 AO12 $PINS O=n334 A1=FE_OFN560_FE_DBTN0_n712 B1=n72 B2=n73
XU14 ND2 $PINS O=n337 I1=n82 I2=n83
XU17 ND2 $PINS O=n338 I1=n87 I2=n88
XU20 ND2 $PINS O=n339 I1=n89 I2=n90
XU23 ND2 $PINS O=n340 I1=n91 I2=n92
XU26 ND2 $PINS O=n341 I1=n93 I2=n94
XU29 ND2 $PINS O=n342 I1=n95 I2=n96
XU32 ND2 $PINS O=n343 I1=n97 I2=n98
XU35 ND2 $PINS O=n344 I1=n99 I2=n100
XU38 ND2 $PINS O=n345 I1=n101 I2=n102
XU41 ND2 $PINS O=n346 I1=n103 I2=n104
XU44 ND2 $PINS O=n347 I1=n105 I2=n106
XU47 ND2 $PINS O=n348 I1=n107 I2=n108
XU50 ND2 $PINS O=n349 I1=n109 I2=n110
XU53 ND2 $PINS O=n350 I1=n111 I2=n112
XU56 ND2 $PINS O=n351 I1=n113 I2=n114
XU59 ND2 $PINS O=n352 I1=n115 I2=n116
XU62 ND2 $PINS O=n353 I1=n117 I2=n118
XU65 ND2 $PINS O=n354 I1=n119 I2=n120
XU68 ND2 $PINS O=n355 I1=n121 I2=n122
XU71 ND2 $PINS O=n356 I1=n123 I2=n124
XU74 ND2 $PINS O=n357 I1=n125 I2=n126
XU77 ND2 $PINS O=n358 I1=n127 I2=n128
XU80 ND2 $PINS O=n359 I1=n129 I2=n130
XU83 ND2 $PINS O=n360 I1=n131 I2=n132
XU86 ND2 $PINS O=n361 I1=n133 I2=n134
XU89 ND2 $PINS O=n362 I1=n135 I2=n136
XU92 ND2 $PINS O=n363 I1=n137 I2=n138
XU95 ND2 $PINS O=n364 I1=n139 I2=n140
XU98 ND2 $PINS O=n365 I1=n141 I2=n142
XU101 ND2 $PINS O=n366 I1=n143 I2=n144
XU104 ND2 $PINS O=n367 I1=n145 I2=n146
XU107 ND2 $PINS O=n368 I1=n147 I2=n148
XU110 ND2 $PINS O=n369 I1=n149 I2=n150
XU113 ND2 $PINS O=n370 I1=n151 I2=n152
XU116 ND2 $PINS O=n371 I1=n153 I2=n154
XU119 ND2 $PINS O=n372 I1=n155 I2=n156
XU122 ND2 $PINS O=n373 I1=n157 I2=n158
XU125 ND2 $PINS O=n374 I1=n159 I2=n160
XU128 ND2 $PINS O=n375 I1=n161 I2=n162
XU131 ND2 $PINS O=n376 I1=n163 I2=n164
XU134 ND2 $PINS O=n377 I1=n165 I2=n166
XU137 ND2 $PINS O=n378 I1=n167 I2=n168
XU140 ND2 $PINS O=n379 I1=n169 I2=n170
XU143 ND2 $PINS O=n380 I1=n171 I2=n172
XU146 ND2 $PINS O=n381 I1=n173 I2=n174
XU149 ND2 $PINS O=n382 I1=n175 I2=n176
XU152 ND2 $PINS O=n383 I1=n177 I2=n178
XU155 ND2 $PINS O=n384 I1=n179 I2=n180
XU158 ND2 $PINS O=n385 I1=n181 I2=n182
XU161 ND2 $PINS O=n386 I1=n183 I2=n184
XU164 ND2 $PINS O=n387 I1=n185 I2=n186
XU167 ND2 $PINS O=n388 I1=n187 I2=n188
XU170 ND2 $PINS O=n389 I1=n189 I2=n190
XU173 ND2 $PINS O=n390 I1=n191 I2=n192
XU176 ND2 $PINS O=n391 I1=n193 I2=n194
XU179 ND2 $PINS O=n392 I1=n195 I2=n196
XU182 ND2 $PINS O=n393 I1=n197 I2=n198
XU185 ND2 $PINS O=n394 I1=n199 I2=n200
XU188 ND2 $PINS O=n395 I1=n201 I2=n202
XU191 ND2 $PINS O=n396 I1=n203 I2=n204
XU353 AO222 $PINS O=n490 A1=N577 A2=FE_OFN1438_n275 B1=vec0_1D[23]
+ B2=FE_OFN641_n86 C1=N995 C2=FE_OFN577_FE_DBTN0_n712
XU354 AO222 $PINS O=n491 A1=N569 A2=FE_OFN1438_n275 B1=vec0_1D[22]
+ B2=FE_OFN647_n86 C1=N987 C2=FE_OFN577_FE_DBTN0_n712
XU355 AO222 $PINS O=n492 A1=N568 A2=FE_OFN1438_n275 B1=vec0_1D[21]
+ B2=FE_OFN647_n86 C1=N986 C2=FE_OFN583_FE_DBTN0_n712
XU356 AO222 $PINS O=n493 A1=N567 A2=FE_OFN1438_n275 B1=vec0_1D[20]
+ B2=FE_OFN647_n86 C1=FE_OFN721_N985 C2=FE_OFN583_FE_DBTN0_n712
XU366 AO222 $PINS O=n498 A1=N613 A2=n275 B1=vec0_1D[15] B2=FE_OFN654_n86
+ C1=N577 C2=FE_OFN580_FE_DBTN0_n712
XU367 AO222 $PINS O=n499 A1=N605 A2=FE_OFN1439_n275 B1=vec0_1D[14]
+ B2=FE_OFN656_n86 C1=N569 C2=FE_OFN594_FE_DBTN0_n712
XU368 AO222 $PINS O=n500 A1=N604 A2=FE_OFN1439_n275 B1=vec0_1D[13]
+ B2=FE_OFN656_n86 C1=N568 C2=FE_OFN594_FE_DBTN0_n712
XU369 AO222 $PINS O=n501 A1=FE_OFN722_N603 A2=FE_OFN1439_n275 B1=vec0_1D[12]
+ B2=FE_OFN658_n86 C1=FE_OFN723_N567 C2=FE_OFN594_FE_DBTN0_n712
XU370 AO222 $PINS O=n502 A1=N995 A2=n275 B1=vec0_1D[11] B2=FE_OFN654_n86
+ C1=N613 C2=FE_OFN586_FE_DBTN0_n712
XU371 AO222 $PINS O=n503 A1=N987 A2=FE_OFN1439_n275 B1=vec0_1D[10]
+ B2=FE_OFN656_n86 C1=N605 C2=FE_OFN594_FE_DBTN0_n712
XU372 AO222 $PINS O=n504 A1=N986 A2=FE_OFN1439_n275 B1=vec0_1D[9]
+ B2=FE_OFN656_n86 C1=N604 C2=FE_OFN594_FE_DBTN0_n712
XU373 AO222 $PINS O=n505 A1=N985 A2=FE_OFN1439_n275 B1=vec0_1D[8]
+ B2=FE_OFN658_n86 C1=N603 C2=FE_OFN597_FE_DBTN0_n712
XU374 AO22 $PINS O=n506 A1=FE_OFN1445_n275 A2=vec0[5][3] B1=vec0_1D[7]
+ B2=FE_OFN657_n86
XU375 AO22 $PINS O=n507 A1=FE_OFN1446_n275 A2=vec0[5][2] B1=vec0_1D[6]
+ B2=FE_OFN657_n86
XU376 AO22 $PINS O=n508 A1=FE_OFN1446_n275 A2=vec0[5][1] B1=vec0_1D[5]
+ B2=FE_OFN659_n86
XU377 AO22 $PINS O=n509 A1=FE_OFN1446_n275 A2=vec0[5][0] B1=vec0_1D[4]
+ B2=FE_OFN659_n86
XU378 AO22 $PINS O=n510 A1=FE_OFN1445_n275 A2=vec0[6][3] B1=vec0_1D[3]
+ B2=FE_OFN659_n86
XU379 AO22 $PINS O=n511 A1=FE_OFN1446_n275 A2=vec0[6][2] B1=vec0_1D[2]
+ B2=FE_OFN659_n86
XU380 AO22 $PINS O=n512 A1=FE_OFN1446_n275 A2=vec0[6][1] B1=vec0_1D[1]
+ B2=FE_OFN659_n86
XU381 AO22 $PINS O=n513 A1=FE_OFN1446_n275 A2=vec0[6][0] B1=vec0_1D[0]
+ B2=FE_OFN659_n86
XU387 AO222 $PINS O=n518 A1=vec1[0][3] A2=FE_OFN1444_n275 B1=vec1_1D[27]
+ B2=FE_OFN655_n86 C1=vec2[0][3] C2=FE_OFN589_FE_DBTN0_n712
XU388 AO222 $PINS O=n519 A1=vec1[0][2] A2=FE_OFN1445_n275 B1=vec1_1D[26]
+ B2=FE_OFN657_n86 C1=vec2[0][2] C2=FE_OFN589_FE_DBTN0_n712
XU389 AO222 $PINS O=n520 A1=vec1[0][1] A2=FE_OFN1445_n275 B1=vec1_1D[25]
+ B2=FE_OFN657_n86 C1=vec2[0][1] C2=FE_OFN589_FE_DBTN0_n712
XU390 AO222 $PINS O=n521 A1=vec1[0][0] A2=FE_OFN1445_n275 B1=vec1_1D[24]
+ B2=FE_OFN657_n86 C1=vec2[0][0] C2=FE_OFN589_FE_DBTN0_n712
XU391 AO222 $PINS O=n522 A1=vec1[1][3] A2=FE_OFN1444_n275 B1=vec1_1D[23]
+ B2=FE_OFN655_n86 C1=vec2[1][3] C2=FE_OFN584_FE_DBTN0_n712
XU392 AO222 $PINS O=n523 A1=vec1[1][2] A2=FE_OFN1444_n275 B1=vec1_1D[22]
+ B2=FE_OFN655_n86 C1=vec2[1][2] C2=FE_OFN584_FE_DBTN0_n712
XU393 AO222 $PINS O=n524 A1=vec1[1][1] A2=FE_OFN1444_n275 B1=vec1_1D[21]
+ B2=FE_OFN655_n86 C1=vec2[1][1] C2=FE_OFN589_FE_DBTN0_n712
XU394 AO222 $PINS O=n525 A1=vec1[1][0] A2=FE_OFN1444_n275 B1=vec1_1D[20]
+ B2=FE_OFN655_n86 C1=vec2[1][0] C2=FE_OFN589_FE_DBTN0_n712
XU395 AO222 $PINS O=n526 A1=vec1[2][3] A2=FE_OFN1440_n275 B1=vec1_1D[19]
+ B2=FE_OFN650_n86 C1=vec2[2][3] C2=FE_OFN585_FE_DBTN0_n712
XU396 AO222 $PINS O=n527 A1=vec1[2][2] A2=FE_OFN1440_n275 B1=vec1_1D[18]
+ B2=FE_OFN650_n86 C1=vec2[2][2] C2=FE_OFN585_FE_DBTN0_n712
XU397 AO222 $PINS O=n528 A1=vec1[2][1] A2=FE_OFN1440_n275 B1=vec1_1D[17]
+ B2=FE_OFN650_n86 C1=vec2[2][1] C2=FE_OFN585_FE_DBTN0_n712
XU398 AO222 $PINS O=n529 A1=vec1[2][0] A2=FE_OFN1440_n275 B1=vec1_1D[16]
+ B2=FE_OFN650_n86 C1=vec2[2][0] C2=FE_OFN585_FE_DBTN0_n712
XU399 AO222 $PINS O=n530 A1=vec1[3][3] A2=FE_OFN1441_n275 B1=vec1_1D[15]
+ B2=FE_OFN643_n86 C1=vec2[3][3] C2=FE_OFN567_FE_DBTN0_n712
XU400 AO222 $PINS O=n531 A1=vec1[3][2] A2=FE_OFN1441_n275 B1=vec1_1D[14]
+ B2=FE_OFN643_n86 C1=vec2[3][2] C2=FE_OFN567_FE_DBTN0_n712
XU401 AO222 $PINS O=n532 A1=vec1[3][1] A2=FE_OFN1440_n275 B1=vec1_1D[13]
+ B2=FE_OFN650_n86 C1=vec2[3][1] C2=FE_OFN585_FE_DBTN0_n712
XU402 AO222 $PINS O=n533 A1=vec1[3][0] A2=FE_OFN1440_n275 B1=vec1_1D[12]
+ B2=FE_OFN650_n86 C1=vec2[3][0] C2=FE_OFN585_FE_DBTN0_n712
XU403 AO222 $PINS O=n534 A1=vec1[4][3] A2=FE_OFN1441_n275 B1=vec1_1D[11]
+ B2=FE_OFN649_n86 C1=vec2[4][3] C2=FE_OFN567_FE_DBTN0_n712
XU404 AO222 $PINS O=n535 A1=vec1[4][2] A2=FE_OFN1441_n275 B1=vec1_1D[10]
+ B2=FE_OFN649_n86 C1=vec2[4][2] C2=FE_OFN567_FE_DBTN0_n712
XU405 AO222 $PINS O=n536 A1=vec1[4][1] A2=FE_OFN1441_n275 B1=vec1_1D[9]
+ B2=FE_OFN643_n86 C1=vec2[4][1] C2=FE_OFN579_FE_DBTN0_n712
XU406 AO222 $PINS O=n537 A1=vec1[4][0] A2=FE_OFN1442_n275 B1=vec1_1D[8]
+ B2=FE_OFN643_n86 C1=vec2[4][0] C2=FE_OFN579_FE_DBTN0_n712
XU407 AO222 $PINS O=n538 A1=vec1[5][3] A2=FE_OFN1442_n275 B1=vec1_1D[7]
+ B2=FE_OFN649_n86 C1=vec2[5][3] C2=FE_OFN578_FE_DBTN0_n712
XU408 AO222 $PINS O=n539 A1=vec1[5][2] A2=FE_OFN1442_n275 B1=vec1_1D[6]
+ B2=FE_OFN649_n86 C1=vec2[5][2] C2=FE_OFN578_FE_DBTN0_n712
XU409 AO222 $PINS O=n540 A1=vec1[5][1] A2=FE_OFN1442_n275 B1=vec1_1D[5]
+ B2=FE_OFN649_n86 C1=vec2[5][1] C2=FE_OFN578_FE_DBTN0_n712
XU410 AO222 $PINS O=n541 A1=vec1[5][0] A2=FE_OFN1443_n275 B1=vec1_1D[4]
+ B2=FE_OFN653_n86 C1=vec2[5][0] C2=FE_OFN578_FE_DBTN0_n712
XU411 AO222 $PINS O=n542 A1=vec1[6][3] A2=FE_OFN1443_n275 B1=vec1_1D[3]
+ B2=FE_OFN653_n86 C1=vec2[6][3] C2=FE_OFN578_FE_DBTN0_n712
XU412 AO222 $PINS O=n543 A1=vec1[6][2] A2=FE_OFN1443_n275 B1=vec1_1D[2]
+ B2=FE_OFN653_n86 C1=vec2[6][2] C2=FE_OFN584_FE_DBTN0_n712
XU413 AO222 $PINS O=n544 A1=vec1[6][1] A2=FE_OFN1443_n275 B1=vec1_1D[1]
+ B2=FE_OFN653_n86 C1=vec2[6][1] C2=FE_OFN584_FE_DBTN0_n712
XU414 AO222 $PINS O=n545 A1=vec1[6][0] A2=FE_OFN1443_n275 B1=vec1_1D[0]
+ B2=FE_OFN653_n86 C1=vec2[6][0] C2=FE_OFN584_FE_DBTN0_n712
XU415 AO12 $PINS O=n86 A1=n286 B1=n285 B2=n943
XU418 ND2 $PINS O=n286 I1=n267 I2=n288
XU419 AO12 $PINS O=n288 A1=n967 B1=start_reg B2=read_counter[2]
XU526 AN3B1 $PINS O=n309 I1=n310 I2=start_reg B1=n285
XU528 AO22 $PINS O=n626 A1=FE_OFN596_FE_DBTN0_n712 A2=N626 B1=temp_LLR1[4][0]
+ B2=FE_OFN719_n312
XU529 AO22 $PINS O=n627 A1=FE_OFN596_FE_DBTN0_n712 A2=N627 B1=temp_LLR1[4][1]
+ B2=FE_OFN719_n312
XU530 AO22 $PINS O=n628 A1=FE_OFN593_FE_DBTN0_n712 A2=N628 B1=temp_LLR1[4][2]
+ B2=FE_OFN719_n312
XU531 AO22 $PINS O=n629 A1=FE_OFN586_FE_DBTN0_n712 A2=N629 B1=temp_LLR1[4][3]
+ B2=FE_OFN715_n312
XU532 AO22 $PINS O=n630 A1=FE_OFN573_FE_DBTN0_n712 A2=N630 B1=temp_LLR1[4][4]
+ B2=FE_OFN715_n312
XU533 AO22 $PINS O=n631 A1=FE_OFN573_FE_DBTN0_n712 A2=N631 B1=temp_LLR1[4][5]
+ B2=FE_OFN715_n312
XU534 AO22 $PINS O=n632 A1=FE_OFN568_FE_DBTN0_n712 A2=N632 B1=temp_LLR1[4][6]
+ B2=FE_OFN712_n312
XU535 AO22 $PINS O=n633 A1=FE_OFN568_FE_DBTN0_n712 A2=N633 B1=temp_LLR1[4][7]
+ B2=FE_OFN712_n312
XU536 AO22 $PINS O=n634 A1=FE_OFN564_FE_DBTN0_n712 A2=N634 B1=temp_LLR1[4][8]
+ B2=FE_OFN709_n312
XU537 AO22 $PINS O=n635 A1=FE_OFN561_FE_DBTN0_n712 A2=N635 B1=temp_LLR1[4][9]
+ B2=FE_OFN709_n312
XU538 AO22 $PINS O=n636 A1=FE_OFN560_FE_DBTN0_n712 A2=N636 B1=temp_LLR1[4][10]
+ B2=n312
XU539 AO22 $PINS O=n637 A1=FE_OFN562_FE_DBTN0_n712 A2=N637 B1=n312
+ B2=temp_LLR1[4][11]
XU540 AO22 $PINS O=n638 A1=FE_OFN596_FE_DBTN0_n712 A2=N590 B1=temp_LLR1[3][0]
+ B2=FE_OFN719_n312
XU541 AO22 $PINS O=n639 A1=FE_OFN596_FE_DBTN0_n712 A2=N591 B1=temp_LLR1[3][1]
+ B2=FE_OFN719_n312
XU542 AO22 $PINS O=n640 A1=FE_OFN593_FE_DBTN0_n712 A2=N592 B1=temp_LLR1[3][2]
+ B2=FE_OFN719_n312
XU543 AO22 $PINS O=n641 A1=FE_OFN580_FE_DBTN0_n712 A2=N593 B1=temp_LLR1[3][3]
+ B2=FE_OFN715_n312
XU544 AO22 $PINS O=n642 A1=FE_OFN580_FE_DBTN0_n712 A2=N594 B1=temp_LLR1[3][4]
+ B2=FE_OFN715_n312
XU545 AO22 $PINS O=n643 A1=FE_OFN573_FE_DBTN0_n712 A2=N595 B1=temp_LLR1[3][5]
+ B2=FE_OFN712_n312
XU546 AO22 $PINS O=n644 A1=FE_OFN568_FE_DBTN0_n712 A2=N596 B1=temp_LLR1[3][6]
+ B2=FE_OFN712_n312
XU547 AO22 $PINS O=n645 A1=FE_OFN564_FE_DBTN0_n712 A2=N597 B1=temp_LLR1[3][7]
+ B2=FE_OFN712_n312
XU548 AO22 $PINS O=n646 A1=FE_OFN561_FE_DBTN0_n712 A2=N598 B1=temp_LLR1[3][8]
+ B2=FE_OFN709_n312
XU549 AO22 $PINS O=n647 A1=FE_OFN561_FE_DBTN0_n712 A2=N599 B1=temp_LLR1[3][9]
+ B2=FE_OFN711_n312
XU550 AO22 $PINS O=n648 A1=FE_OFN560_FE_DBTN0_n712 A2=N600 B1=temp_LLR1[3][10]
+ B2=n312
XU551 AO22 $PINS O=n649 A1=FE_OFN562_FE_DBTN0_n712 A2=N601 B1=FE_OFN710_n312
+ B2=temp_LLR1[3][11]
XU552 AO22 $PINS O=n650 A1=FE_OFN592_FE_DBTN0_n712 A2=N554 B1=temp_LLR1[2][0]
+ B2=FE_OFN720_n312
XU553 AO22 $PINS O=n651 A1=FE_OFN592_FE_DBTN0_n712 A2=N555 B1=temp_LLR1[2][1]
+ B2=FE_OFN720_n312
XU554 AO22 $PINS O=n652 A1=FE_OFN582_FE_DBTN0_n712 A2=N556 B1=temp_LLR1[2][2]
+ B2=FE_OFN720_n312
XU555 AO22 $PINS O=n653 A1=FE_OFN582_FE_DBTN0_n712 A2=N557 B1=temp_LLR1[2][3]
+ B2=FE_OFN718_n312
XU556 AO22 $PINS O=n654 A1=FE_OFN576_FE_DBTN0_n712 A2=N558 B1=temp_LLR1[2][4]
+ B2=FE_OFN718_n312
XU557 AO22 $PINS O=n655 A1=FE_OFN570_FE_DBTN0_n712 A2=N559 B1=temp_LLR1[2][5]
+ B2=FE_OFN718_n312
XU558 AO22 $PINS O=n656 A1=FE_OFN591_FE_DBTN0_n712 A2=N560 B1=temp_LLR1[2][6]
+ B2=FE_OFN716_n312
XU559 AO22 $PINS O=n657 A1=FE_OFN591_FE_DBTN0_n712 A2=N561 B1=temp_LLR1[2][7]
+ B2=FE_OFN716_n312
XU560 AO22 $PINS O=n658 A1=FE_OFN581_FE_DBTN0_n712 A2=N562 B1=temp_LLR1[2][8]
+ B2=FE_OFN713_n312
XU561 AO22 $PINS O=n659 A1=FE_OFN581_FE_DBTN0_n712 A2=N563 B1=temp_LLR1[2][9]
+ B2=FE_OFN713_n312
XU562 AO22 $PINS O=n660 A1=FE_OFN574_FE_DBTN0_n712 A2=N564 B1=temp_LLR1[2][10]
+ B2=FE_OFN713_n312
XU563 AO22 $PINS O=n661 A1=FE_OFN574_FE_DBTN0_n712 A2=N565 B1=FE_OFN710_n312
+ B2=temp_LLR1[2][11]
XU564 AO22 $PINS O=n662 A1=FE_OFN583_FE_DBTN0_n712 A2=N518 B1=temp_LLR1[1][0]
+ B2=FE_OFN717_n312
XU565 AO22 $PINS O=n663 A1=FE_OFN583_FE_DBTN0_n712 A2=N519 B1=temp_LLR1[1][1]
+ B2=FE_OFN717_n312
XU566 AO22 $PINS O=n664 A1=FE_OFN577_FE_DBTN0_n712 A2=N520 B1=temp_LLR1[1][2]
+ B2=FE_OFN717_n312
XU567 AO22 $PINS O=n665 A1=FE_OFN577_FE_DBTN0_n712 A2=N521 B1=temp_LLR1[1][3]
+ B2=FE_OFN717_n312
XU568 AO22 $PINS O=n666 A1=FE_OFN571_FE_DBTN0_n712 A2=N522 B1=temp_LLR1[1][4]
+ B2=FE_OFN717_n312
XU569 AO22 $PINS O=n667 A1=FE_OFN571_FE_DBTN0_n712 A2=N523 B1=temp_LLR1[1][5]
+ B2=FE_OFN717_n312
XU570 AO22 $PINS O=n668 A1=FE_OFN566_FE_DBTN0_n712 A2=N524 B1=temp_LLR1[1][6]
+ B2=FE_OFN711_n312
XU571 AO22 $PINS O=n669 A1=FE_OFN566_FE_DBTN0_n712 A2=N525 B1=temp_LLR1[1][7]
+ B2=FE_OFN711_n312
XU572 AO22 $PINS O=n670 A1=FE_OFN563_FE_DBTN0_n712 A2=N526 B1=temp_LLR1[1][8]
+ B2=FE_OFN711_n312
XU573 AO22 $PINS O=n671 A1=FE_OFN563_FE_DBTN0_n712 A2=N527 B1=temp_LLR1[1][9]
+ B2=FE_OFN711_n312
XU574 AO22 $PINS O=n672 A1=FE_OFN562_FE_DBTN0_n712 A2=N528 B1=temp_LLR1[1][10]
+ B2=n312
XU575 AO22 $PINS O=n673 A1=FE_OFN562_FE_DBTN0_n712 A2=N529 B1=FE_OFN710_n312
+ B2=temp_LLR1[1][11]
XU576 AO22 $PINS O=n674 A1=FE_OFN588_FE_DBTN0_n712 A2=N482 B1=temp_LLR1[0][0]
+ B2=FE_OFN720_n312
XU577 AO22 $PINS O=n675 A1=FE_OFN592_FE_DBTN0_n712 A2=N483 B1=temp_LLR1[0][1]
+ B2=FE_OFN720_n312
XU578 AO22 $PINS O=n676 A1=FE_OFN588_FE_DBTN0_n712 A2=N484 B1=temp_LLR1[0][2]
+ B2=FE_OFN720_n312
XU579 AO22 $PINS O=n677 A1=FE_OFN582_FE_DBTN0_n712 A2=N485 B1=temp_LLR1[0][3]
+ B2=FE_OFN718_n312
XU580 AO22 $PINS O=n678 A1=FE_OFN576_FE_DBTN0_n712 A2=N486 B1=temp_LLR1[0][4]
+ B2=FE_OFN716_n312
XU581 AO22 $PINS O=n679 A1=FE_OFN570_FE_DBTN0_n712 A2=N487 B1=temp_LLR1[0][5]
+ B2=FE_OFN716_n312
XU582 AO22 $PINS O=n680 A1=FE_OFN591_FE_DBTN0_n712 A2=N488 B1=temp_LLR1[0][6]
+ B2=FE_OFN716_n312
XU583 AO22 $PINS O=n681 A1=FE_OFN587_FE_DBTN0_n712 A2=N489 B1=temp_LLR1[0][7]
+ B2=FE_OFN716_n312
XU584 AO22 $PINS O=n682 A1=FE_OFN581_FE_DBTN0_n712 A2=N490 B1=temp_LLR1[0][8]
+ B2=FE_OFN713_n312
XU585 AO22 $PINS O=n683 A1=FE_OFN574_FE_DBTN0_n712 A2=N491 B1=temp_LLR1[0][9]
+ B2=FE_OFN713_n312
XU586 AO22 $PINS O=n684 A1=FE_OFN575_FE_DBTN0_n712 A2=N492 B1=temp_LLR1[0][10]
+ B2=FE_OFN710_n312
XU589 ND2 $PINS O=n267 I1=state[0] I2=state[1]
XU590 ND2 $PINS O=n285 I1=n966 I2=n313
XU606 ND2 $PINS O=n322 I1=n325 I2=n326
XU617 ND2 $PINS O=n269 I1=n967 I2=n313
XU618 AO22 $PINS O=n692 A1=FE_OFN575_FE_DBTN0_n712 A2=N493 B1=FE_OFN710_n312
+ B2=temp_LLR1[0][11]
XU627 ND2 $PINS O=n313 I1=state[0] I2=n968
Xsiso1 Siso $PINS reset_n_i=FE_OFN598_i_reset_n_i read_en_i=dec1_begin
+ sys_i[27]=vec0_1D[27] sys_i[26]=vec0_1D[26] sys_i[25]=vec0_1D[25]
+ sys_i[24]=vec0_1D[24] sys_i[23]=vec0_1D[23] sys_i[22]=vec0_1D[22]
+ sys_i[21]=vec0_1D[21] sys_i[20]=vec0_1D[20] sys_i[19]=vec0_1D[19]
+ sys_i[18]=vec0_1D[18] sys_i[17]=vec0_1D[17] sys_i[16]=vec0_1D[16]
+ sys_i[15]=vec0_1D[15] sys_i[14]=vec0_1D[14] sys_i[13]=vec0_1D[13]
+ sys_i[12]=vec0_1D[12] sys_i[11]=vec0_1D[11] sys_i[10]=vec0_1D[10]
+ sys_i[9]=vec0_1D[9] sys_i[8]=vec0_1D[8] sys_i[7]=vec0_1D[7] sys_i[6]=vec0_1D[6]
+ sys_i[5]=vec0_1D[5] sys_i[4]=vec0_1D[4] sys_i[3]=vec0_1D[3] sys_i[2]=vec0_1D[2]
+ sys_i[1]=vec0_1D[1] sys_i[0]=vec0_1D[0] enc_i[27]=vec1_1D[27]
+ enc_i[26]=vec1_1D[26] enc_i[25]=vec1_1D[25] enc_i[24]=vec1_1D[24]
+ enc_i[23]=vec1_1D[23] enc_i[22]=vec1_1D[22] enc_i[21]=vec1_1D[21]
+ enc_i[20]=vec1_1D[20] enc_i[19]=vec1_1D[19] enc_i[18]=vec1_1D[18]
+ enc_i[17]=vec1_1D[17] enc_i[16]=vec1_1D[16] enc_i[15]=vec1_1D[15]
+ enc_i[14]=vec1_1D[14] enc_i[13]=vec1_1D[13] enc_i[12]=vec1_1D[12]
+ enc_i[11]=vec1_1D[11] enc_i[10]=vec1_1D[10] enc_i[9]=vec1_1D[9]
+ enc_i[8]=vec1_1D[8] enc_i[7]=vec1_1D[7] enc_i[6]=vec1_1D[6] enc_i[5]=vec1_1D[5]
+ enc_i[4]=vec1_1D[4] enc_i[3]=vec1_1D[3] enc_i[2]=vec1_1D[2] enc_i[1]=vec1_1D[1]
+ enc_i[0]=vec1_1D[0] ext_i[83]=vec2_1D[83] ext_i[82]=vec2_1D[82]
+ ext_i[81]=vec2_1D[81] ext_i[80]=vec2_1D[80] ext_i[79]=vec2_1D[79]
+ ext_i[78]=vec2_1D[78] ext_i[77]=vec2_1D[77] ext_i[76]=vec2_1D[76]
+ ext_i[75]=vec2_1D[75] ext_i[74]=vec2_1D[74] ext_i[73]=vec2_1D[73]
+ ext_i[72]=vec2_1D[72] ext_i[71]=vec2_1D[71] ext_i[70]=vec2_1D[70]
+ ext_i[69]=vec2_1D[69] ext_i[68]=vec2_1D[68] ext_i[67]=vec2_1D[67]
+ ext_i[66]=vec2_1D[66] ext_i[65]=vec2_1D[65] ext_i[64]=vec2_1D[64]
+ ext_i[63]=vec2_1D[63] ext_i[62]=vec2_1D[62] ext_i[61]=vec2_1D[61]
+ ext_i[60]=vec2_1D[60] ext_i[59]=vec2_1D[59] ext_i[58]=vec2_1D[58]
+ ext_i[57]=vec2_1D[57] ext_i[56]=vec2_1D[56] ext_i[55]=vec2_1D[55]
+ ext_i[54]=vec2_1D[54] ext_i[53]=vec2_1D[53] ext_i[52]=vec2_1D[52]
+ ext_i[51]=vec2_1D[51] ext_i[50]=vec2_1D[50] ext_i[49]=vec2_1D[49]
+ ext_i[48]=vec2_1D[48] ext_i[47]=vec2_1D[47] ext_i[46]=vec2_1D[46]
+ ext_i[45]=vec2_1D[45] ext_i[44]=vec2_1D[44] ext_i[43]=vec2_1D[43]
+ ext_i[42]=vec2_1D[42] ext_i[41]=vec2_1D[41] ext_i[40]=vec2_1D[40]
+ ext_i[39]=vec2_1D[39] ext_i[38]=vec2_1D[38] ext_i[37]=vec2_1D[37]
+ ext_i[36]=vec2_1D[36] ext_i[35]=vec2_1D[35] ext_i[34]=vec2_1D[34]
+ ext_i[33]=vec2_1D[33] ext_i[32]=vec2_1D[32] ext_i[31]=vec2_1D[31]
+ ext_i[30]=vec2_1D[30] ext_i[29]=vec2_1D[29] ext_i[28]=vec2_1D[28]
+ ext_i[27]=vec2_1D[27] ext_i[26]=vec2_1D[26] ext_i[25]=vec2_1D[25]
+ ext_i[24]=vec2_1D[24] ext_i[23]=n693 ext_i[22]=n693 ext_i[21]=n693
+ ext_i[20]=n693 ext_i[19]=n693 ext_i[18]=n693 ext_i[17]=n693 ext_i[16]=n693
+ ext_i[15]=n693 ext_i[14]=n693 ext_i[13]=n693 ext_i[12]=n693 ext_i[11]=n693
+ ext_i[10]=n693 ext_i[9]=n693 ext_i[8]=n693 ext_i[7]=n693 ext_i[6]=n693
+ ext_i[5]=n693 ext_i[4]=n693 ext_i[3]=n693 ext_i[2]=n693 ext_i[1]=n693
+ ext_i[0]=n693 data_o[83]=siso1_o[83] data_o[82]=siso1_o[82]
+ data_o[81]=siso1_o[81] data_o[80]=siso1_o[80] data_o[79]=siso1_o[79]
+ data_o[78]=siso1_o[78] data_o[77]=siso1_o[77] data_o[76]=siso1_o[76]
+ data_o[75]=siso1_o[75] data_o[74]=siso1_o[74] data_o[73]=siso1_o[73]
+ data_o[72]=siso1_o[72] data_o[71]=siso1_o[71] data_o[70]=siso1_o[70]
+ data_o[69]=siso1_o[69] data_o[68]=siso1_o[68] data_o[67]=siso1_o[67]
+ data_o[66]=siso1_o[66] data_o[65]=siso1_o[65] data_o[64]=siso1_o[64]
+ data_o[63]=siso1_o[63] data_o[62]=siso1_o[62] data_o[61]=siso1_o[61]
+ data_o[60]=siso1_o[60] data_o[59]=siso1_o[59] data_o[58]=siso1_o[58]
+ data_o[57]=siso1_o[57] data_o[56]=siso1_o[56] data_o[55]=siso1_o[55]
+ data_o[54]=siso1_o[54] data_o[53]=siso1_o[53] data_o[52]=siso1_o[52]
+ data_o[51]=siso1_o[51] data_o[50]=siso1_o[50] data_o[49]=siso1_o[49]
+ data_o[48]=siso1_o[48] data_o[47]=siso1_o[47] data_o[46]=siso1_o[46]
+ data_o[45]=siso1_o[45] data_o[44]=siso1_o[44] data_o[43]=siso1_o[43]
+ data_o[42]=siso1_o[42] data_o[41]=siso1_o[41] data_o[40]=siso1_o[40]
+ data_o[39]=siso1_o[39] data_o[38]=siso1_o[38] data_o[37]=siso1_o[37]
+ data_o[36]=siso1_o[36] data_o[35]=siso1_o[35] data_o[34]=siso1_o[34]
+ data_o[33]=siso1_o[33] data_o[32]=siso1_o[32] data_o[31]=siso1_o[31]
+ data_o[30]=siso1_o[30] data_o[29]=siso1_o[29] data_o[28]=siso1_o[28]
+ data_o[27]=siso1_o[27] data_o[26]=siso1_o[26] data_o[25]=siso1_o[25]
+ data_o[24]=siso1_o[24] data_o[23]=SYNOPSYS_UNCONNECTED__0
+ data_o[22]=SYNOPSYS_UNCONNECTED__1 data_o[21]=SYNOPSYS_UNCONNECTED__2
+ data_o[20]=SYNOPSYS_UNCONNECTED__3 data_o[19]=SYNOPSYS_UNCONNECTED__4
+ data_o[18]=SYNOPSYS_UNCONNECTED__5 data_o[17]=SYNOPSYS_UNCONNECTED__6
+ data_o[16]=SYNOPSYS_UNCONNECTED__7 data_o[15]=SYNOPSYS_UNCONNECTED__8
+ data_o[14]=SYNOPSYS_UNCONNECTED__9 data_o[13]=SYNOPSYS_UNCONNECTED__10
+ data_o[12]=SYNOPSYS_UNCONNECTED__11 data_o[11]=SYNOPSYS_UNCONNECTED__12
+ data_o[10]=SYNOPSYS_UNCONNECTED__13 data_o[9]=SYNOPSYS_UNCONNECTED__14
+ data_o[8]=SYNOPSYS_UNCONNECTED__15 data_o[7]=SYNOPSYS_UNCONNECTED__16
+ data_o[6]=SYNOPSYS_UNCONNECTED__17 data_o[5]=SYNOPSYS_UNCONNECTED__18
+ data_o[4]=SYNOPSYS_UNCONNECTED__19 data_o[3]=SYNOPSYS_UNCONNECTED__20
+ data_o[2]=SYNOPSYS_UNCONNECTED__21 data_o[1]=SYNOPSYS_UNCONNECTED__22
+ data_o[0]=SYNOPSYS_UNCONNECTED__23 finish=dec1_finish
+ FE_OFN137_i_reset_n_i=FE_OFN494_i_reset_n_i
+ FE_OFN136_i_reset_n_i=FE_OFN491_i_reset_n_i
+ FE_OFN135_i_reset_n_i=FE_OFN489_i_reset_n_i
+ FE_OFN134_i_reset_n_i=FE_OFN485_i_reset_n_i
+ FE_OFN133_i_reset_n_i=FE_OFN477_i_reset_n_i
+ FE_OFN132_i_reset_n_i=FE_OFN475_i_reset_n_i
+ FE_OFN131_i_reset_n_i=FE_OFN464_i_reset_n_i
+ FE_OFN130_i_reset_n_i=FE_OFN460_i_reset_n_i
+ FE_OFN129_i_reset_n_i=FE_OFN440_i_reset_n_i
+ FE_OFN128_i_reset_n_i=FE_OFN439_i_reset_n_i
+ FE_OFN127_i_reset_n_i=FE_OFN438_i_reset_n_i
+ FE_OFN126_i_reset_n_i=FE_OFN437_i_reset_n_i
+ FE_OFN125_i_reset_n_i=FE_OFN436_i_reset_n_i
+ FE_OFN124_i_reset_n_i=FE_OFN435_i_reset_n_i
+ FE_OFN123_i_reset_n_i=FE_OFN433_i_reset_n_i
+ FE_OFN122_i_reset_n_i=FE_OFN432_i_reset_n_i
+ FE_OFN121_i_reset_n_i=FE_OFN430_i_reset_n_i
+ FE_OFN120_i_reset_n_i=FE_OFN429_i_reset_n_i
+ FE_OFN119_i_reset_n_i=FE_OFN428_i_reset_n_i
+ FE_OFN118_i_reset_n_i=FE_OFN427_i_reset_n_i
+ FE_OFN117_i_reset_n_i=FE_OFN426_i_reset_n_i
+ FE_OFN116_i_reset_n_i=FE_OFN424_i_reset_n_i
+ FE_OFN115_i_reset_n_i=FE_OFN423_i_reset_n_i
+ FE_OFN114_i_reset_n_i=FE_OFN422_i_reset_n_i
+ FE_OFN113_i_reset_n_i=FE_OFN418_i_reset_n_i
+ FE_OFN112_i_reset_n_i=FE_OFN416_i_reset_n_i
+ FE_OFN111_i_reset_n_i=FE_OFN402_i_reset_n_i
+ FE_OFN110_i_reset_n_i=FE_OFN397_i_reset_n_i
+ FE_OFN109_i_reset_n_i=FE_OFN378_i_reset_n_i
+ FE_OFN108_i_reset_n_i=FE_OFN376_i_reset_n_i
+ FE_OFN107_i_reset_n_i=FE_OFN375_i_reset_n_i
+ FE_OFN106_i_reset_n_i=FE_OFN374_i_reset_n_i
+ FE_OFN105_i_reset_n_i=FE_OFN373_i_reset_n_i
+ FE_OFN104_i_reset_n_i=FE_OFN372_i_reset_n_i
+ FE_OFN103_i_reset_n_i=FE_OFN371_i_reset_n_i
+ FE_OFN102_i_reset_n_i=FE_OFN368_i_reset_n_i
+ FE_OFN101_i_reset_n_i=FE_OFN367_i_reset_n_i
+ FE_OFN100_i_reset_n_i=FE_OFN366_i_reset_n_i
+ FE_OFN99_i_reset_n_i=FE_OFN365_i_reset_n_i
+ FE_OFN98_i_reset_n_i=FE_OFN363_i_reset_n_i
+ FE_OFN97_i_reset_n_i=FE_OFN362_i_reset_n_i
+ FE_OFN96_i_reset_n_i=FE_OFN360_i_reset_n_i
+ FE_OFN95_i_reset_n_i=FE_OFN358_i_reset_n_i
+ FE_OFN94_i_reset_n_i=FE_OFN357_i_reset_n_i
+ FE_OFN93_i_reset_n_i=FE_OFN356_i_reset_n_i
+ FE_OFN92_i_reset_n_i=FE_OFN344_i_reset_n_i
+ FE_OFN91_i_reset_n_i=FE_OFN338_i_reset_n_i
+ FE_OFN90_i_reset_n_i=FE_OFN328_i_reset_n_i
+ FE_OFN89_i_reset_n_i=FE_OFN327_i_reset_n_i
+ FE_OFN88_i_reset_n_i=FE_OFN324_i_reset_n_i
+ FE_OFN87_i_reset_n_i=FE_OFN319_i_reset_n_i
+ FE_OFN86_i_reset_n_i=FE_OFN317_i_reset_n_i
+ FE_OFN85_i_reset_n_i=FE_OFN316_i_reset_n_i
+ FE_OFN84_i_reset_n_i=FE_OFN312_i_reset_n_i
+ FE_OFN83_i_reset_n_i=FE_OFN311_i_reset_n_i
+ FE_OFN82_i_reset_n_i=FE_OFN309_i_reset_n_i
+ FE_OFN81_i_reset_n_i=FE_OFN305_i_reset_n_i
+ FE_OFN80_i_reset_n_i=FE_OFN303_i_reset_n_i
+ FE_OFN79_i_reset_n_i=FE_OFN302_i_reset_n_i
+ FE_OFN78_i_reset_n_i=FE_OFN299_i_reset_n_i
+ FE_OFN77_i_reset_n_i=FE_OFN293_i_reset_n_i
+ FE_OFN76_i_reset_n_i=FE_OFN286_i_reset_n_i
+ FE_OFN75_i_reset_n_i=FE_OFN285_i_reset_n_i
+ FE_OFN74_i_reset_n_i=FE_OFN282_i_reset_n_i
+ FE_OFN73_i_reset_n_i=FE_OFN280_i_reset_n_i
+ FE_OFN72_i_reset_n_i=FE_OFN276_i_reset_n_i
+ FE_OFN71_i_reset_n_i=FE_OFN272_i_reset_n_i
+ FE_OFN70_i_reset_n_i=FE_OFN271_i_reset_n_i
+ FE_OFN69_i_reset_n_i=FE_OFN270_i_reset_n_i
+ FE_OFN68_i_reset_n_i=FE_OFN269_i_reset_n_i
+ FE_OFN67_i_reset_n_i=FE_OFN268_i_reset_n_i
+ FE_OFN66_i_reset_n_i=FE_OFN264_i_reset_n_i
+ FE_OFN65_i_reset_n_i=FE_OFN262_i_reset_n_i
+ FE_OFN64_i_reset_n_i=FE_OFN260_i_reset_n_i
+ FE_OFN63_i_reset_n_i=FE_OFN259_i_reset_n_i
+ FE_OFN62_i_reset_n_i=FE_OFN256_i_reset_n_i
+ FE_OFN61_i_reset_n_i=FE_OFN255_i_reset_n_i
+ FE_OFN60_i_reset_n_i=FE_OFN254_i_reset_n_i
+ FE_OFN59_i_reset_n_i=FE_OFN253_i_reset_n_i
+ FE_OFN58_i_reset_n_i=FE_OFN252_i_reset_n_i
+ FE_OFN57_i_reset_n_i=FE_OFN251_i_reset_n_i
+ FE_OFN56_i_reset_n_i=FE_OFN250_i_reset_n_i
+ FE_OFN55_i_reset_n_i=FE_OFN247_i_reset_n_i
+ FE_OFN54_i_reset_n_i=FE_OFN241_i_reset_n_i
+ FE_OFN53_i_reset_n_i=FE_OFN240_i_reset_n_i
+ FE_OFN52_i_reset_n_i=FE_OFN234_i_reset_n_i
+ FE_OFN51_i_reset_n_i=FE_OFN231_i_reset_n_i
+ FE_OFN50_i_reset_n_i=FE_OFN229_i_reset_n_i
+ FE_OFN49_i_reset_n_i=FE_OFN227_i_reset_n_i
+ FE_OFN48_i_reset_n_i=FE_OFN225_i_reset_n_i
+ FE_OFN47_i_reset_n_i=FE_OFN221_i_reset_n_i
+ FE_OFN46_i_reset_n_i=FE_OFN220_i_reset_n_i
+ FE_OFN45_i_reset_n_i=FE_OFN219_i_reset_n_i
+ FE_OFN44_i_reset_n_i=FE_OFN213_i_reset_n_i
+ FE_OFN43_i_reset_n_i=FE_OFN212_i_reset_n_i
+ FE_OFN42_i_reset_n_i=FE_OFN211_i_reset_n_i
+ FE_OFN41_i_reset_n_i=FE_OFN210_i_reset_n_i
+ FE_OFN40_i_reset_n_i=FE_OFN208_i_reset_n_i
+ FE_OFN39_i_reset_n_i=FE_OFN206_i_reset_n_i
+ FE_OFN38_i_reset_n_i=FE_OFN205_i_reset_n_i
+ FE_OFN37_i_reset_n_i=FE_OFN204_i_reset_n_i
+ FE_OFN36_i_reset_n_i=FE_OFN203_i_reset_n_i
+ FE_OFN35_i_reset_n_i=FE_OFN200_i_reset_n_i
+ FE_OFN34_i_reset_n_i=FE_OFN195_i_reset_n_i
+ FE_OFN33_i_reset_n_i=FE_OFN191_i_reset_n_i
+ FE_OFN32_i_reset_n_i=FE_OFN189_i_reset_n_i
+ FE_OFN31_i_reset_n_i=FE_OFN186_i_reset_n_i
+ FE_OFN30_i_reset_n_i=FE_OFN185_i_reset_n_i
+ FE_OFN29_i_reset_n_i=FE_OFN181_i_reset_n_i
+ FE_OFN28_i_reset_n_i=FE_OFN180_i_reset_n_i
+ FE_OFN27_i_reset_n_i=FE_OFN179_i_reset_n_i
+ FE_OFN26_i_reset_n_i=FE_OFN175_i_reset_n_i
+ FE_OFN25_i_reset_n_i=FE_OFN174_i_reset_n_i
+ FE_OFN24_i_reset_n_i=FE_OFN173_i_reset_n_i
+ FE_OFN23_i_reset_n_i=FE_OFN172_i_reset_n_i
+ FE_OFN22_i_reset_n_i=FE_OFN171_i_reset_n_i
+ FE_OFN21_i_reset_n_i=FE_OFN169_i_reset_n_i
+ FE_OFN20_i_reset_n_i=FE_OFN168_i_reset_n_i
+ FE_OFN19_i_reset_n_i=FE_OFN167_i_reset_n_i
+ FE_OFN18_i_reset_n_i=FE_OFN165_i_reset_n_i
+ FE_OFN17_i_reset_n_i=FE_OFN164_i_reset_n_i
+ FE_OFN16_i_reset_n_i=FE_OFN160_i_reset_n_i
+ FE_OFN15_i_reset_n_i=FE_OFN158_i_reset_n_i
+ FE_OFN14_i_reset_n_i=FE_OFN156_i_reset_n_i
+ FE_OFN13_i_reset_n_i=FE_OFN154_i_reset_n_i
+ FE_OFN12_i_reset_n_i=FE_OFN152_i_reset_n_i
+ FE_OFN11_i_reset_n_i=FE_OFN151_i_reset_n_i
+ FE_OFN10_i_reset_n_i=FE_OFN148_i_reset_n_i
+ FE_OFN9_i_reset_n_i=FE_OFN145_i_reset_n_i
+ FE_OFN8_i_reset_n_i=FE_OFN144_i_reset_n_i
+ FE_OFN7_i_reset_n_i=FE_OFN142_i_reset_n_i
+ FE_OFN6_i_reset_n_i=FE_OFN141_i_reset_n_i
+ FE_OFN5_i_reset_n_i=FE_OFN140_i_reset_n_i
+ FE_OFN4_i_reset_n_i=FE_OFN5_i_reset_n_i FE_OFN3_i_reset_n_i=FE_OFN4_i_reset_n_i
+ FE_OFN2_i_reset_n_i=FE_OFN3_i_reset_n_i FE_OFN1_i_reset_n_i=FE_OFN2_i_reset_n_i
+ FE_OFN0_i_reset_n_i=FE_OFN1_i_reset_n_i clk_i_clone24=CTS_116
+ clk_i_clone23=CTS_117 clk_i_clone22=CTS_118 clk_i_clone21=CTS_120
+ clk_i_clone20=CTS_121 clk_i_clone19=CTS_122 clk_i_clone17=CTS_125
+ clk_i_clone16=CTS_126 clk_i_clone18=CTS_128 clk_i_clone13=CTS_130
+ clk_i_clone14=CTS_131 clk_i_clone12=CTS_132 clk_i_clone10=CTS_133
+ clk_i_clone11=CTS_134 clk_i_clone15=CTS_135 clk_i_clone9=CTS_137
+ clk_i_clone8=CTS_138 clk_i_clone7=CTS_139 clk_i_clone5=CTS_141
+ clk_i_clone6=CTS_142 clk_i_clone3=CTS_144 clk_i_clone4=CTS_145
+ clk_i_clone1=CTS_146 clk_i=CTS_147 clk_i_clone2=CTS_148
Xsub_2_root_sub_0_root_sub_242_3 Deco_DW01_sub_15 $PINS A[11]=siso1_o[71]
+ A[10]=siso1_o[70] A[9]=siso1_o[69] A[8]=siso1_o[68] A[7]=siso1_o[67]
+ A[6]=siso1_o[66] A[5]=siso1_o[65] A[4]=siso1_o[64] A[3]=siso1_o[63]
+ A[2]=siso1_o[62] A[1]=siso1_o[61] A[0]=siso1_o[60] B[11]=temp_LLR1[1][11]
+ B[10]=temp_LLR1[1][10] B[9]=temp_LLR1[1][9] B[8]=temp_LLR1[1][8]
+ B[7]=temp_LLR1[1][7] B[6]=temp_LLR1[1][6] B[5]=temp_LLR1[1][5]
+ B[4]=temp_LLR1[1][4] B[3]=temp_LLR1[1][3] B[2]=temp_LLR1[1][2]
+ B[1]=temp_LLR1[1][1] B[0]=temp_LLR1[1][0] CI=n693 DIFF[11]=N1007 DIFF[10]=N1006
+ DIFF[9]=N1005 DIFF[8]=N1004 DIFF[7]=N1003 DIFF[6]=N1002 DIFF[5]=N1001
+ DIFF[4]=N1000 DIFF[3]=N999 DIFF[2]=N998 DIFF[1]=N997 DIFF[0]=N996
Xsub_0_root_sub_0_root_sub_242_3 Deco_DW01_sub_14 $PINS A[11]=N1007 A[10]=N1006
+ A[9]=N1005 A[8]=N1004 A[7]=N1003 A[6]=N1002 A[5]=N1001 A[4]=N1000 A[3]=N999
+ A[2]=N998 A[1]=N997 A[0]=N996 B[11]=FE_UNCONNECTED_3 B[10]=N995 B[9]=n713
+ B[8]=FE_UNCONNECTED_3 B[7]=n713 B[6]=FE_UNCONNECTED_3 B[5]=n713
+ B[4]=FE_UNCONNECTED_4 B[3]=N987 B[2]=N986 B[1]=FE_OFN721_N985 B[0]=n693 CI=n693
+ DIFF[11]=N1019 DIFF[10]=N1018 DIFF[9]=N1017 DIFF[8]=N1016 DIFF[7]=N1015
+ DIFF[6]=N1014 DIFF[5]=N1013 DIFF[4]=N1012 DIFF[3]=N1011 DIFF[2]=N1010
+ DIFF[1]=N1009 DIFF[0]=N1008 FE_OFN146_n713=FE_OFN725_n713
+ FE_OFN144_n713=FE_OFN724_n713
Xsub_2_root_sub_0_root_sub_241_3 Deco_DW01_sub_3 $PINS A[11]=siso1_o[35]
+ A[10]=siso1_o[34] A[9]=siso1_o[33] A[8]=siso1_o[32] A[7]=siso1_o[31]
+ A[6]=siso1_o[30] A[5]=siso1_o[29] A[4]=siso1_o[28] A[3]=siso1_o[27]
+ A[2]=siso1_o[26] A[1]=siso1_o[25] A[0]=siso1_o[24] B[11]=temp_LLR1[4][11]
+ B[10]=temp_LLR1[4][10] B[9]=temp_LLR1[4][9] B[8]=temp_LLR1[4][8]
+ B[7]=temp_LLR1[4][7] B[6]=temp_LLR1[4][6] B[5]=temp_LLR1[4][5]
+ B[4]=temp_LLR1[4][4] B[3]=temp_LLR1[4][3] B[2]=temp_LLR1[4][2]
+ B[1]=temp_LLR1[4][1] B[0]=temp_LLR1[4][0] CI=n693 DIFF[11]=N971 DIFF[10]=N970
+ DIFF[9]=N969 DIFF[8]=N968 DIFF[7]=N967 DIFF[6]=N966 DIFF[5]=N965 DIFF[4]=N964
+ DIFF[3]=N963 DIFF[2]=N962 DIFF[1]=N961 DIFF[0]=N960
Xsub_0_root_sub_0_root_sub_241_3 Deco_DW01_sub_2 $PINS A[11]=N971 A[10]=N970
+ A[9]=N969 A[8]=N968 A[7]=N967 A[6]=N966 A[5]=N965 A[4]=N964 A[3]=N963 A[2]=N962
+ A[1]=N961 A[0]=N960 B[11]=N613 B[10]=N613 B[9]=FE_DBTN97_N613 B[8]=N613
+ B[7]=N613 B[6]=FE_DBTN97_N613 B[5]=N613 B[4]=N613 B[3]=N605 B[2]=N604
+ B[1]=FE_OFN722_N603 B[0]=n693 CI=n693 DIFF[11]=N983 DIFF[10]=N982 DIFF[9]=N981
+ DIFF[8]=N980 DIFF[7]=N979 DIFF[6]=N978 DIFF[5]=N977 DIFF[4]=N976 DIFF[3]=N975
+ DIFF[2]=N974 DIFF[1]=N973 DIFF[0]=N972
Xsub_2_root_sub_0_root_sub_240_3 Deco_DW01_sub_11 $PINS A[11]=siso1_o[59]
+ A[10]=siso1_o[58] A[9]=siso1_o[57] A[8]=siso1_o[56] A[7]=siso1_o[55]
+ A[6]=siso1_o[54] A[5]=siso1_o[53] A[4]=siso1_o[52] A[3]=siso1_o[51]
+ A[2]=siso1_o[50] A[1]=siso1_o[49] A[0]=siso1_o[48] B[11]=temp_LLR1[2][11]
+ B[10]=temp_LLR1[2][10] B[9]=temp_LLR1[2][9] B[8]=temp_LLR1[2][8]
+ B[7]=temp_LLR1[2][7] B[6]=temp_LLR1[2][6] B[5]=temp_LLR1[2][5]
+ B[4]=temp_LLR1[2][4] B[3]=temp_LLR1[2][3] B[2]=temp_LLR1[2][2]
+ B[1]=temp_LLR1[2][1] B[0]=temp_LLR1[2][0] CI=n693 DIFF[11]=N935 DIFF[10]=N934
+ DIFF[9]=N933 DIFF[8]=N932 DIFF[7]=N931 DIFF[6]=N930 DIFF[5]=N929 DIFF[4]=N928
+ DIFF[3]=N927 DIFF[2]=N926 DIFF[1]=N925 DIFF[0]=N924
Xsub_0_root_sub_0_root_sub_240_3 Deco_DW01_sub_10 $PINS A[11]=N935 A[10]=N934
+ A[9]=N933 A[8]=N932 A[7]=N931 A[6]=N930 A[5]=N929 A[4]=N928 A[3]=N927 A[2]=N926
+ A[1]=N925 A[0]=N924 B[11]=N923 B[10]=N923 B[9]=FE_OFN523_FE_DBTN10_N923
+ B[8]=N923 B[7]=FE_OFN522_FE_DBTN10_N923 B[6]=N923 B[5]=FE_DBTN10_N923 B[4]=N923
+ B[3]=FE_DBTN9_N915 B[2]=FE_DBTN8_N914 B[1]=N913 B[0]=n693 CI=n693 DIFF[11]=N947
+ DIFF[10]=N946 DIFF[9]=N945 DIFF[8]=N944 DIFF[7]=N943 DIFF[6]=N942 DIFF[5]=N941
+ DIFF[4]=N940 DIFF[3]=N939 DIFF[2]=N938 DIFF[1]=N937 DIFF[0]=N936
+ p1=FE_DBTN7_N913 FE_OFN138_FE_DBTN10_N923=FE_OFN524_FE_DBTN10_N923
Xsub_2_root_sub_0_root_sub_239_3 Deco_DW01_sub_7 $PINS A[11]=siso1_o[47]
+ A[10]=siso1_o[46] A[9]=siso1_o[45] A[8]=siso1_o[44] A[7]=siso1_o[43]
+ A[6]=siso1_o[42] A[5]=siso1_o[41] A[4]=siso1_o[40] A[3]=siso1_o[39]
+ A[2]=siso1_o[38] A[1]=siso1_o[37] A[0]=siso1_o[36] B[11]=temp_LLR1[3][11]
+ B[10]=temp_LLR1[3][10] B[9]=temp_LLR1[3][9] B[8]=temp_LLR1[3][8]
+ B[7]=temp_LLR1[3][7] B[6]=temp_LLR1[3][6] B[5]=temp_LLR1[3][5]
+ B[4]=temp_LLR1[3][4] B[3]=temp_LLR1[3][3] B[2]=temp_LLR1[3][2]
+ B[1]=temp_LLR1[3][1] B[0]=temp_LLR1[3][0] CI=n693 DIFF[11]=N899 DIFF[10]=N898
+ DIFF[9]=N897 DIFF[8]=N896 DIFF[7]=N895 DIFF[6]=N894 DIFF[5]=N893 DIFF[4]=N892
+ DIFF[3]=N891 DIFF[2]=N890 DIFF[1]=N889 DIFF[0]=N888
Xsub_0_root_sub_0_root_sub_239_3 Deco_DW01_sub_6 $PINS A[11]=N899 A[10]=N898
+ A[9]=N897 A[8]=N896 A[7]=N895 A[6]=N894 A[5]=N893 A[4]=N892 A[3]=N891 A[2]=N890
+ A[1]=N889 A[0]=N888 B[11]=N577 B[10]=N577 B[9]=N577 B[8]=N577 B[7]=N577
+ B[6]=N577 B[5]=FE_OFN525_FE_DBTN3_N577 B[4]=FE_DBTN3_N577 B[3]=N569 B[2]=N568
+ B[1]=N567 B[0]=n693 CI=n693 DIFF[11]=N911 DIFF[10]=N910 DIFF[9]=N909
+ DIFF[8]=N908 DIFF[7]=N907 DIFF[6]=N906 DIFF[5]=N905 DIFF[4]=N904 DIFF[3]=N903
+ DIFF[2]=N902 DIFF[1]=N901 DIFF[0]=N900
+ FE_OFN141_FE_DBTN3_N577=FE_OFN526_FE_DBTN3_N577 FE_OFN142_N567=FE_OFN723_N567
Xsub_2_root_sub_0_root_sub_238_3 Deco_DW01_sub_19 $PINS A[11]=siso1_o[83]
+ A[10]=siso1_o[82] A[9]=siso1_o[81] A[8]=siso1_o[80] A[7]=siso1_o[79]
+ A[6]=siso1_o[78] A[5]=siso1_o[77] A[4]=siso1_o[76] A[3]=siso1_o[75]
+ A[2]=siso1_o[74] A[1]=siso1_o[73] A[0]=siso1_o[72] B[11]=temp_LLR1[0][11]
+ B[10]=temp_LLR1[0][10] B[9]=temp_LLR1[0][9] B[8]=temp_LLR1[0][8]
+ B[7]=temp_LLR1[0][7] B[6]=temp_LLR1[0][6] B[5]=temp_LLR1[0][5]
+ B[4]=temp_LLR1[0][4] B[3]=temp_LLR1[0][3] B[2]=temp_LLR1[0][2]
+ B[1]=temp_LLR1[0][1] B[0]=temp_LLR1[0][0] CI=n693 DIFF[11]=N863 DIFF[10]=N862
+ DIFF[9]=N861 DIFF[8]=N860 DIFF[7]=N859 DIFF[6]=N858 DIFF[5]=N857 DIFF[4]=N856
+ DIFF[3]=N855 DIFF[2]=N854 DIFF[1]=N853 DIFF[0]=N852
Xsub_0_root_sub_0_root_sub_238_3 Deco_DW01_sub_18 $PINS A[11]=N863 A[10]=N862
+ A[9]=N861 A[8]=N860 A[7]=N859 A[6]=N858 A[5]=N857 A[4]=N856 A[3]=N855 A[2]=N854
+ A[1]=N853 A[0]=N852 B[11]=FE_UNCONNECTED_1 B[10]=FE_OFN726_n717
+ B[9]=FE_UNCONNECTED_1 B[8]=FE_UNCONNECTED_1 B[7]=n717 B[6]=FE_UNCONNECTED_1
+ B[5]=n717 B[4]=FE_UNCONNECTED_2 B[3]=FE_DBTN6_N843 B[2]=FE_DBTN5_N842 B[1]=N841
+ B[0]=n693 CI=n693 DIFF[11]=N875 DIFF[10]=N874 DIFF[9]=N873 DIFF[8]=N872
+ DIFF[7]=N871 DIFF[6]=N870 DIFF[5]=N869 DIFF[4]=N868 DIFF[3]=N867 DIFF[2]=N866
+ DIFF[1]=N865 DIFF[0]=N864 p1=FE_DBTN4_N841 FE_OFN150_n717=FE_OFN728_n717
+ FE_OFN147_n717=FE_OFN727_n717
Xsub_2_root_sub_0_root_sub_202_3 Deco_DW01_sub_5 $PINS A[11]=siso1_o[47]
+ A[10]=siso1_o[46] A[9]=siso1_o[45] A[8]=siso1_o[44] A[7]=siso1_o[43]
+ A[6]=siso1_o[42] A[5]=siso1_o[41] A[4]=siso1_o[40] A[3]=siso1_o[39]
+ A[2]=siso1_o[38] A[1]=siso1_o[37] A[0]=siso1_o[36]
+ B[11]=FE_DBTN34_temp_LLR_3_11 B[10]=FE_DBTN33_temp_LLR_3_10
+ B[9]=FE_DBTN32_temp_LLR_3_9 B[8]=FE_DBTN31_temp_LLR_3_8
+ B[7]=FE_DBTN30_temp_LLR_3_7 B[6]=FE_DBTN29_temp_LLR_3_6
+ B[5]=FE_DBTN28_temp_LLR_3_5 B[4]=FE_DBTN27_temp_LLR_3_4
+ B[3]=FE_DBTN26_temp_LLR_3_3 B[2]=FE_DBTN25_temp_LLR_3_2
+ B[1]=FE_DBTN24_temp_LLR_3_1 B[0]=temp_LLR[3][0] CI=n693 DIFF[11]=N625
+ DIFF[10]=N624 DIFF[9]=N623 DIFF[8]=N622 DIFF[7]=N621 DIFF[6]=N620 DIFF[5]=N619
+ DIFF[4]=N618 DIFF[3]=N617 DIFF[2]=N616 DIFF[1]=N615 DIFF[0]=N614
+ p1=FE_DBTN23_temp_LLR_3_0
Xsub_0_root_sub_0_root_sub_202_3 Deco_DW01_sub_4 $PINS A[11]=N625 A[10]=N624
+ A[9]=N623 A[8]=N622 A[7]=N621 A[6]=N620 A[5]=N619 A[4]=N618 A[3]=N617 A[2]=N616
+ A[1]=N615 A[0]=N614 B[11]=N613 B[10]=N613 B[9]=N613 B[8]=N613 B[7]=N613
+ B[6]=FE_DBTN97_N613 B[5]=FE_UNCONNECTED_5 B[4]=N613 B[3]=N605 B[2]=N604
+ B[1]=FE_OFN722_N603 B[0]=n693 CI=n693 DIFF[11]=N637 DIFF[10]=N636 DIFF[9]=N635
+ DIFF[8]=N634 DIFF[7]=N633 DIFF[6]=N632 DIFF[5]=N631 DIFF[4]=N630 DIFF[3]=N629
+ DIFF[2]=N628 DIFF[1]=N627 DIFF[0]=N626
Xsub_2_root_sub_0_root_sub_201_3 Deco_DW01_sub_13 $PINS A[11]=siso1_o[71]
+ A[10]=siso1_o[70] A[9]=siso1_o[69] A[8]=siso1_o[68] A[7]=siso1_o[67]
+ A[6]=siso1_o[66] A[5]=siso1_o[65] A[4]=siso1_o[64] A[3]=siso1_o[63]
+ A[2]=siso1_o[62] A[1]=siso1_o[61] A[0]=siso1_o[60]
+ B[11]=FE_DBTN58_temp_LLR_1_11 B[10]=FE_DBTN57_temp_LLR_1_10
+ B[9]=FE_DBTN56_temp_LLR_1_9 B[8]=FE_DBTN55_temp_LLR_1_8
+ B[7]=FE_DBTN54_temp_LLR_1_7 B[6]=FE_DBTN53_temp_LLR_1_6
+ B[5]=FE_DBTN52_temp_LLR_1_5 B[4]=FE_DBTN51_temp_LLR_1_4
+ B[3]=FE_DBTN50_temp_LLR_1_3 B[2]=FE_DBTN49_temp_LLR_1_2
+ B[1]=FE_DBTN48_temp_LLR_1_1 B[0]=temp_LLR[1][0] CI=n693 DIFF[11]=N589
+ DIFF[10]=N588 DIFF[9]=N587 DIFF[8]=N586 DIFF[7]=N585 DIFF[6]=N584 DIFF[5]=N583
+ DIFF[4]=N582 DIFF[3]=N581 DIFF[2]=N580 DIFF[1]=N579 DIFF[0]=N578
+ p1=FE_DBTN47_temp_LLR_1_0
Xsub_0_root_sub_0_root_sub_201_3 Deco_DW01_sub_12 $PINS A[11]=N589 A[10]=N588
+ A[9]=N587 A[8]=N586 A[7]=N585 A[6]=N584 A[5]=N583 A[4]=N582 A[3]=N581 A[2]=N580
+ A[1]=N579 A[0]=N578 B[11]=N577 B[10]=N577 B[9]=N577
+ B[8]=FE_OFN525_FE_DBTN3_N577 B[7]=N577 B[6]=N577 B[5]=FE_DBTN3_N577 B[4]=N577
+ B[3]=N569 B[2]=N568 B[1]=FE_OFN723_N567 B[0]=n693 CI=n693 DIFF[11]=N601
+ DIFF[10]=N600 DIFF[9]=N599 DIFF[8]=N598 DIFF[7]=N597 DIFF[6]=N596 DIFF[5]=N595
+ DIFF[4]=N594 DIFF[3]=N593 DIFF[2]=N592 DIFF[1]=N591 DIFF[0]=N590
+ FE_OFN140_FE_DBTN3_N577=FE_OFN526_FE_DBTN3_N577
Xsub_2_root_sub_0_root_sub_200_3 Deco_DW01_sub_9 $PINS A[11]=siso1_o[59]
+ A[10]=siso1_o[58] A[9]=siso1_o[57] A[8]=siso1_o[56] A[7]=siso1_o[55]
+ A[6]=siso1_o[54] A[5]=siso1_o[53] A[4]=siso1_o[52] A[3]=siso1_o[51]
+ A[2]=siso1_o[50] A[1]=siso1_o[49] A[0]=siso1_o[48]
+ B[11]=FE_DBTN46_temp_LLR_2_11 B[10]=FE_DBTN45_temp_LLR_2_10
+ B[9]=FE_DBTN44_temp_LLR_2_9 B[8]=FE_DBTN43_temp_LLR_2_8
+ B[7]=FE_DBTN42_temp_LLR_2_7 B[6]=FE_DBTN41_temp_LLR_2_6
+ B[5]=FE_DBTN40_temp_LLR_2_5 B[4]=FE_DBTN39_temp_LLR_2_4
+ B[3]=FE_DBTN38_temp_LLR_2_3 B[2]=FE_DBTN37_temp_LLR_2_2
+ B[1]=FE_DBTN36_temp_LLR_2_1 B[0]=temp_LLR[2][0] CI=n693 DIFF[11]=N553
+ DIFF[10]=N552 DIFF[9]=N551 DIFF[8]=N550 DIFF[7]=N549 DIFF[6]=N548 DIFF[5]=N547
+ DIFF[4]=N546 DIFF[3]=N545 DIFF[2]=N544 DIFF[1]=N543 DIFF[0]=N542
+ p1=FE_DBTN35_temp_LLR_2_0
Xsub_0_root_sub_0_root_sub_200_3 Deco_DW01_sub_8 $PINS A[11]=N553 A[10]=N552
+ A[9]=N551 A[8]=N550 A[7]=N549 A[6]=N548 A[5]=N547 A[4]=N546 A[3]=N545 A[2]=N544
+ A[1]=N543 A[0]=N542 B[11]=N923 B[10]=N923 B[9]=FE_DBTN10_N923 B[8]=N923
+ B[7]=FE_OFN523_FE_DBTN10_N923 B[6]=N923 B[5]=N923 B[4]=FE_OFN522_FE_DBTN10_N923
+ B[3]=FE_DBTN9_N915 B[2]=FE_DBTN8_N914 B[1]=N913 B[0]=n693 CI=n693 DIFF[11]=N565
+ DIFF[10]=N564 DIFF[9]=N563 DIFF[8]=N562 DIFF[7]=N561 DIFF[6]=N560 DIFF[5]=N559
+ DIFF[4]=N558 DIFF[3]=N557 DIFF[2]=N556 DIFF[1]=N555 DIFF[0]=N554
+ p1=FE_DBTN7_N913 FE_OFN139_FE_DBTN10_N923=FE_OFN524_FE_DBTN10_N923
Xsub_2_root_sub_0_root_sub_199_3 Deco_DW01_sub_1 $PINS A[11]=siso1_o[35]
+ A[10]=siso1_o[34] A[9]=siso1_o[33] A[8]=siso1_o[32] A[7]=siso1_o[31]
+ A[6]=siso1_o[30] A[5]=siso1_o[29] A[4]=siso1_o[28] A[3]=siso1_o[27]
+ A[2]=siso1_o[26] A[1]=siso1_o[25] A[0]=siso1_o[24]
+ B[11]=FE_DBTN22_temp_LLR_4_11 B[10]=FE_DBTN21_temp_LLR_4_10
+ B[9]=FE_DBTN20_temp_LLR_4_9 B[8]=FE_DBTN19_temp_LLR_4_8
+ B[7]=FE_DBTN18_temp_LLR_4_7 B[6]=FE_DBTN17_temp_LLR_4_6
+ B[5]=FE_DBTN16_temp_LLR_4_5 B[4]=FE_DBTN15_temp_LLR_4_4
+ B[3]=FE_DBTN14_temp_LLR_4_3 B[2]=FE_DBTN13_temp_LLR_4_2
+ B[1]=FE_DBTN12_temp_LLR_4_1 B[0]=temp_LLR[4][0] CI=n693 DIFF[11]=N517
+ DIFF[10]=N516 DIFF[9]=N515 DIFF[8]=N514 DIFF[7]=N513 DIFF[6]=N512 DIFF[5]=N511
+ DIFF[4]=N510 DIFF[3]=N509 DIFF[2]=N508 DIFF[1]=N507 DIFF[0]=N506
+ p1=FE_DBTN11_temp_LLR_4_0
Xsub_0_root_sub_0_root_sub_199_3 Deco_DW01_sub_0 $PINS A[11]=N517 A[10]=N516
+ A[9]=N515 A[8]=N514 A[7]=N513 A[6]=N512 A[5]=N511 A[4]=N510 A[3]=N509 A[2]=N508
+ A[1]=N507 A[0]=N506 B[11]=n713 B[10]=FE_UNCONNECTED_3 B[9]=n713 B[8]=N995
+ B[7]=n713 B[6]=FE_UNCONNECTED_3 B[5]=N995 B[4]=n713 B[3]=N987 B[2]=N986
+ B[1]=FE_OFN721_N985 B[0]=n693 CI=n693 DIFF[11]=N529 DIFF[10]=N528 DIFF[9]=N527
+ DIFF[8]=N526 DIFF[7]=N525 DIFF[6]=N524 DIFF[5]=N523 DIFF[4]=N522 DIFF[3]=N521
+ DIFF[2]=N520 DIFF[1]=N519 DIFF[0]=N518 FE_OFN145_n713=FE_OFN725_n713
+ FE_OFN143_n713=FE_OFN724_n713
Xsub_2_root_sub_0_root_sub_198_3 Deco_DW01_sub_17 $PINS A[11]=siso1_o[83]
+ A[10]=siso1_o[82] A[9]=siso1_o[81] A[8]=siso1_o[80] A[7]=siso1_o[79]
+ A[6]=siso1_o[78] A[5]=siso1_o[77] A[4]=siso1_o[76] A[3]=siso1_o[75]
+ A[2]=siso1_o[74] A[1]=siso1_o[73] A[0]=siso1_o[72]
+ B[11]=FE_DBTN70_temp_LLR_0_11 B[10]=FE_DBTN69_temp_LLR_0_10
+ B[9]=FE_DBTN68_temp_LLR_0_9 B[8]=FE_DBTN67_temp_LLR_0_8
+ B[7]=FE_DBTN66_temp_LLR_0_7 B[6]=FE_DBTN65_temp_LLR_0_6
+ B[5]=FE_DBTN64_temp_LLR_0_5 B[4]=FE_DBTN63_temp_LLR_0_4
+ B[3]=FE_DBTN62_temp_LLR_0_3 B[2]=FE_DBTN61_temp_LLR_0_2
+ B[1]=FE_DBTN60_temp_LLR_0_1 B[0]=temp_LLR[0][0] CI=n693 DIFF[11]=N481
+ DIFF[10]=N480 DIFF[9]=N479 DIFF[8]=N478 DIFF[7]=N477 DIFF[6]=N476 DIFF[5]=N475
+ DIFF[4]=N474 DIFF[3]=N473 DIFF[2]=N472 DIFF[1]=N471 DIFF[0]=N470
+ p1=FE_DBTN59_temp_LLR_0_0
Xsub_0_root_sub_0_root_sub_198_3 Deco_DW01_sub_16 $PINS A[11]=N481 A[10]=N480
+ A[9]=N479 A[8]=N478 A[7]=N477 A[6]=N476 A[5]=N475 A[4]=N474 A[3]=N473 A[2]=N472
+ A[1]=N471 A[0]=N470 B[11]=FE_UNCONNECTED_1 B[10]=FE_UNCONNECTED_1 B[9]=n717
+ B[8]=N851 B[7]=FE_UNCONNECTED_1 B[6]=FE_OFN726_n717 B[5]=FE_UNCONNECTED_1
+ B[4]=FE_UNCONNECTED_1 B[3]=FE_DBTN6_N843 B[2]=FE_DBTN5_N842 B[1]=N841 B[0]=n693
+ CI=n693 DIFF[11]=N493 DIFF[10]=N492 DIFF[9]=N491 DIFF[8]=N490 DIFF[7]=N489
+ DIFF[6]=N488 DIFF[5]=N487 DIFF[4]=N486 DIFF[3]=N485 DIFF[2]=N484 DIFF[1]=N483
+ DIFF[0]=N482 p1=FE_DBTN4_N841 FE_OFN149_n717=FE_OFN728_n717
+ FE_OFN148_n717=FE_OFN727_n717
Xadd_290/U1_1_1 HA1 $PINS S=N1035 C=add_290/carry[2] A=iter_counter[1]
+ B=iter_counter[0]
Xadd_290/U1_1_2 HA1 $PINS S=N1036 C=add_290/carry[3] A=iter_counter[2]
+ B=add_290/carry[2]
Xadd_290/U1_1_3 HA1 $PINS S=N1037 C=add_290/carry[4] A=iter_counter[3]
+ B=add_290/carry[3]
Xadd_290/U1_1_4 HA1 $PINS S=N1038 C=add_290/carry[5] A=iter_counter[4]
+ B=add_290/carry[4]
Xvec0_reg_reg[6] QDFFRBN $PINS Q=vec0_reg[6] D=data_i[20] CK=CTS_137
+ RB=FE_OFN492_i_reset_n_i
Xvec0_reg_reg[5] QDFFRBN $PINS Q=vec0_reg[5] D=data_i[19] CK=CTS_137
+ RB=FE_OFN493_i_reset_n_i
Xvec0_reg_reg[4] QDFFRBN $PINS Q=vec0_reg[4] D=data_i[18] CK=CTS_116
+ RB=FE_OFN493_i_reset_n_i
Xvec0_reg_reg[3] QDFFRBN $PINS Q=vec0_reg[3] D=data_i[17] CK=CTS_118
+ RB=FE_OFN309_i_reset_n_i
Xvec0_reg_reg[2] QDFFRBN $PINS Q=vec0_reg[2] D=data_i[16] CK=CTS_117
+ RB=FE_OFN357_i_reset_n_i
Xvec0_reg_reg[1] QDFFRBN $PINS Q=vec0_reg[1] D=data_i[15] CK=CTS_117
+ RB=FE_OFN300_i_reset_n_i
Xvec0_reg_reg[0] QDFFRBN $PINS Q=vec0_reg[0] D=data_i[14] CK=CTS_125
+ RB=FE_OFN464_i_reset_n_i
Xvec1_reg_reg[6] QDFFRBN $PINS Q=vec1_reg[6] D=data_i[13] CK=CTS_126
+ RB=FE_OFN285_i_reset_n_i
Xvec1_reg_reg[5] QDFFRBN $PINS Q=vec1_reg[5] D=data_i[12] CK=CTS_132
+ RB=reset_n_i
Xvec1_reg_reg[4] QDFFRBN $PINS Q=vec1_reg[4] D=data_i[11] CK=CTS_132
+ RB=FE_OFN280_i_reset_n_i
Xvec1_reg_reg[3] QDFFRBN $PINS Q=vec1_reg[3] D=data_i[10] CK=CTS_130
+ RB=FE_OFN485_i_reset_n_i
Xvec1_reg_reg[2] QDFFRBN $PINS Q=vec1_reg[2] D=data_i[9] CK=CTS_130
+ RB=FE_OFN485_i_reset_n_i
Xvec1_reg_reg[1] QDFFRBN $PINS Q=vec1_reg[1] D=data_i[8] CK=CTS_126
+ RB=FE_OFN241_i_reset_n_i
Xvec1_reg_reg[0] QDFFRBN $PINS Q=vec1_reg[0] D=data_i[7] CK=CTS_126
+ RB=FE_OFN293_i_reset_n_i
Xvec2_reg_reg[6] QDFFRBN $PINS Q=vec2_reg[6] D=data_i[6] CK=CTS_126
+ RB=FE_OFN195_i_reset_n_i
Xvec2_reg_reg[5] QDFFRBN $PINS Q=vec2_reg[5] D=data_i[5] CK=CTS_126
+ RB=FE_OFN285_i_reset_n_i
Xvec2_reg_reg[4] QDFFRBN $PINS Q=vec2_reg[4] D=data_i[4] CK=CTS_147
+ RB=FE_OFN440_i_reset_n_i
Xvec2_reg_reg[3] QDFFRBN $PINS Q=vec2_reg[3] D=data_i[3] CK=CTS_147
+ RB=FE_OFN175_i_reset_n_i
Xvec2_reg_reg[2] QDFFRBN $PINS Q=vec2_reg[2] D=data_i[2] CK=CTS_147
+ RB=FE_OFN145_i_reset_n_i
Xvec2_reg_reg[1] QDFFRBN $PINS Q=vec2_reg[1] D=data_i[1] CK=CTS_146
+ RB=FE_OFN276_i_reset_n_i
Xvec2_reg_reg[0] QDFFRBN $PINS Q=vec2_reg[0] D=data_i[0] CK=CTS_133
+ RB=FE_OFN227_i_reset_n_i
Xsys_reg_reg[4] QDFFRBN $PINS Q=vec0_1D[4] D=n509 CK=CTS_117
+ RB=FE_OFN417_i_reset_n_i
Xsys_reg_reg[0] QDFFRBN $PINS Q=vec0_1D[0] D=n513 CK=CTS_117
+ RB=FE_OFN417_i_reset_n_i
Xsys_reg_reg[5] QDFFRBN $PINS Q=vec0_1D[5] D=n508 CK=CTS_117
+ RB=FE_OFN355_i_reset_n_i
Xsys_reg_reg[1] QDFFRBN $PINS Q=vec0_1D[1] D=n512 CK=CTS_117
+ RB=FE_OFN417_i_reset_n_i
Xsys_reg_reg[6] QDFFRBN $PINS Q=vec0_1D[6] D=n507 CK=CTS_117
+ RB=FE_OFN355_i_reset_n_i
Xsys_reg_reg[2] QDFFRBN $PINS Q=vec0_1D[2] D=n511 CK=CTS_117
+ RB=FE_OFN417_i_reset_n_i
Xsys_reg_reg[7] QDFFRBN $PINS Q=vec0_1D[7] D=n506 CK=CTS_117
+ RB=FE_OFN356_i_reset_n_i
Xsys_reg_reg[3] QDFFRBN $PINS Q=vec0_1D[3] D=n510 CK=CTS_117
+ RB=FE_OFN299_i_reset_n_i
Xvec2_reg[0][0] QDFFRBN $PINS Q=vec2[0][0] D=n550 CK=CTS_117
+ RB=FE_OFN299_i_reset_n_i
Xvec2_reg[1][0] QDFFRBN $PINS Q=vec2[1][0] D=n562 CK=CTS_117
+ RB=FE_OFN354_i_reset_n_i
Xvec2_reg[2][0] QDFFRBN $PINS Q=vec2[2][0] D=n574 CK=CTS_120
+ RB=FE_OFN254_i_reset_n_i
Xvec2_reg[3][0] QDFFRBN $PINS Q=vec2[3][0] D=n586 CK=CTS_120
+ RB=FE_OFN169_i_reset_n_i
Xvec2_reg[4][0] QDFFRBN $PINS Q=vec2[4][0] D=n598 CK=CTS_122
+ RB=FE_OFN473_i_reset_n_i
Xvec2_reg[5][0] QDFFRBN $PINS Q=vec2[5][0] D=n610 CK=CTS_120
+ RB=FE_OFN426_i_reset_n_i
Xvec2_reg[6][0] QDFFRBN $PINS Q=vec2[6][0] D=n622 CK=CTS_120
+ RB=FE_OFN301_i_reset_n_i
Xvec2_reg[0][1] QDFFRBN $PINS Q=vec2[0][1] D=n551 CK=CTS_117
+ RB=FE_OFN354_i_reset_n_i
Xvec2_reg[1][1] QDFFRBN $PINS Q=vec2[1][1] D=n563 CK=CTS_117
+ RB=FE_OFN416_i_reset_n_i
Xvec2_reg[2][1] QDFFRBN $PINS Q=vec2[2][1] D=n575 CK=CTS_120
+ RB=FE_OFN254_i_reset_n_i
Xvec2_reg[3][1] QDFFRBN $PINS Q=vec2[3][1] D=n587 CK=CTS_121
+ RB=FE_OFN169_i_reset_n_i
Xvec2_reg[4][1] QDFFRBN $PINS Q=vec2[4][1] D=n599 CK=CTS_122
+ RB=FE_OFN490_i_reset_n_i
Xvec2_reg[5][1] QDFFRBN $PINS Q=vec2[5][1] D=n611 CK=CTS_120
+ RB=FE_OFN472_i_reset_n_i
Xvec2_reg[6][1] QDFFRBN $PINS Q=vec2[6][1] D=n623 CK=CTS_120
+ RB=FE_OFN248_i_reset_n_i
Xvec2_reg[0][2] QDFFRBN $PINS Q=vec2[0][2] D=n552 CK=CTS_117
+ RB=FE_OFN354_i_reset_n_i
Xvec2_reg[1][2] QDFFRBN $PINS Q=vec2[1][2] D=n564 CK=CTS_117
+ RB=FE_OFN424_i_reset_n_i
Xvec2_reg[2][2] QDFFRBN $PINS Q=vec2[2][2] D=n576 CK=CTS_118
+ RB=FE_OFN254_i_reset_n_i
Xvec2_reg[3][2] QDFFRBN $PINS Q=vec2[3][2] D=n588 CK=CTS_122
+ RB=FE_OFN473_i_reset_n_i
Xvec2_reg[4][2] QDFFRBN $PINS Q=vec2[4][2] D=n600 CK=CTS_122
+ RB=FE_OFN471_i_reset_n_i
Xvec2_reg[5][2] QDFFRBN $PINS Q=vec2[5][2] D=n612 CK=CTS_122
+ RB=FE_OFN361_i_reset_n_i
Xvec2_reg[6][2] QDFFRBN $PINS Q=vec2[6][2] D=n624 CK=CTS_120
+ RB=FE_OFN204_i_reset_n_i
Xvec2_reg[0][3] QDFFRBN $PINS Q=vec2[0][3] D=n553 CK=CTS_117
+ RB=FE_OFN416_i_reset_n_i
Xvec2_reg[1][3] QDFFRBN $PINS Q=vec2[1][3] D=n565 CK=CTS_120
+ RB=FE_OFN359_i_reset_n_i
Xvec2_reg[2][3] QDFFRBN $PINS Q=vec2[2][3] D=n577 CK=CTS_118
+ RB=FE_OFN254_i_reset_n_i
Xvec2_reg[3][3] QDFFRBN $PINS Q=vec2[3][3] D=n589 CK=CTS_122
+ RB=FE_OFN490_i_reset_n_i
Xvec2_reg[4][3] QDFFRBN $PINS Q=vec2[4][3] D=n601 CK=CTS_122
+ RB=FE_OFN490_i_reset_n_i
Xvec2_reg[5][3] QDFFRBN $PINS Q=vec2[5][3] D=n613 CK=CTS_122
+ RB=FE_OFN428_i_reset_n_i
Xvec2_reg[6][3] QDFFRBN $PINS Q=vec2[6][3] D=n625 CK=CTS_122
+ RB=FE_OFN247_i_reset_n_i
Xenc_reg_reg[24] QDFFRBN $PINS Q=vec1_1D[24] D=n521 CK=CTS_117
+ RB=FE_OFN356_i_reset_n_i
Xenc_reg_reg[20] QDFFRBN $PINS Q=vec1_1D[20] D=n525 CK=CTS_117
+ RB=FE_OFN418_i_reset_n_i
Xenc_reg_reg[16] QDFFRBN $PINS Q=vec1_1D[16] D=n529 CK=CTS_120
+ RB=FE_OFN425_i_reset_n_i
Xsys_reg_reg[12] QDFFRBN $PINS Q=vec0_1D[12] D=n501 CK=CTS_118
+ RB=FE_OFN210_i_reset_n_i
Xenc_reg_reg[12] QDFFRBN $PINS Q=vec1_1D[12] D=n533 CK=CTS_120
+ RB=FE_OFN426_i_reset_n_i
Xsys_reg_reg[8] QDFFRBN $PINS Q=vec0_1D[8] D=n505 CK=CTS_118
+ RB=FE_OFN210_i_reset_n_i
Xsys_reg_reg[20] QDFFRBN $PINS Q=vec0_1D[20] D=n493 CK=CTS_116
+ RB=FE_OFN372_i_reset_n_i
Xenc_reg_reg[8] QDFFRBN $PINS Q=vec1_1D[8] D=n537 CK=CTS_120
+ RB=FE_OFN472_i_reset_n_i
Xenc_reg_reg[4] QDFFRBN $PINS Q=vec1_1D[4] D=n541 CK=CTS_120
+ RB=FE_OFN247_i_reset_n_i
Xenc_reg_reg[0] QDFFRBN $PINS Q=vec1_1D[0] D=n545 CK=CTS_120
+ RB=FE_OFN301_i_reset_n_i
Xenc_reg_reg[25] QDFFRBN $PINS Q=vec1_1D[25] D=n520 CK=CTS_117
+ RB=FE_OFN418_i_reset_n_i
Xenc_reg_reg[21] QDFFRBN $PINS Q=vec1_1D[21] D=n524 CK=CTS_117
+ RB=FE_OFN359_i_reset_n_i
Xenc_reg_reg[17] QDFFRBN $PINS Q=vec1_1D[17] D=n528 CK=CTS_120
+ RB=FE_OFN425_i_reset_n_i
Xsys_reg_reg[13] QDFFRBN $PINS Q=vec0_1D[13] D=n500 CK=CTS_118
+ RB=FE_OFN170_i_reset_n_i
Xenc_reg_reg[13] QDFFRBN $PINS Q=vec1_1D[13] D=n532 CK=CTS_120
+ RB=FE_OFN426_i_reset_n_i
Xsys_reg_reg[9] QDFFRBN $PINS Q=vec0_1D[9] D=n504 CK=CTS_118
+ RB=FE_OFN170_i_reset_n_i
Xsys_reg_reg[21] QDFFRBN $PINS Q=vec0_1D[21] D=n492 CK=CTS_116
+ RB=FE_OFN372_i_reset_n_i
Xenc_reg_reg[9] QDFFRBN $PINS Q=vec1_1D[9] D=n536 CK=CTS_120
+ RB=FE_OFN472_i_reset_n_i
Xenc_reg_reg[5] QDFFRBN $PINS Q=vec1_1D[5] D=n540 CK=CTS_120
+ RB=FE_OFN472_i_reset_n_i
Xenc_reg_reg[1] QDFFRBN $PINS Q=vec1_1D[1] D=n544 CK=CTS_120
+ RB=FE_OFN301_i_reset_n_i
Xenc_reg_reg[26] QDFFRBN $PINS Q=vec1_1D[26] D=n519 CK=CTS_117
+ RB=FE_OFN418_i_reset_n_i
Xenc_reg_reg[22] QDFFRBN $PINS Q=vec1_1D[22] D=n523 CK=CTS_117
+ RB=FE_OFN423_i_reset_n_i
Xenc_reg_reg[18] QDFFRBN $PINS Q=vec1_1D[18] D=n527 CK=CTS_118
+ RB=FE_OFN422_i_reset_n_i
Xsys_reg_reg[14] QDFFRBN $PINS Q=vec0_1D[14] D=n499 CK=CTS_118
+ RB=FE_OFN209_i_reset_n_i
Xenc_reg_reg[14] QDFFRBN $PINS Q=vec1_1D[14] D=n531 CK=CTS_122
+ RB=FE_OFN429_i_reset_n_i
Xsys_reg_reg[10] QDFFRBN $PINS Q=vec0_1D[10] D=n503 CK=CTS_118
+ RB=FE_OFN170_i_reset_n_i
Xsys_reg_reg[22] QDFFRBN $PINS Q=vec0_1D[22] D=n491 CK=CTS_116
+ RB=FE_OFN171_i_reset_n_i
Xenc_reg_reg[10] QDFFRBN $PINS Q=vec1_1D[10] D=n535 CK=CTS_122
+ RB=FE_OFN471_i_reset_n_i
Xenc_reg_reg[6] QDFFRBN $PINS Q=vec1_1D[6] D=n539 CK=CTS_122
+ RB=FE_OFN472_i_reset_n_i
Xenc_reg_reg[2] QDFFRBN $PINS Q=vec1_1D[2] D=n543 CK=CTS_120
+ RB=FE_OFN247_i_reset_n_i
Xenc_reg_reg[27] QDFFRBN $PINS Q=vec1_1D[27] D=n518 CK=CTS_117
+ RB=FE_OFN418_i_reset_n_i
Xenc_reg_reg[23] QDFFRBN $PINS Q=vec1_1D[23] D=n522 CK=CTS_117
+ RB=FE_OFN301_i_reset_n_i
Xenc_reg_reg[19] QDFFRBN $PINS Q=vec1_1D[19] D=n526 CK=CTS_118
+ RB=FE_OFN422_i_reset_n_i
Xsys_reg_reg[15] QDFFRBN $PINS Q=vec0_1D[15] D=n498 CK=CTS_120
+ RB=FE_OFN366_i_reset_n_i
Xenc_reg_reg[15] QDFFRBN $PINS Q=vec1_1D[15] D=n530 CK=CTS_122
+ RB=FE_OFN471_i_reset_n_i
Xsys_reg_reg[11] QDFFRBN $PINS Q=vec0_1D[11] D=n502 CK=CTS_118
+ RB=FE_OFN433_i_reset_n_i
Xsys_reg_reg[23] QDFFRBN $PINS Q=vec0_1D[23] D=n490 CK=CTS_116
+ RB=FE_OFN211_i_reset_n_i
Xenc_reg_reg[11] QDFFRBN $PINS Q=vec1_1D[11] D=n534 CK=CTS_122
+ RB=FE_OFN471_i_reset_n_i
Xenc_reg_reg[7] QDFFRBN $PINS Q=vec1_1D[7] D=n538 CK=CTS_122
+ RB=FE_OFN361_i_reset_n_i
Xenc_reg_reg[3] QDFFRBN $PINS Q=vec1_1D[3] D=n542 CK=CTS_120
+ RB=FE_OFN247_i_reset_n_i
Xvec0_reg[5][0] QDFFRBN $PINS Q=vec0[5][0] D=n602 CK=CTS_117
+ RB=FE_OFN300_i_reset_n_i
Xvec0_reg[6][0] QDFFRBN $PINS Q=vec0[6][0] D=n614 CK=CTS_117
+ RB=FE_OFN355_i_reset_n_i
Xvec0_reg[5][1] QDFFRBN $PINS Q=vec0[5][1] D=n603 CK=CTS_117
+ RB=FE_OFN300_i_reset_n_i
Xvec0_reg[6][1] QDFFRBN $PINS Q=vec0[6][1] D=n615 CK=CTS_117
+ RB=FE_OFN355_i_reset_n_i
Xvec0_reg[5][2] QDFFRBN $PINS Q=vec0[5][2] D=n604 CK=CTS_117
+ RB=FE_OFN300_i_reset_n_i
Xvec0_reg[6][2] QDFFRBN $PINS Q=vec0[6][2] D=n616 CK=CTS_117
+ RB=FE_OFN300_i_reset_n_i
Xvec0_reg[5][3] QDFFRBN $PINS Q=vec0[5][3] D=n605 CK=CTS_117
+ RB=FE_OFN246_i_reset_n_i
Xvec0_reg[6][3] QDFFRBN $PINS Q=vec0[6][3] D=n617 CK=CTS_117
+ RB=FE_OFN355_i_reset_n_i
Xvec1_reg[0][0] QDFFRBN $PINS Q=vec1[0][0] D=n546 CK=CTS_117
+ RB=FE_OFN246_i_reset_n_i
Xvec1_reg[1][0] QDFFRBN $PINS Q=vec1[1][0] D=n558 CK=CTS_117
+ RB=FE_OFN416_i_reset_n_i
Xvec1_reg[2][0] QDFFRBN $PINS Q=vec1[2][0] D=n570 CK=CTS_120
+ RB=FE_OFN425_i_reset_n_i
Xvec1_reg[3][0] QDFFRBN $PINS Q=vec1[3][0] D=n582 CK=CTS_120
+ RB=FE_OFN207_i_reset_n_i
Xvec1_reg[4][0] QDFFRBN $PINS Q=vec1[4][0] D=n594 CK=CTS_122
+ RB=FE_OFN429_i_reset_n_i
Xvec1_reg[5][0] QDFFRBN $PINS Q=vec1[5][0] D=n606 CK=CTS_122
+ RB=FE_OFN427_i_reset_n_i
Xvec1_reg[6][0] QDFFRBN $PINS Q=vec1[6][0] D=n618 CK=CTS_120
+ RB=FE_OFN248_i_reset_n_i
Xvec1_reg[0][1] QDFFRBN $PINS Q=vec1[0][1] D=n547 CK=CTS_117
+ RB=FE_OFN246_i_reset_n_i
Xvec1_reg[1][1] QDFFRBN $PINS Q=vec1[1][1] D=n559 CK=CTS_117
+ RB=FE_OFN354_i_reset_n_i
Xvec1_reg[2][1] QDFFRBN $PINS Q=vec1[2][1] D=n571 CK=CTS_120
+ RB=FE_OFN426_i_reset_n_i
Xvec1_reg[3][1] QDFFRBN $PINS Q=vec1[3][1] D=n583 CK=CTS_120
+ RB=FE_OFN490_i_reset_n_i
Xvec1_reg[4][1] QDFFRBN $PINS Q=vec1[4][1] D=n595 CK=CTS_122
+ RB=FE_OFN473_i_reset_n_i
Xvec1_reg[5][1] QDFFRBN $PINS Q=vec1[5][1] D=n607 CK=CTS_122
+ RB=FE_OFN427_i_reset_n_i
Xvec1_reg[6][1] QDFFRBN $PINS Q=vec1[6][1] D=n619 CK=CTS_120
+ RB=FE_OFN248_i_reset_n_i
Xvec1_reg[0][2] QDFFRBN $PINS Q=vec1[0][2] D=n548 CK=CTS_117
+ RB=FE_OFN246_i_reset_n_i
Xvec1_reg[1][2] QDFFRBN $PINS Q=vec1[1][2] D=n560 CK=CTS_117
+ RB=FE_OFN359_i_reset_n_i
Xvec1_reg[2][2] QDFFRBN $PINS Q=vec1[2][2] D=n572 CK=CTS_120
+ RB=FE_OFN425_i_reset_n_i
Xvec1_reg[3][2] QDFFRBN $PINS Q=vec1[3][2] D=n584 CK=CTS_122
+ RB=FE_OFN490_i_reset_n_i
Xvec1_reg[4][2] QDFFRBN $PINS Q=vec1[4][2] D=n596 CK=CTS_122
+ RB=FE_OFN471_i_reset_n_i
Xvec1_reg[5][2] QDFFRBN $PINS Q=vec1[5][2] D=n608 CK=CTS_122
+ RB=FE_OFN303_i_reset_n_i
Xvec1_reg[6][2] QDFFRBN $PINS Q=vec1[6][2] D=n620 CK=CTS_120
+ RB=FE_OFN248_i_reset_n_i
Xvec1_reg[0][3] QDFFRBN $PINS Q=vec1[0][3] D=n549 CK=CTS_117
+ RB=FE_OFN416_i_reset_n_i
Xvec1_reg[1][3] QDFFRBN $PINS Q=vec1[1][3] D=n561 CK=CTS_120
+ RB=FE_OFN359_i_reset_n_i
Xvec1_reg[2][3] QDFFRBN $PINS Q=vec1[2][3] D=n573 CK=CTS_120
+ RB=FE_OFN425_i_reset_n_i
Xvec1_reg[3][3] QDFFRBN $PINS Q=vec1[3][3] D=n585 CK=CTS_122
+ RB=FE_OFN471_i_reset_n_i
Xvec1_reg[4][3] QDFFRBN $PINS Q=vec1[4][3] D=n597 CK=CTS_122
+ RB=FE_OFN428_i_reset_n_i
Xvec1_reg[5][3] QDFFRBN $PINS Q=vec1[5][3] D=n609 CK=CTS_122
+ RB=FE_OFN361_i_reset_n_i
Xvec1_reg[6][3] QDFFRBN $PINS Q=vec1[6][3] D=n621 CK=CTS_120
+ RB=FE_OFN247_i_reset_n_i
Xsys_reg_reg[24] QDFFRBN $PINS Q=vec0_1D[24] D=n489 CK=CTS_137
+ RB=FE_OFN439_i_reset_n_i
Xsys_reg_reg[16] QDFFRBN $PINS Q=vec0_1D[16] D=n497 CK=CTS_137
+ RB=FE_OFN373_i_reset_n_i
Xsys_reg_reg[25] QDFFRBN $PINS Q=vec0_1D[25] D=n488 CK=CTS_137
+ RB=FE_OFN259_i_reset_n_i
Xsys_reg_reg[17] QDFFRBN $PINS Q=vec0_1D[17] D=n496 CK=CTS_137
+ RB=FE_OFN373_i_reset_n_i
Xsys_reg_reg[26] QDFFRBN $PINS Q=vec0_1D[26] D=n487 CK=CTS_137
+ RB=FE_OFN211_i_reset_n_i
Xsys_reg_reg[18] QDFFRBN $PINS Q=vec0_1D[18] D=n495 CK=CTS_137
+ RB=FE_OFN211_i_reset_n_i
Xsys_reg_reg[27] QDFFRBN $PINS Q=vec0_1D[27] D=n486 CK=CTS_139
+ RB=FE_OFN316_i_reset_n_i
Xsys_reg_reg[19] QDFFRBN $PINS Q=vec0_1D[19] D=n494 CK=CTS_137
+ RB=FE_OFN376_i_reset_n_i
Xext_reg_reg[83] QDFFRBN $PINS Q=vec2_1D[83] D=n337 CK=CTS_141
+ RB=FE_OFN388_i_reset_n_i
Xext_reg_reg[82] QDFFRBN $PINS Q=vec2_1D[82] D=n338 CK=CTS_141
+ RB=FE_OFN329_i_reset_n_i
Xext_reg_reg[81] QDFFRBN $PINS Q=vec2_1D[81] D=n339 CK=CTS_138
+ RB=FE_OFN325_i_reset_n_i
Xext_reg_reg[80] QDFFRBN $PINS Q=vec2_1D[80] D=n340 CK=CTS_138
+ RB=FE_OFN325_i_reset_n_i
Xext_reg_reg[79] QDFFRBN $PINS Q=vec2_1D[79] D=n341 CK=CTS_138
+ RB=FE_OFN387_i_reset_n_i
Xext_reg_reg[78] QDFFRBN $PINS Q=vec2_1D[78] D=n342 CK=CTS_139
+ RB=FE_OFN445_i_reset_n_i
Xext_reg_reg[77] QDFFRBN $PINS Q=vec2_1D[77] D=n343 CK=CTS_139
+ RB=FE_OFN314_i_reset_n_i
Xext_reg_reg[76] QDFFRBN $PINS Q=vec2_1D[76] D=n344 CK=CTS_139
+ RB=FE_OFN261_i_reset_n_i
Xext_reg_reg[75] QDFFRBN $PINS Q=vec2_1D[75] D=n345 CK=CTS_139
+ RB=FE_OFN313_i_reset_n_i
Xext_reg_reg[74] QDFFRBN $PINS Q=vec2_1D[74] D=n346 CK=CTS_137
+ RB=FE_OFN377_i_reset_n_i
Xext_reg_reg[73] QDFFRBN $PINS Q=vec2_1D[73] D=n347 CK=CTS_137
+ RB=FE_OFN476_i_reset_n_i
Xext_reg_reg[72] QDFFRBN $PINS Q=vec2_1D[72] D=n348 CK=CTS_137
+ RB=FE_OFN492_i_reset_n_i
Xext_reg_reg[71] QDFFRBN $PINS Q=vec2_1D[71] D=n349 CK=CTS_141
+ RB=FE_OFN272_i_reset_n_i
Xext_reg_reg[70] QDFFRBN $PINS Q=vec2_1D[70] D=n350 CK=CTS_141
+ RB=FE_OFN271_i_reset_n_i
Xext_reg_reg[69] QDFFRBN $PINS Q=vec2_1D[69] D=n351 CK=CTS_138
+ RB=FE_OFN179_i_reset_n_i
Xext_reg_reg[68] QDFFRBN $PINS Q=vec2_1D[68] D=n352 CK=CTS_138
+ RB=FE_OFN326_i_reset_n_i
Xext_reg_reg[67] QDFFRBN $PINS Q=vec2_1D[67] D=n353 CK=CTS_138
+ RB=FE_OFN326_i_reset_n_i
Xext_reg_reg[66] QDFFRBN $PINS Q=vec2_1D[66] D=n354 CK=CTS_121
+ RB=FE_OFN172_i_reset_n_i
Xext_reg_reg[65] QDFFRBN $PINS Q=vec2_1D[65] D=n355 CK=CTS_121
+ RB=FE_OFN173_i_reset_n_i
Xext_reg_reg[64] QDFFRBN $PINS Q=vec2_1D[64] D=n356 CK=CTS_121
+ RB=FE_OFN260_i_reset_n_i
Xext_reg_reg[63] QDFFRBN $PINS Q=vec2_1D[63] D=n357 CK=CTS_121
+ RB=FE_OFN376_i_reset_n_i
Xext_reg_reg[62] QDFFRBN $PINS Q=vec2_1D[62] D=n358 CK=CTS_116
+ RB=FE_OFN171_i_reset_n_i
Xext_reg_reg[61] QDFFRBN $PINS Q=vec2_1D[61] D=n359 CK=CTS_116
+ RB=FE_OFN494_i_reset_n_i
Xext_reg_reg[60] QDFFRBN $PINS Q=vec2_1D[60] D=n360 CK=CTS_116
+ RB=FE_OFN493_i_reset_n_i
Xext_reg_reg[59] QDFFRBN $PINS Q=vec2_1D[59] D=n361 CK=CTS_141
+ RB=FE_OFN329_i_reset_n_i
Xext_reg_reg[58] QDFFRBN $PINS Q=vec2_1D[58] D=n362 CK=CTS_138
+ RB=FE_OFN325_i_reset_n_i
Xext_reg_reg[57] QDFFRBN $PINS Q=vec2_1D[57] D=n363 CK=CTS_138
+ RB=FE_OFN325_i_reset_n_i
Xext_reg_reg[56] QDFFRBN $PINS Q=vec2_1D[56] D=n364 CK=CTS_138
+ RB=FE_OFN327_i_reset_n_i
Xext_reg_reg[55] QDFFRBN $PINS Q=vec2_1D[55] D=n365 CK=CTS_138
+ RB=FE_OFN327_i_reset_n_i
Xext_reg_reg[54] QDFFRBN $PINS Q=vec2_1D[54] D=n366 CK=CTS_139
+ RB=FE_OFN174_i_reset_n_i
Xext_reg_reg[53] QDFFRBN $PINS Q=vec2_1D[53] D=n367 CK=CTS_139
+ RB=FE_OFN314_i_reset_n_i
Xext_reg_reg[52] QDFFRBN $PINS Q=vec2_1D[52] D=n368 CK=CTS_139
+ RB=FE_OFN261_i_reset_n_i
Xext_reg_reg[51] QDFFRBN $PINS Q=vec2_1D[51] D=n369 CK=CTS_139
+ RB=FE_OFN313_i_reset_n_i
Xext_reg_reg[50] QDFFRBN $PINS Q=vec2_1D[50] D=n370 CK=CTS_137
+ RB=FE_OFN317_i_reset_n_i
Xext_reg_reg[49] QDFFRBN $PINS Q=vec2_1D[49] D=n371 CK=CTS_137
+ RB=FE_OFN476_i_reset_n_i
Xext_reg_reg[48] QDFFRBN $PINS Q=vec2_1D[48] D=n372 CK=CTS_137
+ RB=FE_OFN438_i_reset_n_i
Xext_reg_reg[47] QDFFRBN $PINS Q=vec2_1D[47] D=n373 CK=CTS_141
+ RB=FE_OFN220_i_reset_n_i
Xext_reg_reg[46] QDFFRBN $PINS Q=vec2_1D[46] D=n374 CK=CTS_144
+ RB=FE_OFN220_i_reset_n_i
Xext_reg_reg[45] QDFFRBN $PINS Q=vec2_1D[45] D=n375 CK=CTS_144
+ RB=FE_OFN253_i_reset_n_i
Xext_reg_reg[44] QDFFRBN $PINS Q=vec2_1D[44] D=n376 CK=CTS_122
+ RB=FE_OFN364_i_reset_n_i
Xext_reg_reg[43] QDFFRBN $PINS Q=vec2_1D[43] D=n377 CK=CTS_122
+ RB=FE_OFN431_i_reset_n_i
Xext_reg_reg[42] QDFFRBN $PINS Q=vec2_1D[42] D=n378 CK=CTS_121
+ RB=FE_OFN489_i_reset_n_i
Xext_reg_reg[41] QDFFRBN $PINS Q=vec2_1D[41] D=n379 CK=CTS_121
+ RB=FE_OFN255_i_reset_n_i
Xext_reg_reg[40] QDFFRBN $PINS Q=vec2_1D[40] D=n380 CK=CTS_120
+ RB=FE_OFN256_i_reset_n_i
Xext_reg_reg[39] QDFFRBN $PINS Q=vec2_1D[39] D=n381 CK=CTS_121
+ RB=FE_OFN366_i_reset_n_i
Xext_reg_reg[38] QDFFRBN $PINS Q=vec2_1D[38] D=n382 CK=CTS_116
+ RB=FE_OFN209_i_reset_n_i
Xext_reg_reg[37] QDFFRBN $PINS Q=vec2_1D[37] D=n383 CK=CTS_118
+ RB=FE_OFN309_i_reset_n_i
Xext_reg_reg[36] QDFFRBN $PINS Q=vec2_1D[36] D=n384 CK=CTS_118
+ RB=FE_OFN309_i_reset_n_i
Xext_reg_reg[35] QDFFRBN $PINS Q=vec2_1D[35] D=n385 CK=CTS_141
+ RB=FE_OFN271_i_reset_n_i
Xext_reg_reg[34] QDFFRBN $PINS Q=vec2_1D[34] D=n386 CK=CTS_144
+ RB=FE_OFN168_i_reset_n_i
Xext_reg_reg[33] QDFFRBN $PINS Q=vec2_1D[33] D=n387 CK=CTS_144
+ RB=FE_OFN305_i_reset_n_i
Xext_reg_reg[32] QDFFRBN $PINS Q=vec2_1D[32] D=n388 CK=CTS_122
+ RB=FE_OFN364_i_reset_n_i
Xext_reg_reg[31] QDFFRBN $PINS Q=vec2_1D[31] D=n389 CK=CTS_121
+ RB=FE_OFN489_i_reset_n_i
Xext_reg_reg[30] QDFFRBN $PINS Q=vec2_1D[30] D=n390 CK=CTS_121
+ RB=FE_OFN208_i_reset_n_i
Xext_reg_reg[29] QDFFRBN $PINS Q=vec2_1D[29] D=n391 CK=CTS_121
+ RB=FE_OFN208_i_reset_n_i
Xext_reg_reg[28] QDFFRBN $PINS Q=vec2_1D[28] D=n392 CK=CTS_121
+ RB=FE_OFN256_i_reset_n_i
Xext_reg_reg[27] QDFFRBN $PINS Q=vec2_1D[27] D=n393 CK=CTS_118
+ RB=FE_OFN366_i_reset_n_i
Xext_reg_reg[26] QDFFRBN $PINS Q=vec2_1D[26] D=n394 CK=CTS_118
+ RB=FE_OFN209_i_reset_n_i
Xext_reg_reg[25] QDFFRBN $PINS Q=vec2_1D[25] D=n395 CK=CTS_118
+ RB=FE_OFN210_i_reset_n_i
Xext_reg_reg[24] QDFFRBN $PINS Q=vec2_1D[24] D=n396 CK=CTS_116
+ RB=FE_OFN310_i_reset_n_i
Xdec1_begin_reg QDFFRBN $PINS Q=dec1_begin D=n336 CK=CTS_144
+ RB=FE_OFN141_i_reset_n_i
Xiter_counter_reg[1] QDFFRBN $PINS Q=iter_counter[1] D=n687 CK=CTS_141
+ RB=FE_OFN447_i_reset_n_i
Xiter_counter_reg[2] QDFFRBN $PINS Q=iter_counter[2] D=n688 CK=CTS_141
+ RB=FE_OFN388_i_reset_n_i
Xiter_counter_reg[4] QDFFRBN $PINS Q=iter_counter[4] D=n690 CK=CTS_141
+ RB=FE_OFN328_i_reset_n_i
Xiter_counter_reg[5] QDFFRBN $PINS Q=iter_counter[5] D=n691 CK=CTS_141
+ RB=FE_OFN272_i_reset_n_i
Xtemp_LLR_reg[0][11] QDFFRBN $PINS Q=temp_LLR[0][11] D=n421 CK=CTS_141
+ RB=FE_OFN388_i_reset_n_i
Xtemp_LLR_reg[0][10] QDFFRBN $PINS Q=temp_LLR[0][10] D=n422 CK=CTS_141
+ RB=FE_OFN329_i_reset_n_i
Xtemp_LLR_reg[1][11] QDFFRBN $PINS Q=temp_LLR[1][11] D=n433 CK=CTS_138
+ RB=FE_OFN324_i_reset_n_i
Xtemp_LLR_reg[1][10] QDFFRBN $PINS Q=temp_LLR[1][10] D=n434 CK=CTS_141
+ RB=FE_OFN179_i_reset_n_i
Xtemp_LLR_reg[2][11] QDFFRBN $PINS Q=temp_LLR[2][11] D=n445 CK=CTS_141
+ RB=FE_OFN329_i_reset_n_i
Xtemp_LLR_reg[2][10] QDFFRBN $PINS Q=temp_LLR[2][10] D=n446 CK=CTS_138
+ RB=FE_OFN325_i_reset_n_i
Xtemp_LLR_reg[3][11] QDFFRBN $PINS Q=temp_LLR[3][11] D=n457 CK=CTS_141
+ RB=FE_OFN220_i_reset_n_i
Xtemp_LLR_reg[3][10] QDFFRBN $PINS Q=temp_LLR[3][10] D=n458 CK=CTS_144
+ RB=FE_OFN252_i_reset_n_i
Xtemp_LLR_reg[4][11] QDFFRBN $PINS Q=temp_LLR[4][11] D=n469 CK=CTS_141
+ RB=FE_OFN324_i_reset_n_i
Xtemp_LLR_reg[4][10] QDFFRBN $PINS Q=temp_LLR[4][10] D=n470 CK=CTS_144
+ RB=FE_OFN251_i_reset_n_i
Xiter_counter_reg[3] QDFFRBN $PINS Q=iter_counter[3] D=n689 CK=CTS_141
+ RB=FE_OFN447_i_reset_n_i
Xiter_counter_reg[0] QDFFRBN $PINS Q=iter_counter[0] D=n686 CK=CTS_141
+ RB=FE_OFN447_i_reset_n_i
Xread_counter_reg[0] QDFFRBN $PINS Q=read_counter[0] D=n333 CK=CTS_122
+ RB=FE_OFN363_i_reset_n_i
Xread_counter_reg[1] QDFFRBN $PINS Q=read_counter[1] D=n332 CK=CTS_122
+ RB=FE_OFN363_i_reset_n_i
Xtemp_LLR1_reg[4][10] QDFFRBN $PINS Q=temp_LLR1[4][10] D=n636 CK=CTS_144
+ RB=FE_OFN168_i_reset_n_i
Xtemp_LLR1_reg[3][10] QDFFRBN $PINS Q=temp_LLR1[3][10] D=n648 CK=CTS_144
+ RB=FE_OFN168_i_reset_n_i
Xtemp_LLR1_reg[2][10] QDFFRBN $PINS Q=temp_LLR1[2][10] D=n660 CK=CTS_138
+ RB=FE_OFN268_i_reset_n_i
Xtemp_LLR1_reg[1][10] QDFFRBN $PINS Q=temp_LLR1[1][10] D=n672 CK=CTS_141
+ RB=FE_OFN271_i_reset_n_i
Xtemp_LLR1_reg[0][10] QDFFRBN $PINS Q=temp_LLR1[0][10] D=n684 CK=CTS_141
+ RB=FE_OFN388_i_reset_n_i
Xtemp_LLR1_reg[0][11] QDFFRBN $PINS Q=temp_LLR1[0][11] D=n692 CK=CTS_141
+ RB=FE_OFN388_i_reset_n_i
Xtemp_LLR1_reg[4][11] QDFFRBN $PINS Q=temp_LLR1[4][11] D=n637 CK=CTS_141
+ RB=FE_OFN271_i_reset_n_i
Xtemp_LLR1_reg[3][11] QDFFRBN $PINS Q=temp_LLR1[3][11] D=n649 CK=CTS_141
+ RB=FE_OFN271_i_reset_n_i
Xtemp_LLR1_reg[2][11] QDFFRBN $PINS Q=temp_LLR1[2][11] D=n661 CK=CTS_141
+ RB=FE_OFN329_i_reset_n_i
Xtemp_LLR1_reg[1][11] QDFFRBN $PINS Q=temp_LLR1[1][11] D=n673 CK=CTS_141
+ RB=FE_OFN324_i_reset_n_i
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=n334 CK=CTS_144
+ RB=FE_OFN168_i_reset_n_i
Xtemp_LLR_reg[0][9] QDFFRBN $PINS Q=temp_LLR[0][9] D=n423 CK=CTS_138
+ RB=FE_OFN446_i_reset_n_i
Xtemp_LLR_reg[0][8] QDFFRBN $PINS Q=temp_LLR[0][8] D=n424 CK=CTS_138
+ RB=FE_OFN446_i_reset_n_i
Xtemp_LLR_reg[0][7] QDFFRBN $PINS Q=temp_LLR[0][7] D=n425 CK=CTS_138
+ RB=FE_OFN387_i_reset_n_i
Xtemp_LLR_reg[1][9] QDFFRBN $PINS Q=temp_LLR[1][9] D=n435 CK=CTS_144
+ RB=FE_OFN475_i_reset_n_i
Xtemp_LLR_reg[1][8] QDFFRBN $PINS Q=temp_LLR[1][8] D=n436 CK=CTS_138
+ RB=FE_OFN475_i_reset_n_i
Xtemp_LLR_reg[1][7] QDFFRBN $PINS Q=temp_LLR[1][7] D=n437 CK=CTS_138
+ RB=FE_OFN475_i_reset_n_i
Xtemp_LLR_reg[2][9] QDFFRBN $PINS Q=temp_LLR[2][9] D=n447 CK=CTS_138
+ RB=FE_OFN446_i_reset_n_i
Xtemp_LLR_reg[2][8] QDFFRBN $PINS Q=temp_LLR[2][8] D=n448 CK=CTS_138
+ RB=FE_OFN387_i_reset_n_i
Xtemp_LLR_reg[2][7] QDFFRBN $PINS Q=temp_LLR[2][7] D=n449 CK=CTS_139
+ RB=FE_OFN445_i_reset_n_i
Xtemp_LLR_reg[3][9] QDFFRBN $PINS Q=temp_LLR[3][9] D=n459 CK=CTS_122
+ RB=FE_OFN365_i_reset_n_i
Xtemp_LLR_reg[3][8] QDFFRBN $PINS Q=temp_LLR[3][8] D=n460 CK=CTS_122
+ RB=FE_OFN431_i_reset_n_i
Xtemp_LLR_reg[3][7] QDFFRBN $PINS Q=temp_LLR[3][7] D=n461 CK=CTS_122
+ RB=FE_OFN474_i_reset_n_i
Xtemp_LLR_reg[4][9] QDFFRBN $PINS Q=temp_LLR[4][9] D=n471 CK=CTS_138
+ RB=FE_OFN432_i_reset_n_i
Xtemp_LLR_reg[4][8] QDFFRBN $PINS Q=temp_LLR[4][8] D=n472 CK=CTS_138
+ RB=FE_OFN432_i_reset_n_i
Xtemp_LLR_reg[4][7] QDFFRBN $PINS Q=temp_LLR[4][7] D=n473 CK=CTS_121
+ RB=FE_OFN491_i_reset_n_i
Xstart_reg_reg QDFFRBN $PINS Q=start_reg D=start_i CK=CTS_133
+ RB=FE_OFN3_i_reset_n_i
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=n335 CK=CTS_144
+ RB=FE_OFN141_i_reset_n_i
Xread_counter_reg[2] QDFFRBN $PINS Q=read_counter[2] D=n331 CK=CTS_144
+ RB=FE_OFN362_i_reset_n_i
Xtemp_LLR1_reg[4][6] QDFFRBN $PINS Q=temp_LLR1[4][6] D=n632 CK=CTS_121
+ RB=FE_OFN474_i_reset_n_i
Xtemp_LLR1_reg[4][7] QDFFRBN $PINS Q=temp_LLR1[4][7] D=n633 CK=CTS_121
+ RB=FE_OFN474_i_reset_n_i
Xtemp_LLR1_reg[4][8] QDFFRBN $PINS Q=temp_LLR1[4][8] D=n634 CK=CTS_122
+ RB=FE_OFN431_i_reset_n_i
Xtemp_LLR1_reg[4][9] QDFFRBN $PINS Q=temp_LLR1[4][9] D=n635 CK=CTS_122
+ RB=FE_OFN365_i_reset_n_i
Xtemp_LLR1_reg[3][6] QDFFRBN $PINS Q=temp_LLR1[3][6] D=n644 CK=CTS_121
+ RB=FE_OFN255_i_reset_n_i
Xtemp_LLR1_reg[3][7] QDFFRBN $PINS Q=temp_LLR1[3][7] D=n645 CK=CTS_122
+ RB=FE_OFN474_i_reset_n_i
Xtemp_LLR1_reg[3][8] QDFFRBN $PINS Q=temp_LLR1[3][8] D=n646 CK=CTS_122
+ RB=FE_OFN365_i_reset_n_i
Xtemp_LLR1_reg[3][9] QDFFRBN $PINS Q=temp_LLR1[3][9] D=n647 CK=CTS_122
+ RB=FE_OFN432_i_reset_n_i
Xtemp_LLR1_reg[2][6] QDFFRBN $PINS Q=temp_LLR1[2][6] D=n656 CK=CTS_139
+ RB=FE_OFN314_i_reset_n_i
Xtemp_LLR1_reg[2][7] QDFFRBN $PINS Q=temp_LLR1[2][7] D=n657 CK=CTS_139
+ RB=FE_OFN445_i_reset_n_i
Xtemp_LLR1_reg[2][8] QDFFRBN $PINS Q=temp_LLR1[2][8] D=n658 CK=CTS_138
+ RB=FE_OFN269_i_reset_n_i
Xtemp_LLR1_reg[2][9] QDFFRBN $PINS Q=temp_LLR1[2][9] D=n659 CK=CTS_138
+ RB=FE_OFN325_i_reset_n_i
Xtemp_LLR1_reg[1][6] QDFFRBN $PINS Q=temp_LLR1[1][6] D=n668 CK=CTS_121
+ RB=FE_OFN173_i_reset_n_i
Xtemp_LLR1_reg[1][7] QDFFRBN $PINS Q=temp_LLR1[1][7] D=n669 CK=CTS_139
+ RB=FE_OFN172_i_reset_n_i
Xtemp_LLR1_reg[1][8] QDFFRBN $PINS Q=temp_LLR1[1][8] D=n670 CK=CTS_138
+ RB=FE_OFN270_i_reset_n_i
Xtemp_LLR1_reg[1][9] QDFFRBN $PINS Q=temp_LLR1[1][9] D=n671 CK=CTS_138
+ RB=FE_OFN179_i_reset_n_i
Xtemp_LLR1_reg[0][6] QDFFRBN $PINS Q=temp_LLR1[0][6] D=n680 CK=CTS_139
+ RB=FE_OFN314_i_reset_n_i
Xtemp_LLR1_reg[0][7] QDFFRBN $PINS Q=temp_LLR1[0][7] D=n681 CK=CTS_139
+ RB=FE_OFN445_i_reset_n_i
Xtemp_LLR1_reg[0][8] QDFFRBN $PINS Q=temp_LLR1[0][8] D=n682 CK=CTS_138
+ RB=FE_OFN387_i_reset_n_i
Xtemp_LLR1_reg[0][9] QDFFRBN $PINS Q=temp_LLR1[0][9] D=n683 CK=CTS_138
+ RB=FE_OFN446_i_reset_n_i
Xtemp_LLR_reg[0][6] QDFFRBN $PINS Q=temp_LLR[0][6] D=n426 CK=CTS_139
+ RB=FE_OFN445_i_reset_n_i
Xtemp_LLR_reg[0][5] QDFFRBN $PINS Q=temp_LLR[0][5] D=n427 CK=CTS_139
+ RB=FE_OFN315_i_reset_n_i
Xtemp_LLR_reg[0][4] QDFFRBN $PINS Q=temp_LLR[0][4] D=n428 CK=CTS_139
+ RB=FE_OFN313_i_reset_n_i
Xtemp_LLR_reg[1][6] QDFFRBN $PINS Q=temp_LLR[1][6] D=n438 CK=CTS_121
+ RB=FE_OFN491_i_reset_n_i
Xtemp_LLR_reg[1][5] QDFFRBN $PINS Q=temp_LLR[1][5] D=n439 CK=CTS_121
+ RB=FE_OFN436_i_reset_n_i
Xtemp_LLR_reg[1][4] QDFFRBN $PINS Q=temp_LLR[1][4] D=n440 CK=CTS_121
+ RB=FE_OFN436_i_reset_n_i
Xtemp_LLR_reg[2][6] QDFFRBN $PINS Q=temp_LLR[2][6] D=n450 CK=CTS_139
+ RB=FE_OFN314_i_reset_n_i
Xtemp_LLR_reg[2][5] QDFFRBN $PINS Q=temp_LLR[2][5] D=n451 CK=CTS_139
+ RB=FE_OFN314_i_reset_n_i
Xtemp_LLR_reg[2][4] QDFFRBN $PINS Q=temp_LLR[2][4] D=n452 CK=CTS_139
+ RB=FE_OFN313_i_reset_n_i
Xtemp_LLR_reg[3][6] QDFFRBN $PINS Q=temp_LLR[3][6] D=n462 CK=CTS_121
+ RB=FE_OFN474_i_reset_n_i
Xtemp_LLR_reg[3][5] QDFFRBN $PINS Q=temp_LLR[3][5] D=n463 CK=CTS_121
+ RB=FE_OFN255_i_reset_n_i
Xtemp_LLR_reg[3][4] QDFFRBN $PINS Q=temp_LLR[3][4] D=n464 CK=CTS_121
+ RB=FE_OFN308_i_reset_n_i
Xtemp_LLR_reg[4][6] QDFFRBN $PINS Q=temp_LLR[4][6] D=n474 CK=CTS_121
+ RB=FE_OFN436_i_reset_n_i
Xtemp_LLR_reg[4][5] QDFFRBN $PINS Q=temp_LLR[4][5] D=n475 CK=CTS_121
+ RB=FE_OFN436_i_reset_n_i
Xtemp_LLR_reg[4][4] QDFFRBN $PINS Q=temp_LLR[4][4] D=n476 CK=CTS_121
+ RB=FE_OFN435_i_reset_n_i
Xtemp_LLR1_reg[4][3] QDFFRBN $PINS Q=temp_LLR1[4][3] D=n629 CK=CTS_116
+ RB=FE_OFN433_i_reset_n_i
Xtemp_LLR1_reg[4][4] QDFFRBN $PINS Q=temp_LLR1[4][4] D=n630 CK=CTS_121
+ RB=FE_OFN306_i_reset_n_i
Xtemp_LLR1_reg[4][5] QDFFRBN $PINS Q=temp_LLR1[4][5] D=n631 CK=CTS_121
+ RB=FE_OFN306_i_reset_n_i
Xtemp_LLR1_reg[3][3] QDFFRBN $PINS Q=temp_LLR1[3][3] D=n641 CK=CTS_121
+ RB=FE_OFN308_i_reset_n_i
Xtemp_LLR1_reg[3][4] QDFFRBN $PINS Q=temp_LLR1[3][4] D=n642 CK=CTS_121
+ RB=FE_OFN368_i_reset_n_i
Xtemp_LLR1_reg[3][5] QDFFRBN $PINS Q=temp_LLR1[3][5] D=n643 CK=CTS_121
+ RB=FE_OFN436_i_reset_n_i
Xtemp_LLR1_reg[2][3] QDFFRBN $PINS Q=temp_LLR1[2][3] D=n653 CK=CTS_139
+ RB=FE_OFN313_i_reset_n_i
Xtemp_LLR1_reg[2][4] QDFFRBN $PINS Q=temp_LLR1[2][4] D=n654 CK=CTS_139
+ RB=FE_OFN261_i_reset_n_i
Xtemp_LLR1_reg[2][5] QDFFRBN $PINS Q=temp_LLR1[2][5] D=n655 CK=CTS_139
+ RB=FE_OFN212_i_reset_n_i
Xtemp_LLR1_reg[1][3] QDFFRBN $PINS Q=temp_LLR1[1][3] D=n665 CK=CTS_121
+ RB=FE_OFN143_i_reset_n_i
Xtemp_LLR1_reg[1][4] QDFFRBN $PINS Q=temp_LLR1[1][4] D=n666 CK=CTS_121
+ RB=FE_OFN316_i_reset_n_i
Xtemp_LLR1_reg[1][5] QDFFRBN $PINS Q=temp_LLR1[1][5] D=n667 CK=CTS_139
+ RB=FE_OFN260_i_reset_n_i
Xtemp_LLR1_reg[0][3] QDFFRBN $PINS Q=temp_LLR1[0][3] D=n677 CK=CTS_139
+ RB=FE_OFN313_i_reset_n_i
Xtemp_LLR1_reg[0][4] QDFFRBN $PINS Q=temp_LLR1[0][4] D=n678 CK=CTS_139
+ RB=FE_OFN315_i_reset_n_i
Xtemp_LLR1_reg[0][5] QDFFRBN $PINS Q=temp_LLR1[0][5] D=n679 CK=CTS_139
+ RB=FE_OFN315_i_reset_n_i
Xvec0_reg[0][3] QDFFRBN $PINS Q=N851 D=n517 CK=CTS_137 RB=FE_OFN262_i_reset_n_i
Xvec0_reg[1][3] QDFFRBN $PINS Q=N577 D=n557 CK=CTS_116 RB=FE_OFN367_i_reset_n_i
Xvec0_reg[2][3] QDFFRBN $PINS Q=N923 D=n569 CK=CTS_137 RB=FE_OFN374_i_reset_n_i
Xvec0_reg[3][3] QDFFRBN $PINS Q=N613 D=n581 CK=CTS_118 RB=FE_OFN433_i_reset_n_i
Xvec0_reg[4][3] QDFFRBN $PINS Q=N995 D=n593 CK=CTS_118 RB=FE_OFN366_i_reset_n_i
Xtemp_LLR_reg[0][3] QDFFRBN $PINS Q=temp_LLR[0][3] D=n429 CK=CTS_137
+ RB=FE_OFN377_i_reset_n_i
Xtemp_LLR_reg[0][2] QDFFRBN $PINS Q=temp_LLR[0][2] D=n430 CK=CTS_137
+ RB=FE_OFN377_i_reset_n_i
Xtemp_LLR_reg[0][1] QDFFRBN $PINS Q=temp_LLR[0][1] D=n431 CK=CTS_137
+ RB=FE_OFN492_i_reset_n_i
Xtemp_LLR_reg[0][0] QDFFRBN $PINS Q=temp_LLR[0][0] D=n432 CK=CTS_137
+ RB=FE_OFN492_i_reset_n_i
Xtemp_LLR_reg[1][3] QDFFRBN $PINS Q=temp_LLR[1][3] D=n441 CK=CTS_121
+ RB=FE_OFN435_i_reset_n_i
Xtemp_LLR_reg[1][2] QDFFRBN $PINS Q=temp_LLR[1][2] D=n442 CK=CTS_116
+ RB=FE_OFN171_i_reset_n_i
Xtemp_LLR_reg[1][1] QDFFRBN $PINS Q=temp_LLR[1][1] D=n443 CK=CTS_116
+ RB=FE_OFN494_i_reset_n_i
Xtemp_LLR_reg[1][0] QDFFRBN $PINS Q=temp_LLR[1][0] D=n444 CK=CTS_116
+ RB=FE_OFN493_i_reset_n_i
Xtemp_LLR_reg[2][3] QDFFRBN $PINS Q=temp_LLR[2][3] D=n453 CK=CTS_139
+ RB=FE_OFN377_i_reset_n_i
Xtemp_LLR_reg[2][2] QDFFRBN $PINS Q=temp_LLR[2][2] D=n454 CK=CTS_137
+ RB=FE_OFN317_i_reset_n_i
Xtemp_LLR_reg[2][1] QDFFRBN $PINS Q=temp_LLR[2][1] D=n455 CK=CTS_137
+ RB=FE_OFN375_i_reset_n_i
Xtemp_LLR_reg[2][0] QDFFRBN $PINS Q=temp_LLR[2][0] D=n456 CK=CTS_137
+ RB=FE_OFN377_i_reset_n_i
Xtemp_LLR_reg[3][3] QDFFRBN $PINS Q=temp_LLR[3][3] D=n465 CK=CTS_116
+ RB=FE_OFN308_i_reset_n_i
Xtemp_LLR_reg[3][2] QDFFRBN $PINS Q=temp_LLR[3][2] D=n466 CK=CTS_116
+ RB=FE_OFN209_i_reset_n_i
Xtemp_LLR_reg[3][1] QDFFRBN $PINS Q=temp_LLR[3][1] D=n467 CK=CTS_116
+ RB=FE_OFN258_i_reset_n_i
Xtemp_LLR_reg[3][0] QDFFRBN $PINS Q=temp_LLR[3][0] D=n468 CK=CTS_116
+ RB=FE_OFN310_i_reset_n_i
Xtemp_LLR_reg[4][3] QDFFRBN $PINS Q=temp_LLR[4][3] D=n477 CK=CTS_116
+ RB=FE_OFN143_i_reset_n_i
Xtemp_LLR_reg[4][2] QDFFRBN $PINS Q=temp_LLR[4][2] D=n478 CK=CTS_116
+ RB=FE_OFN437_i_reset_n_i
Xtemp_LLR_reg[4][1] QDFFRBN $PINS Q=temp_LLR[4][1] D=n479 CK=CTS_116
+ RB=FE_OFN371_i_reset_n_i
Xtemp_LLR_reg[4][0] QDFFRBN $PINS Q=temp_LLR[4][0] D=n480 CK=CTS_116
+ RB=FE_OFN310_i_reset_n_i
Xvec0_reg[0][0] QDFFRBN $PINS Q=N841 D=n514 CK=CTS_137 RB=FE_OFN439_i_reset_n_i
Xvec0_reg[2][0] QDFFRBN $PINS Q=N913 D=n566 CK=CTS_137 RB=FE_OFN439_i_reset_n_i
Xvec0_reg[0][1] QDFFRBN $PINS Q=N842 D=n515 CK=CTS_137 RB=FE_OFN373_i_reset_n_i
Xvec0_reg[2][1] QDFFRBN $PINS Q=N914 D=n567 CK=CTS_137 RB=FE_OFN375_i_reset_n_i
Xvec0_reg[0][2] QDFFRBN $PINS Q=N843 D=n516 CK=CTS_137 RB=FE_OFN317_i_reset_n_i
Xvec0_reg[2][2] QDFFRBN $PINS Q=N915 D=n568 CK=CTS_137 RB=FE_OFN259_i_reset_n_i
Xvec0_reg[1][0] QDFFRBN $PINS Q=N567 D=n554 CK=CTS_116 RB=FE_OFN372_i_reset_n_i
Xvec0_reg[3][0] QDFFRBN $PINS Q=N603 D=n578 CK=CTS_118 RB=FE_OFN210_i_reset_n_i
Xvec0_reg[4][0] QDFFRBN $PINS Q=N985 D=n590 CK=CTS_118 RB=FE_OFN258_i_reset_n_i
Xvec0_reg[1][1] QDFFRBN $PINS Q=N568 D=n555 CK=CTS_116 RB=FE_OFN437_i_reset_n_i
Xvec0_reg[3][1] QDFFRBN $PINS Q=N604 D=n579 CK=CTS_118 RB=FE_OFN437_i_reset_n_i
Xvec0_reg[4][1] QDFFRBN $PINS Q=N986 D=n591 CK=CTS_118 RB=FE_OFN170_i_reset_n_i
Xvec0_reg[1][2] QDFFRBN $PINS Q=N569 D=n556 CK=CTS_116 RB=FE_OFN367_i_reset_n_i
Xvec0_reg[3][2] QDFFRBN $PINS Q=N605 D=n580 CK=CTS_118 RB=FE_OFN209_i_reset_n_i
Xvec0_reg[4][2] QDFFRBN $PINS Q=N987 D=n592 CK=CTS_118 RB=FE_OFN433_i_reset_n_i
Xtemp_LLR1_reg[4][0] QDFFRBN $PINS Q=temp_LLR1[4][0] D=n626 CK=CTS_116
+ RB=FE_OFN258_i_reset_n_i
Xtemp_LLR1_reg[4][1] QDFFRBN $PINS Q=temp_LLR1[4][1] D=n627 CK=CTS_116
+ RB=FE_OFN258_i_reset_n_i
Xtemp_LLR1_reg[4][2] QDFFRBN $PINS Q=temp_LLR1[4][2] D=n628 CK=CTS_116
+ RB=FE_OFN437_i_reset_n_i
Xtemp_LLR1_reg[3][0] QDFFRBN $PINS Q=temp_LLR1[3][0] D=n638 CK=CTS_116
+ RB=FE_OFN310_i_reset_n_i
Xtemp_LLR1_reg[3][1] QDFFRBN $PINS Q=temp_LLR1[3][1] D=n639 CK=CTS_116
+ RB=FE_OFN310_i_reset_n_i
Xtemp_LLR1_reg[3][2] QDFFRBN $PINS Q=temp_LLR1[3][2] D=n640 CK=CTS_116
+ RB=FE_OFN437_i_reset_n_i
Xtemp_LLR1_reg[2][0] QDFFRBN $PINS Q=temp_LLR1[2][0] D=n650 CK=CTS_137
+ RB=FE_OFN438_i_reset_n_i
Xtemp_LLR1_reg[2][1] QDFFRBN $PINS Q=temp_LLR1[2][1] D=n651 CK=CTS_137
+ RB=FE_OFN476_i_reset_n_i
Xtemp_LLR1_reg[2][2] QDFFRBN $PINS Q=temp_LLR1[2][2] D=n652 CK=CTS_137
+ RB=FE_OFN438_i_reset_n_i
Xtemp_LLR1_reg[1][0] QDFFRBN $PINS Q=temp_LLR1[1][0] D=n662 CK=CTS_116
+ RB=FE_OFN493_i_reset_n_i
Xtemp_LLR1_reg[1][1] QDFFRBN $PINS Q=temp_LLR1[1][1] D=n663 CK=CTS_116
+ RB=FE_OFN494_i_reset_n_i
Xtemp_LLR1_reg[1][2] QDFFRBN $PINS Q=temp_LLR1[1][2] D=n664 CK=CTS_116
+ RB=FE_OFN372_i_reset_n_i
Xtemp_LLR1_reg[0][0] QDFFRBN $PINS Q=temp_LLR1[0][0] D=n674 CK=CTS_137
+ RB=FE_OFN492_i_reset_n_i
Xtemp_LLR1_reg[0][1] QDFFRBN $PINS Q=temp_LLR1[0][1] D=n675 CK=CTS_137
+ RB=FE_OFN492_i_reset_n_i
Xtemp_LLR1_reg[0][2] QDFFRBN $PINS Q=temp_LLR1[0][2] D=n676 CK=CTS_137
+ RB=FE_OFN377_i_reset_n_i
Xout_reg_reg[0] QDFFRBN $PINS Q=data_o[0] D=n485 CK=CTS_138
+ RB=FE_OFN446_i_reset_n_i
Xout_reg_reg[1] QDFFRBN $PINS Q=data_o[1] D=n484 CK=CTS_138
+ RB=FE_OFN446_i_reset_n_i
Xout_reg_reg[2] QDFFRBN $PINS Q=data_o[2] D=n483 CK=CTS_141
+ RB=FE_OFN447_i_reset_n_i
Xout_reg_reg[3] QDFFRBN $PINS Q=data_o[3] D=n482 CK=CTS_141
+ RB=FE_OFN447_i_reset_n_i
Xout_reg_reg[4] QDFFRBN $PINS Q=data_o[4] D=n481 CK=CTS_141
+ RB=FE_OFN447_i_reset_n_i
Xdone_reg QDFFRBN $PINS Q=done_o D=n685 CK=CTS_144 RB=FE_OFN253_i_reset_n_i
XU630 AN3 $PINS O=n694 I1=n267 I2=n81 I3=n268
XU631 INV1S $PINS O=n713 I=N995
XU644 INV1S $PINS O=n717 I=N851
XU651 AO12S $PINS O=n685 A1=n965 B1=done_o B2=n285
XU656 NR2 $PINS O=n270 I1=FE_OFN1438_n275 I2=FE_OFN571_FE_DBTN0_n712
XU662 OR2B1S $PINS O=n275 I1=FE_OFN539_FE_DBTN1_n711 B1=n710
XU663 INV1S $PINS O=n710 I=FE_OFN623_n85
XU857 NR2 $PINS O=n315 I1=n711 I2=n81
XU858 OAI112HS $PINS O=n336 A1=n75 B1=n712 C1=n966 C2=n72
XU859 MOAI1S $PINS O=n688 A1=FE_OFN670_n205 A2=n1032 B1=N1036 B2=n315
XU860 MOAI1S $PINS O=n687 A1=FE_OFN669_n205 A2=n1031 B1=N1035 B2=n315
XU861 MOAI1S $PINS O=n690 A1=FE_OFN670_n205 A2=n1034 B1=N1038 B2=n315
XU862 NR2 $PINS O=n268 I1=n943 I2=n269
XU863 OR2 $PINS O=n72 I1=n943 I2=n81
XU864 AOI12HS $PINS O=n205 A1=n269 B1=n73 B2=n943
XU865 OR2 $PINS O=n711 I1=n966 I2=n943
XU866 NR2 $PINS O=n85 I1=n286 I2=n967
XU867 ND3 $PINS O=n280 I1=n1035 I2=n1036 I3=n309
XU868 INV1S $PINS O=n966 I=n73
XU869 INV1S $PINS O=n967 I=n71
XU870 OR2 $PINS O=n712 I1=n313 I2=n943
XU871 INV1S $PINS O=n965 I=n267
XU884 ND3 $PINS O=n312 I1=n76 I2=n967 I3=n966
XU885 NR3 $PINS O=n331 I1=n1036 I2=n68 I3=n1035
XU886 ND3 $PINS O=n335 I1=n75 I2=n76 I3=n711
XU894 OAI22S $PINS O=n81 A1=n321 A2=n322 B1=n323 B2=n324
XU895 ND3 $PINS O=n323 I1=n1034 I2=n1029 I3=n1032
XU896 ND3 $PINS O=n324 I1=iter_counter[0] I2=n1031 I3=iter_counter[3]
XU897 XNR2HS $PINS O=n326 I1=temp_LLR1[4][11] I2=N983
XU898 XNR2HS $PINS O=n325 I1=temp_LLR1[0][11] I2=N875
XU899 MOAI1S $PINS O=n485 A1=N1019 A2=FE_DBTN2_n694 B1=data_o[0]
+ B2=FE_DBTN2_n694
XU900 MOAI1S $PINS O=n484 A1=N983 A2=FE_DBTN2_n694 B1=data_o[1]
+ B2=FE_DBTN2_n694
XU901 MOAI1S $PINS O=n483 A1=N947 A2=FE_OFN527_FE_DBTN2_n694 B1=data_o[2]
+ B2=FE_OFN527_FE_DBTN2_n694
XU902 MOAI1S $PINS O=n482 A1=N911 A2=FE_OFN527_FE_DBTN2_n694 B1=data_o[3]
+ B2=FE_OFN527_FE_DBTN2_n694
XU903 MOAI1S $PINS O=n481 A1=N875 A2=FE_OFN527_FE_DBTN2_n694 B1=data_o[4]
+ B2=FE_OFN527_FE_DBTN2_n694
XU904 MOAI1S $PINS O=n691 A1=FE_OFN670_n205 A2=n1029 B1=N1039 B2=n315
XU905 MOAI1S $PINS O=n686 A1=FE_OFN669_n205 A2=n1030 B1=n1030 B2=n315
XU906 INV1S $PINS O=n1030 I=iter_counter[0]
XU907 MOAI1S $PINS O=n689 A1=FE_OFN670_n205 A2=n1033 B1=N1037 B2=n315
XU908 INV1S $PINS O=n1033 I=iter_counter[3]
XU909 ND3 $PINS O=n321 I1=n327 I2=n328 I3=n329
XU910 XNR2HS $PINS O=n327 I1=temp_LLR1[2][11] I2=N947
XU911 XNR2HS $PINS O=n328 I1=temp_LLR1[1][11] I2=N1019
XU912 XNR2HS $PINS O=n329 I1=temp_LLR1[3][11] I2=N911
XU913 AOI22S $PINS O=n181 A1=vec2_1D[35] A2=FE_OFN637_n86 B1=N637
+ B2=FE_OFN565_FE_DBTN0_n712
XU914 AOI22S $PINS O=n182 A1=FE_OFN531_FE_DBTN1_n711 A2=N1019
+ B1=temp_LLR[4][11] B2=FE_OFN622_n85
XU915 AOI22S $PINS O=n157 A1=vec2_1D[47] A2=FE_OFN637_n86 B1=N601
+ B2=FE_OFN562_FE_DBTN0_n712
XU916 AOI22S $PINS O=n158 A1=FE_OFN530_FE_DBTN1_n711 A2=N983 B1=temp_LLR[3][11]
+ B2=n85
XU917 AOI22S $PINS O=n133 A1=vec2_1D[59] A2=FE_OFN640_n86 B1=N565
+ B2=FE_OFN575_FE_DBTN0_n712
XU918 AOI22S $PINS O=n134 A1=FE_OFN531_FE_DBTN1_n711 A2=N947 B1=temp_LLR[2][11]
+ B2=FE_OFN622_n85
XU919 AOI22S $PINS O=n109 A1=vec2_1D[71] A2=FE_OFN640_n86 B1=N529
+ B2=FE_OFN565_FE_DBTN0_n712
XU920 AOI22S $PINS O=n110 A1=FE_OFN531_FE_DBTN1_n711 A2=N911 B1=temp_LLR[1][11]
+ B2=FE_OFN622_n85
XU921 AOI22S $PINS O=n82 A1=vec2_1D[83] A2=FE_OFN640_n86 B1=N493
+ B2=FE_OFN575_FE_DBTN0_n712
XU922 AOI22S $PINS O=n83 A1=FE_OFN537_FE_DBTN1_n711 A2=N875 B1=temp_LLR[0][11]
+ B2=FE_OFN622_n85
XU923 MOAI1S $PINS O=n471 A1=FE_OFN662_n205 A2=FE_DBTN20_temp_LLR_4_9
+ B1=FE_OFN532_FE_DBTN1_n711 B2=N1017
XU925 MOAI1S $PINS O=n470 A1=FE_OFN662_n205 A2=FE_DBTN21_temp_LLR_4_10
+ B1=FE_OFN529_FE_DBTN1_n711 B2=N1018
XU927 MOAI1S $PINS O=n469 A1=FE_OFN661_n205 A2=FE_DBTN22_temp_LLR_4_11 B1=N1019
+ B2=FE_OFN531_FE_DBTN1_n711
XU929 MOAI1S $PINS O=n459 A1=FE_OFN660_n205 A2=FE_DBTN32_temp_LLR_3_9
+ B1=FE_OFN535_FE_DBTN1_n711 B2=N981
XU931 MOAI1S $PINS O=n458 A1=n205 A2=FE_DBTN33_temp_LLR_3_10
+ B1=FE_OFN529_FE_DBTN1_n711 B2=N982
XU933 MOAI1S $PINS O=n457 A1=FE_OFN661_n205 A2=FE_DBTN34_temp_LLR_3_11 B1=N983
+ B2=FE_OFN530_FE_DBTN1_n711
XU935 MOAI1S $PINS O=n447 A1=FE_OFN665_n205 A2=FE_DBTN44_temp_LLR_2_9
+ B1=FE_OFN540_FE_DBTN1_n711 B2=N945
XU937 MOAI1S $PINS O=n446 A1=FE_OFN665_n205 A2=FE_DBTN45_temp_LLR_2_10
+ B1=FE_OFN536_FE_DBTN1_n711 B2=N946
XU939 MOAI1S $PINS O=n445 A1=FE_OFN661_n205 A2=FE_DBTN46_temp_LLR_2_11 B1=N947
+ B2=FE_OFN536_FE_DBTN1_n711
XU941 MOAI1S $PINS O=n435 A1=FE_OFN662_n205 A2=FE_DBTN56_temp_LLR_1_9
+ B1=FE_OFN532_FE_DBTN1_n711 B2=N909
XU943 MOAI1S $PINS O=n434 A1=n205 A2=FE_DBTN57_temp_LLR_1_10 B1=FE_DBTN1_n711
+ B2=N910
XU945 MOAI1S $PINS O=n433 A1=FE_OFN661_n205 A2=FE_DBTN58_temp_LLR_1_11 B1=N911
+ B2=FE_OFN531_FE_DBTN1_n711
XU947 MOAI1S $PINS O=n423 A1=FE_OFN665_n205 A2=FE_DBTN68_temp_LLR_0_9
+ B1=FE_OFN536_FE_DBTN1_n711 B2=N873
XU949 MOAI1S $PINS O=n422 A1=FE_OFN669_n205 A2=FE_DBTN69_temp_LLR_0_10
+ B1=FE_OFN537_FE_DBTN1_n711 B2=N874
XU952 MOAI1S $PINS O=n421 A1=FE_OFN669_n205 A2=FE_DBTN70_temp_LLR_0_11 B1=N875
+ B2=FE_OFN537_FE_DBTN1_n711
XU954 AOI22S $PINS O=n186 A1=N1017 A2=FE_OFN532_FE_DBTN1_n711 B1=temp_LLR[4][9]
+ B2=FE_OFN621_n85
XU955 AOI22S $PINS O=n185 A1=vec2_1D[33] A2=FE_OFN636_n86 B1=N635
+ B2=FE_OFN559_FE_DBTN0_n712
XU956 AOI22S $PINS O=n184 A1=N1018 A2=FE_OFN529_FE_DBTN1_n711
+ B1=temp_LLR[4][10] B2=n85
XU957 AOI22S $PINS O=n183 A1=vec2_1D[34] A2=FE_OFN637_n86 B1=N636
+ B2=FE_OFN560_FE_DBTN0_n712
XU958 AOI22S $PINS O=n162 A1=N981 A2=FE_OFN532_FE_DBTN1_n711 B1=temp_LLR[3][9]
+ B2=FE_OFN621_n85
XU959 AOI22S $PINS O=n161 A1=vec2_1D[45] A2=FE_OFN636_n86 B1=N599
+ B2=FE_OFN559_FE_DBTN0_n712
XU960 AOI22S $PINS O=n160 A1=N982 A2=FE_OFN529_FE_DBTN1_n711 B1=temp_LLR[3][10]
+ B2=n85
XU961 AOI22S $PINS O=n159 A1=vec2_1D[46] A2=FE_OFN637_n86 B1=N600
+ B2=FE_OFN560_FE_DBTN0_n712
XU962 AOI22S $PINS O=n138 A1=N945 A2=FE_OFN540_FE_DBTN1_n711 B1=temp_LLR[2][9]
+ B2=FE_OFN626_n85
XU963 AOI22S $PINS O=n137 A1=vec2_1D[57] A2=FE_OFN645_n86 B1=N563
+ B2=FE_OFN581_FE_DBTN0_n712
XU964 AOI22S $PINS O=n136 A1=N946 A2=FE_OFN536_FE_DBTN1_n711 B1=temp_LLR[2][10]
+ B2=FE_OFN626_n85
XU965 AOI22S $PINS O=n135 A1=vec2_1D[58] A2=FE_OFN640_n86 B1=N564
+ B2=FE_OFN574_FE_DBTN0_n712
XU966 AOI22S $PINS O=n114 A1=N909 A2=FE_OFN529_FE_DBTN1_n711 B1=temp_LLR[1][9]
+ B2=FE_OFN621_n85
XU967 AOI22S $PINS O=n113 A1=vec2_1D[69] A2=FE_OFN636_n86 B1=N527
+ B2=FE_OFN563_FE_DBTN0_n712
XU968 AOI22S $PINS O=n112 A1=N910 A2=FE_OFN530_FE_DBTN1_n711 B1=temp_LLR[1][10]
+ B2=n85
XU969 AOI22S $PINS O=n111 A1=vec2_1D[70] A2=FE_OFN637_n86 B1=N528
+ B2=FE_OFN565_FE_DBTN0_n712
XU970 AOI22S $PINS O=n90 A1=N873 A2=FE_OFN536_FE_DBTN1_n711 B1=temp_LLR[0][9]
+ B2=FE_OFN626_n85
XU971 AOI22S $PINS O=n89 A1=vec2_1D[81] A2=FE_OFN645_n86 B1=N491
+ B2=FE_OFN574_FE_DBTN0_n712
XU972 AOI22S $PINS O=n88 A1=N874 A2=FE_OFN537_FE_DBTN1_n711 B1=temp_LLR[0][10]
+ B2=FE_OFN622_n85
XU973 AOI22S $PINS O=n87 A1=vec2_1D[82] A2=FE_OFN640_n86 B1=N492
+ B2=FE_OFN575_FE_DBTN0_n712
XU974 MOAI1S $PINS O=n474 A1=FE_OFN666_n205 A2=FE_DBTN17_temp_LLR_4_6
+ B1=FE_OFN541_FE_DBTN1_n711 B2=N1014
XU976 MOAI1S $PINS O=n473 A1=FE_OFN666_n205 A2=FE_DBTN18_temp_LLR_4_7
+ B1=FE_OFN538_FE_DBTN1_n711 B2=N1015
XU978 MOAI1S $PINS O=n472 A1=FE_OFN662_n205 A2=FE_DBTN19_temp_LLR_4_8
+ B1=FE_OFN534_FE_DBTN1_n711 B2=N1016
XU980 MOAI1S $PINS O=n462 A1=FE_OFN660_n205 A2=FE_DBTN29_temp_LLR_3_6
+ B1=FE_OFN539_FE_DBTN1_n711 B2=N978
XU982 MOAI1S $PINS O=n461 A1=FE_OFN660_n205 A2=FE_DBTN30_temp_LLR_3_7
+ B1=FE_OFN535_FE_DBTN1_n711 B2=N979
XU984 MOAI1S $PINS O=n460 A1=FE_OFN660_n205 A2=FE_DBTN31_temp_LLR_3_8
+ B1=FE_OFN535_FE_DBTN1_n711 B2=N980
XU986 MOAI1S $PINS O=n450 A1=FE_OFN673_n205 A2=FE_DBTN41_temp_LLR_2_6
+ B1=FE_OFN545_FE_DBTN1_n711 B2=N942
XU988 MOAI1S $PINS O=n449 A1=FE_OFN671_n205 A2=FE_DBTN42_temp_LLR_2_7
+ B1=FE_OFN545_FE_DBTN1_n711 B2=N943
XU990 MOAI1S $PINS O=n448 A1=FE_OFN665_n205 A2=FE_DBTN43_temp_LLR_2_8
+ B1=FE_OFN540_FE_DBTN1_n711 B2=N944
XU992 MOAI1S $PINS O=n438 A1=FE_OFN666_n205 A2=FE_DBTN53_temp_LLR_1_6
+ B1=FE_OFN541_FE_DBTN1_n711 B2=N906
XU994 MOAI1S $PINS O=n437 A1=FE_OFN666_n205 A2=FE_DBTN54_temp_LLR_1_7
+ B1=FE_OFN538_FE_DBTN1_n711 B2=N907
XU996 MOAI1S $PINS O=n436 A1=FE_OFN662_n205 A2=FE_DBTN55_temp_LLR_1_8
+ B1=FE_OFN534_FE_DBTN1_n711 B2=N908
XU998 MOAI1S $PINS O=n426 A1=FE_OFN671_n205 A2=FE_DBTN65_temp_LLR_0_6
+ B1=FE_OFN548_FE_DBTN1_n711 B2=N870
XU1000 MOAI1S $PINS O=n425 A1=FE_OFN671_n205 A2=FE_DBTN66_temp_LLR_0_7
+ B1=FE_OFN548_FE_DBTN1_n711 B2=N871
XU1002 MOAI1S $PINS O=n424 A1=FE_OFN665_n205 A2=FE_DBTN67_temp_LLR_0_8
+ B1=FE_OFN540_FE_DBTN1_n711 B2=N872
XU1004 AOI22S $PINS O=n192 A1=N1014 A2=FE_OFN541_FE_DBTN1_n711
+ B1=temp_LLR[4][6] B2=FE_OFN629_n85
XU1005 AOI22S $PINS O=n191 A1=vec2_1D[30] A2=FE_OFN651_n86 B1=N632
+ B2=FE_OFN568_FE_DBTN0_n712
XU1006 AOI22S $PINS O=n190 A1=N1015 A2=FE_OFN538_FE_DBTN1_n711
+ B1=temp_LLR[4][7] B2=FE_OFN629_n85
XU1007 AOI22S $PINS O=n189 A1=vec2_1D[31] A2=FE_OFN644_n86 B1=N633
+ B2=FE_OFN564_FE_DBTN0_n712
XU1008 AOI22S $PINS O=n188 A1=N1016 A2=FE_OFN534_FE_DBTN1_n711
+ B1=temp_LLR[4][8] B2=FE_OFN621_n85
XU1009 AOI22S $PINS O=n187 A1=vec2_1D[32] A2=FE_OFN644_n86 B1=N634
+ B2=FE_OFN567_FE_DBTN0_n712
XU1010 AOI22S $PINS O=n168 A1=N978 A2=FE_OFN539_FE_DBTN1_n711 B1=temp_LLR[3][6]
+ B2=FE_OFN623_n85
XU1011 AOI22S $PINS O=n167 A1=vec2_1D[42] A2=FE_OFN644_n86 B1=N596
+ B2=FE_OFN568_FE_DBTN0_n712
XU1012 AOI22S $PINS O=n166 A1=N979 A2=FE_OFN535_FE_DBTN1_n711 B1=temp_LLR[3][7]
+ B2=FE_OFN623_n85
XU1013 AOI22S $PINS O=n165 A1=vec2_1D[43] A2=FE_OFN644_n86 B1=N597
+ B2=FE_OFN564_FE_DBTN0_n712
XU1014 AOI22S $PINS O=n164 A1=N980 A2=FE_OFN535_FE_DBTN1_n711 B1=temp_LLR[3][8]
+ B2=FE_OFN623_n85
XU1015 AOI22S $PINS O=n163 A1=vec2_1D[44] A2=FE_OFN636_n86 B1=N598
+ B2=FE_OFN561_FE_DBTN0_n712
XU1016 AOI22S $PINS O=n144 A1=N942 A2=FE_OFN545_FE_DBTN1_n711 B1=temp_LLR[2][6]
+ B2=FE_OFN630_n85
XU1017 AOI22S $PINS O=n143 A1=vec2_1D[54] A2=FE_OFN638_n86 B1=N560
+ B2=FE_OFN591_FE_DBTN0_n712
XU1018 AOI22S $PINS O=n142 A1=N943 A2=FE_OFN545_FE_DBTN1_n711 B1=temp_LLR[2][7]
+ B2=FE_OFN630_n85
XU1019 AOI22S $PINS O=n141 A1=vec2_1D[55] A2=FE_OFN645_n86 B1=N561
+ B2=FE_OFN591_FE_DBTN0_n712
XU1020 AOI22S $PINS O=n140 A1=N944 A2=FE_OFN546_FE_DBTN1_n711 B1=temp_LLR[2][8]
+ B2=FE_OFN626_n85
XU1021 AOI22S $PINS O=n139 A1=vec2_1D[56] A2=FE_OFN645_n86 B1=N562
+ B2=FE_OFN587_FE_DBTN0_n712
XU1022 AOI22S $PINS O=n120 A1=N906 A2=FE_OFN541_FE_DBTN1_n711 B1=temp_LLR[1][6]
+ B2=FE_OFN629_n85
XU1023 AOI22S $PINS O=n119 A1=vec2_1D[66] A2=FE_OFN638_n86 B1=N524
+ B2=FE_OFN566_FE_DBTN0_n712
XU1024 AOI22S $PINS O=n118 A1=N907 A2=FE_OFN534_FE_DBTN1_n711 B1=temp_LLR[1][7]
+ B2=FE_OFN628_n85
XU1025 AOI22S $PINS O=n117 A1=vec2_1D[67] A2=FE_OFN638_n86 B1=N525
+ B2=FE_OFN563_FE_DBTN0_n712
XU1026 AOI22S $PINS O=n116 A1=N908 A2=FE_OFN534_FE_DBTN1_n711 B1=temp_LLR[1][8]
+ B2=FE_OFN628_n85
XU1027 AOI22S $PINS O=n115 A1=vec2_1D[68] A2=FE_OFN638_n86 B1=N526
+ B2=FE_OFN563_FE_DBTN0_n712
XU1028 AOI22S $PINS O=n96 A1=N870 A2=FE_OFN548_FE_DBTN1_n711 B1=temp_LLR[0][6]
+ B2=FE_OFN630_n85
XU1029 AOI22S $PINS O=n95 A1=vec2_1D[78] A2=FE_OFN642_n86 B1=N488
+ B2=FE_OFN591_FE_DBTN0_n712
XU1030 AOI22S $PINS O=n94 A1=N871 A2=FE_OFN548_FE_DBTN1_n711 B1=temp_LLR[0][7]
+ B2=FE_OFN630_n85
XU1031 AOI22S $PINS O=n93 A1=vec2_1D[79] A2=FE_OFN645_n86 B1=N489
+ B2=FE_OFN587_FE_DBTN0_n712
XU1032 AOI22S $PINS O=n92 A1=N872 A2=FE_OFN540_FE_DBTN1_n711 B1=temp_LLR[0][8]
+ B2=FE_OFN626_n85
XU1033 AOI22S $PINS O=n91 A1=vec2_1D[80] A2=FE_OFN645_n86 B1=N490
+ B2=FE_OFN581_FE_DBTN0_n712
XU1034 NR2 $PINS O=n310 I1=read_counter[2] I2=n965
XU1035 INV1S $PINS O=n943 I=dec1_finish
XU1036 ND3 $PINS O=n284 I1=read_counter[1] I2=read_counter[0] I3=n309
XU1037 ND3 $PINS O=n283 I1=read_counter[1] I2=n1035 I3=n309
XU1038 ND3 $PINS O=n282 I1=read_counter[0] I2=n1036 I3=n309
XU1039 NR2 $PINS O=n71 I1=state[0] I2=state[1]
XU1040 NR2 $PINS O=n73 I1=n968 I2=state[0]
XU1041 AOI22S $PINS O=n154 A1=N937 A2=FE_OFN557_FE_DBTN1_n711 B1=temp_LLR[2][1]
+ B2=FE_OFN635_n85
XU1042 AOI22S $PINS O=n153 A1=vec2_1D[49] A2=FE_OFN652_n86 B1=N555
+ B2=FE_OFN592_FE_DBTN0_n712
XU1043 AOI22S $PINS O=n106 A1=N865 A2=FE_OFN557_FE_DBTN1_n711 B1=temp_LLR[0][1]
+ B2=FE_OFN635_n85
XU1044 AOI22S $PINS O=n105 A1=vec2_1D[73] A2=FE_OFN652_n86 B1=N483
+ B2=FE_OFN592_FE_DBTN0_n712
XU1045 MOAI1S $PINS O=n494 A1=n270 A2=FE_DBTN10_N923 B1=vec0_1D[19]
+ B2=FE_OFN646_n86
XU1046 MOAI1S $PINS O=n486 A1=n270 A2=n717 B1=vec0_1D[27] B2=FE_OFN646_n86
XU1047 MOAI1S $PINS O=n495 A1=FE_OFN1760_n270 A2=FE_DBTN9_N915 B1=vec0_1D[18]
+ B2=FE_OFN646_n86
XU1049 MOAI1S $PINS O=n487 A1=FE_OFN1760_n270 A2=FE_DBTN6_N843 B1=vec0_1D[26]
+ B2=FE_OFN646_n86
XU1051 MOAI1S $PINS O=n496 A1=FE_OFN1760_n270 A2=FE_DBTN8_N914 B1=vec0_1D[17]
+ B2=FE_OFN652_n86
XU1053 MOAI1S $PINS O=n488 A1=FE_OFN1760_n270 A2=FE_DBTN5_N842 B1=vec0_1D[25]
+ B2=FE_OFN652_n86
XU1055 MOAI1S $PINS O=n497 A1=FE_OFN1760_n270 A2=FE_DBTN7_N913 B1=vec0_1D[16]
+ B2=FE_OFN652_n86
XU1057 MOAI1S $PINS O=n489 A1=FE_OFN1760_n270 A2=FE_DBTN4_N841 B1=vec0_1D[24]
+ B2=FE_OFN652_n86
XU1059 MOAI1S $PINS O=n516 A1=n944 A2=FE_OFN699_n283 B1=N843 B2=FE_OFN699_n283
XU1060 MOAI1S $PINS O=n515 A1=n944 A2=FE_OFN689_n282 B1=N842 B2=FE_OFN689_n282
XU1061 MOAI1S $PINS O=n517 A1=n944 A2=FE_OFN707_n284 B1=N851 B2=FE_OFN707_n284
XU1062 MOAI1S $PINS O=n625 A1=FE_OFN704_n284 A2=n964 B1=vec2[6][3]
+ B2=FE_OFN702_n284
XU1063 MOAI1S $PINS O=n621 A1=FE_OFN704_n284 A2=n957 B1=vec1[6][3]
+ B2=FE_OFN704_n284
XU1064 MOAI1S $PINS O=n617 A1=FE_OFN708_n284 A2=n950 B1=vec0[6][3]
+ B2=FE_OFN708_n284
XU1065 MOAI1S $PINS O=n613 A1=FE_OFN702_n284 A2=n963 B1=vec2[5][3]
+ B2=FE_OFN702_n284
XU1066 MOAI1S $PINS O=n609 A1=FE_OFN702_n284 A2=n956 B1=vec1[5][3]
+ B2=FE_OFN702_n284
XU1067 MOAI1S $PINS O=n605 A1=FE_OFN708_n284 A2=n949 B1=vec0[5][3]
+ B2=FE_OFN708_n284
XU1068 MOAI1S $PINS O=n601 A1=FE_OFN701_n284 A2=n962 B1=vec2[4][3]
+ B2=FE_OFN701_n284
XU1069 MOAI1S $PINS O=n597 A1=n284 A2=n955 B1=vec1[4][3] B2=n284
XU1070 MOAI1S $PINS O=n589 A1=FE_OFN701_n284 A2=n961 B1=vec2[3][3]
+ B2=FE_OFN701_n284
XU1071 MOAI1S $PINS O=n585 A1=FE_OFN703_n284 A2=n954 B1=vec1[3][3]
+ B2=FE_OFN701_n284
XU1072 MOAI1S $PINS O=n577 A1=FE_OFN703_n284 A2=n960 B1=vec2[2][3]
+ B2=FE_OFN703_n284
XU1073 MOAI1S $PINS O=n573 A1=FE_OFN703_n284 A2=n953 B1=vec1[2][3]
+ B2=FE_OFN703_n284
XU1074 MOAI1S $PINS O=n565 A1=FE_OFN706_n284 A2=n959 B1=vec2[1][3]
+ B2=FE_OFN706_n284
XU1075 MOAI1S $PINS O=n561 A1=FE_OFN704_n284 A2=n952 B1=vec1[1][3]
+ B2=FE_OFN704_n284
XU1076 MOAI1S $PINS O=n553 A1=FE_OFN706_n284 A2=n958 B1=vec2[0][3]
+ B2=FE_OFN706_n284
XU1077 MOAI1S $PINS O=n549 A1=FE_OFN708_n284 A2=n951 B1=vec1[0][3]
+ B2=FE_OFN708_n284
XU1078 MOAI1S $PINS O=n624 A1=FE_OFN696_n283 A2=n964 B1=vec2[6][2]
+ B2=FE_OFN696_n283
XU1079 MOAI1S $PINS O=n620 A1=FE_OFN696_n283 A2=n957 B1=vec1[6][2]
+ B2=FE_OFN696_n283
XU1080 MOAI1S $PINS O=n616 A1=FE_OFN700_n283 A2=n950 B1=vec0[6][2]
+ B2=FE_OFN700_n283
XU1081 MOAI1S $PINS O=n612 A1=FE_OFN694_n283 A2=n963 B1=vec2[5][2]
+ B2=FE_OFN694_n283
XU1082 MOAI1S $PINS O=n608 A1=FE_OFN694_n283 A2=n956 B1=vec1[5][2]
+ B2=FE_OFN694_n283
XU1083 MOAI1S $PINS O=n604 A1=FE_OFN700_n283 A2=n949 B1=vec0[5][2]
+ B2=FE_OFN700_n283
XU1084 MOAI1S $PINS O=n600 A1=FE_OFN692_n283 A2=n962 B1=vec2[4][2]
+ B2=FE_OFN692_n283
XU1085 MOAI1S $PINS O=n596 A1=FE_OFN692_n283 A2=n955 B1=vec1[4][2]
+ B2=FE_OFN692_n283
XU1086 MOAI1S $PINS O=n592 A1=FE_OFN697_n283 A2=n948 B1=N987 B2=FE_OFN697_n283
XU1087 MOAI1S $PINS O=n588 A1=n283 A2=n961 B1=vec2[3][2] B2=n283
XU1088 MOAI1S $PINS O=n584 A1=n283 A2=n954 B1=vec1[3][2] B2=n283
XU1089 MOAI1S $PINS O=n580 A1=FE_OFN697_n283 A2=n947 B1=N605 B2=FE_OFN697_n283
XU1090 MOAI1S $PINS O=n576 A1=FE_OFN695_n283 A2=n960 B1=vec2[2][2]
+ B2=FE_OFN695_n283
XU1091 MOAI1S $PINS O=n572 A1=FE_OFN695_n283 A2=n953 B1=vec1[2][2]
+ B2=FE_OFN695_n283
XU1092 MOAI1S $PINS O=n568 A1=FE_OFN699_n283 A2=n946 B1=N915 B2=FE_OFN699_n283
XU1093 MOAI1S $PINS O=n564 A1=FE_OFN698_n283 A2=n959 B1=vec2[1][2]
+ B2=FE_OFN698_n283
XU1094 MOAI1S $PINS O=n560 A1=FE_OFN698_n283 A2=n952 B1=vec1[1][2]
+ B2=FE_OFN696_n283
XU1095 MOAI1S $PINS O=n556 A1=FE_OFN699_n283 A2=n945 B1=N569 B2=FE_OFN699_n283
XU1096 MOAI1S $PINS O=n552 A1=FE_OFN698_n283 A2=n958 B1=vec2[0][2]
+ B2=FE_OFN698_n283
XU1097 MOAI1S $PINS O=n548 A1=FE_OFN700_n283 A2=n951 B1=vec1[0][2]
+ B2=FE_OFN700_n283
XU1098 MOAI1S $PINS O=n623 A1=FE_OFN688_n282 A2=n964 B1=vec2[6][1]
+ B2=FE_OFN688_n282
XU1099 MOAI1S $PINS O=n619 A1=FE_OFN688_n282 A2=n957 B1=vec1[6][1]
+ B2=FE_OFN688_n282
XU1100 MOAI1S $PINS O=n615 A1=FE_OFN691_n282 A2=n950 B1=vec0[6][1]
+ B2=FE_OFN691_n282
XU1101 MOAI1S $PINS O=n611 A1=FE_OFN683_n282 A2=n963 B1=vec2[5][1]
+ B2=FE_OFN683_n282
XU1102 MOAI1S $PINS O=n607 A1=FE_OFN683_n282 A2=n956 B1=vec1[5][1]
+ B2=FE_OFN683_n282
XU1103 MOAI1S $PINS O=n603 A1=FE_OFN691_n282 A2=n949 B1=vec0[5][1]
+ B2=FE_OFN691_n282
XU1104 MOAI1S $PINS O=n599 A1=n282 A2=n962 B1=vec2[4][1] B2=n282
XU1105 MOAI1S $PINS O=n595 A1=FE_OFN683_n282 A2=n955 B1=vec1[4][1]
+ B2=FE_OFN683_n282
XU1106 MOAI1S $PINS O=n591 A1=FE_OFN687_n282 A2=n948 B1=N986 B2=FE_OFN687_n282
XU1107 MOAI1S $PINS O=n587 A1=FE_OFN685_n282 A2=n961 B1=vec2[3][1]
+ B2=FE_OFN685_n282
XU1108 MOAI1S $PINS O=n583 A1=FE_OFN685_n282 A2=n954 B1=vec1[3][1]
+ B2=FE_OFN685_n282
XU1109 MOAI1S $PINS O=n579 A1=FE_OFN687_n282 A2=n947 B1=N604 B2=FE_OFN687_n282
XU1110 MOAI1S $PINS O=n575 A1=FE_OFN686_n282 A2=n960 B1=vec2[2][1]
+ B2=FE_OFN686_n282
XU1111 MOAI1S $PINS O=n571 A1=FE_OFN686_n282 A2=n953 B1=vec1[2][1]
+ B2=FE_OFN686_n282
XU1112 MOAI1S $PINS O=n567 A1=FE_OFN689_n282 A2=n946 B1=N914 B2=FE_OFN689_n282
XU1113 MOAI1S $PINS O=n563 A1=FE_OFN690_n282 A2=n959 B1=vec2[1][1]
+ B2=FE_OFN690_n282
XU1114 MOAI1S $PINS O=n559 A1=FE_OFN690_n282 A2=n952 B1=vec1[1][1]
+ B2=FE_OFN688_n282
XU1115 MOAI1S $PINS O=n555 A1=FE_OFN689_n282 A2=n945 B1=N568 B2=FE_OFN689_n282
XU1116 MOAI1S $PINS O=n551 A1=FE_OFN691_n282 A2=n958 B1=vec2[0][1]
+ B2=FE_OFN691_n282
XU1117 MOAI1S $PINS O=n547 A1=FE_OFN690_n282 A2=n951 B1=vec1[0][1]
+ B2=FE_OFN690_n282
XU1118 MOAI1S $PINS O=n622 A1=FE_OFN680_n280 A2=n964 B1=vec2[6][0]
+ B2=FE_OFN680_n280
XU1119 MOAI1S $PINS O=n618 A1=FE_OFN678_n280 A2=n957 B1=vec1[6][0]
+ B2=FE_OFN678_n280
XU1120 MOAI1S $PINS O=n614 A1=FE_OFN682_n280 A2=n950 B1=vec0[6][0]
+ B2=FE_OFN682_n280
XU1121 MOAI1S $PINS O=n610 A1=FE_OFN675_n280 A2=n963 B1=vec2[5][0]
+ B2=FE_OFN675_n280
XU1122 MOAI1S $PINS O=n606 A1=FE_OFN675_n280 A2=n956 B1=vec1[5][0]
+ B2=FE_OFN675_n280
XU1123 MOAI1S $PINS O=n602 A1=FE_OFN682_n280 A2=n949 B1=vec0[5][0]
+ B2=FE_OFN682_n280
XU1124 MOAI1S $PINS O=n598 A1=n280 A2=n962 B1=vec2[4][0] B2=n280
XU1125 MOAI1S $PINS O=n594 A1=FE_OFN675_n280 A2=n955 B1=vec1[4][0]
+ B2=FE_OFN675_n280
XU1126 MOAI1S $PINS O=n590 A1=FE_OFN677_n280 A2=n948 B1=N985 B2=FE_OFN677_n280
XU1127 MOAI1S $PINS O=n586 A1=n280 A2=n961 B1=vec2[3][0] B2=n280
XU1128 MOAI1S $PINS O=n582 A1=FE_OFN676_n280 A2=n954 B1=vec1[3][0]
+ B2=FE_OFN676_n280
XU1129 MOAI1S $PINS O=n578 A1=FE_OFN677_n280 A2=n947 B1=FE_OFN722_N603
+ B2=FE_OFN677_n280
XU1130 MOAI1S $PINS O=n574 A1=FE_OFN676_n280 A2=n960 B1=vec2[2][0]
+ B2=FE_OFN676_n280
XU1131 MOAI1S $PINS O=n570 A1=FE_OFN678_n280 A2=n953 B1=vec1[2][0]
+ B2=FE_OFN678_n280
XU1132 MOAI1S $PINS O=n566 A1=FE_OFN679_n280 A2=n946 B1=N913 B2=FE_OFN679_n280
XU1133 MOAI1S $PINS O=n562 A1=FE_OFN681_n280 A2=n959 B1=vec2[1][0]
+ B2=FE_OFN681_n280
XU1134 MOAI1S $PINS O=n558 A1=FE_OFN680_n280 A2=n952 B1=vec1[1][0]
+ B2=FE_OFN680_n280
XU1135 MOAI1S $PINS O=n554 A1=FE_OFN679_n280 A2=n945 B1=FE_OFN723_N567
+ B2=FE_OFN679_n280
XU1136 MOAI1S $PINS O=n550 A1=FE_OFN681_n280 A2=n958 B1=vec2[0][0]
+ B2=FE_OFN681_n280
XU1137 MOAI1S $PINS O=n546 A1=FE_OFN682_n280 A2=n951 B1=vec1[0][0]
+ B2=FE_OFN682_n280
XU1138 MOAI1S $PINS O=n593 A1=FE_OFN705_n284 A2=n948 B1=N995 B2=FE_OFN705_n284
XU1139 MOAI1S $PINS O=n581 A1=FE_OFN705_n284 A2=n947 B1=N613 B2=FE_OFN705_n284
XU1140 MOAI1S $PINS O=n569 A1=FE_OFN707_n284 A2=n946 B1=N923 B2=FE_OFN707_n284
XU1141 MOAI1S $PINS O=n557 A1=FE_OFN707_n284 A2=n945 B1=N577 B2=FE_OFN707_n284
XU1142 MOAI1S $PINS O=n514 A1=FE_OFN679_n280 A2=n944 B1=N841 B2=FE_OFN679_n280
XU1143 MOAI1S $PINS O=n480 A1=FE_OFN672_n205 A2=FE_DBTN11_temp_LLR_4_0
+ B1=FE_OFN553_FE_DBTN1_n711 B2=N1008
XU1145 MOAI1S $PINS O=n479 A1=FE_OFN672_n205 A2=FE_DBTN12_temp_LLR_4_1
+ B1=FE_OFN554_FE_DBTN1_n711 B2=N1009
XU1147 MOAI1S $PINS O=n478 A1=FE_OFN667_n205 A2=FE_DBTN13_temp_LLR_4_2
+ B1=FE_OFN549_FE_DBTN1_n711 B2=N1010
XU1149 MOAI1S $PINS O=n477 A1=FE_OFN667_n205 A2=FE_DBTN14_temp_LLR_4_3
+ B1=FE_OFN549_FE_DBTN1_n711 B2=N1011
XU1151 MOAI1S $PINS O=n476 A1=FE_OFN667_n205 A2=FE_DBTN15_temp_LLR_4_4
+ B1=FE_OFN547_FE_DBTN1_n711 B2=N1012
XU1153 MOAI1S $PINS O=n475 A1=FE_OFN666_n205 A2=FE_DBTN16_temp_LLR_4_5
+ B1=FE_OFN544_FE_DBTN1_n711 B2=N1013
XU1155 MOAI1S $PINS O=n468 A1=FE_OFN672_n205 A2=FE_DBTN23_temp_LLR_3_0
+ B1=FE_OFN554_FE_DBTN1_n711 B2=N972
XU1157 MOAI1S $PINS O=n467 A1=FE_OFN672_n205 A2=FE_DBTN24_temp_LLR_3_1
+ B1=FE_OFN554_FE_DBTN1_n711 B2=N973
XU1159 MOAI1S $PINS O=n466 A1=FE_OFN668_n205 A2=FE_DBTN25_temp_LLR_3_2
+ B1=FE_OFN542_FE_DBTN1_n711 B2=N974
XU1161 MOAI1S $PINS O=n465 A1=FE_OFN668_n205 A2=FE_DBTN26_temp_LLR_3_3
+ B1=FE_OFN542_FE_DBTN1_n711 B2=N975
XU1163 MOAI1S $PINS O=n464 A1=FE_OFN668_n205 A2=FE_DBTN27_temp_LLR_3_4
+ B1=FE_OFN542_FE_DBTN1_n711 B2=N976
XU1165 MOAI1S $PINS O=n463 A1=FE_OFN660_n205 A2=FE_DBTN28_temp_LLR_3_5
+ B1=FE_OFN539_FE_DBTN1_n711 B2=N977
XU1167 MOAI1S $PINS O=n456 A1=FE_OFN674_n205 A2=FE_DBTN35_temp_LLR_2_0
+ B1=FE_OFN556_FE_DBTN1_n711 B2=N936
XU1169 MOAI1S $PINS O=n455 A1=FE_OFN674_n205 A2=FE_DBTN36_temp_LLR_2_1
+ B1=FE_OFN557_FE_DBTN1_n711 B2=N937
XU1171 MOAI1S $PINS O=n454 A1=FE_OFN673_n205 A2=FE_DBTN37_temp_LLR_2_2
+ B1=FE_OFN555_FE_DBTN1_n711 B2=N938
XU1173 MOAI1S $PINS O=n453 A1=FE_OFN673_n205 A2=FE_DBTN38_temp_LLR_2_3
+ B1=FE_OFN555_FE_DBTN1_n711 B2=N939
XU1175 MOAI1S $PINS O=n452 A1=FE_OFN673_n205 A2=FE_DBTN39_temp_LLR_2_4
+ B1=FE_OFN550_FE_DBTN1_n711 B2=N940
XU1177 MOAI1S $PINS O=n451 A1=FE_OFN673_n205 A2=FE_DBTN40_temp_LLR_2_5
+ B1=FE_OFN545_FE_DBTN1_n711 B2=N941
XU1179 MOAI1S $PINS O=n444 A1=FE_OFN672_n205 A2=FE_DBTN47_temp_LLR_1_0
+ B1=FE_OFN553_FE_DBTN1_n711 B2=N900
XU1181 MOAI1S $PINS O=n443 A1=FE_OFN672_n205 A2=FE_DBTN48_temp_LLR_1_1
+ B1=FE_OFN553_FE_DBTN1_n711 B2=N901
XU1183 MOAI1S $PINS O=n442 A1=FE_OFN667_n205 A2=FE_DBTN49_temp_LLR_1_2
+ B1=FE_OFN549_FE_DBTN1_n711 B2=N902
XU1185 MOAI1S $PINS O=n441 A1=FE_OFN667_n205 A2=FE_DBTN50_temp_LLR_1_3
+ B1=FE_OFN547_FE_DBTN1_n711 B2=N903
XU1187 MOAI1S $PINS O=n440 A1=FE_OFN667_n205 A2=FE_DBTN51_temp_LLR_1_4
+ B1=FE_OFN544_FE_DBTN1_n711 B2=N904
XU1189 MOAI1S $PINS O=n439 A1=FE_OFN666_n205 A2=FE_DBTN52_temp_LLR_1_5
+ B1=FE_OFN541_FE_DBTN1_n711 B2=N905
XU1191 MOAI1S $PINS O=n432 A1=FE_OFN674_n205 A2=FE_DBTN59_temp_LLR_0_0
+ B1=FE_OFN557_FE_DBTN1_n711 B2=N864
XU1193 MOAI1S $PINS O=n431 A1=FE_OFN674_n205 A2=FE_DBTN60_temp_LLR_0_1
+ B1=FE_OFN557_FE_DBTN1_n711 B2=N865
XU1195 MOAI1S $PINS O=n430 A1=FE_OFN674_n205 A2=FE_DBTN61_temp_LLR_0_2
+ B1=FE_OFN556_FE_DBTN1_n711 B2=N866
XU1197 MOAI1S $PINS O=n429 A1=FE_OFN674_n205 A2=FE_DBTN62_temp_LLR_0_3
+ B1=FE_OFN556_FE_DBTN1_n711 B2=N867
XU1199 MOAI1S $PINS O=n428 A1=FE_OFN671_n205 A2=FE_DBTN63_temp_LLR_0_4
+ B1=FE_OFN550_FE_DBTN1_n711 B2=N868
XU1201 MOAI1S $PINS O=n427 A1=FE_OFN671_n205 A2=FE_DBTN64_temp_LLR_0_5
+ B1=FE_OFN550_FE_DBTN1_n711 B2=N869
XU1203 AOI22S $PINS O=n202 A1=N1009 A2=FE_OFN554_FE_DBTN1_n711
+ B1=temp_LLR[4][1] B2=FE_OFN634_n85
XU1204 AOI22S $PINS O=n201 A1=vec2_1D[25] A2=FE_OFN658_n86 B1=N627
+ B2=FE_OFN596_FE_DBTN0_n712
XU1205 AOI22S $PINS O=n178 A1=N973 A2=FE_OFN554_FE_DBTN1_n711 B1=temp_LLR[3][1]
+ B2=FE_OFN634_n85
XU1206 AOI22S $PINS O=n177 A1=vec2_1D[37] A2=FE_OFN658_n86 B1=N591
+ B2=FE_OFN597_FE_DBTN0_n712
XU1207 AOI22S $PINS O=n130 A1=N901 A2=FE_OFN553_FE_DBTN1_n711 B1=temp_LLR[1][1]
+ B2=FE_OFN634_n85
XU1208 AOI22S $PINS O=n129 A1=vec2_1D[61] A2=FE_OFN647_n86 B1=N519
+ B2=FE_OFN583_FE_DBTN0_n712
XU1209 AOI22S $PINS O=n200 A1=N1010 A2=FE_OFN549_FE_DBTN1_n711
+ B1=temp_LLR[4][2] B2=FE_OFN631_n85
XU1210 AOI22S $PINS O=n199 A1=vec2_1D[26] A2=FE_OFN656_n86 B1=N628
+ B2=FE_OFN593_FE_DBTN0_n712
XU1211 AOI22S $PINS O=n198 A1=N1011 A2=FE_OFN547_FE_DBTN1_n711
+ B1=temp_LLR[4][3] B2=FE_OFN631_n85
XU1212 AOI22S $PINS O=n197 A1=vec2_1D[27] A2=FE_OFN654_n86 B1=N629
+ B2=FE_OFN586_FE_DBTN0_n712
XU1213 AOI22S $PINS O=n196 A1=N1012 A2=FE_OFN547_FE_DBTN1_n711
+ B1=temp_LLR[4][4] B2=FE_OFN631_n85
XU1214 AOI22S $PINS O=n195 A1=vec2_1D[28] A2=FE_OFN651_n86 B1=N630
+ B2=FE_OFN580_FE_DBTN0_n712
XU1215 AOI22S $PINS O=n194 A1=N1013 A2=FE_OFN544_FE_DBTN1_n711
+ B1=temp_LLR[4][5] B2=FE_OFN629_n85
XU1216 AOI22S $PINS O=n193 A1=vec2_1D[29] A2=FE_OFN651_n86 B1=N631
+ B2=FE_OFN573_FE_DBTN0_n712
XU1217 AOI22S $PINS O=n176 A1=N974 A2=FE_OFN542_FE_DBTN1_n711 B1=temp_LLR[3][2]
+ B2=FE_OFN632_n85
XU1218 AOI22S $PINS O=n175 A1=vec2_1D[38] A2=FE_OFN654_n86 B1=N592
+ B2=FE_OFN586_FE_DBTN0_n712
XU1219 AOI22S $PINS O=n174 A1=N975 A2=FE_OFN542_FE_DBTN1_n711 B1=temp_LLR[3][3]
+ B2=FE_OFN632_n85
XU1220 AOI22S $PINS O=n173 A1=vec2_1D[39] A2=FE_OFN654_n86 B1=N593
+ B2=FE_OFN586_FE_DBTN0_n712
XU1221 AOI22S $PINS O=n172 A1=N976 A2=FE_OFN542_FE_DBTN1_n711 B1=temp_LLR[3][4]
+ B2=FE_OFN632_n85
XU1222 AOI22S $PINS O=n171 A1=vec2_1D[40] A2=FE_OFN651_n86 B1=N594
+ B2=FE_OFN580_FE_DBTN0_n712
XU1223 AOI22S $PINS O=n170 A1=N977 A2=FE_OFN539_FE_DBTN1_n711 B1=temp_LLR[3][5]
+ B2=FE_OFN623_n85
XU1224 AOI22S $PINS O=n169 A1=vec2_1D[41] A2=FE_OFN651_n86 B1=N595
+ B2=FE_OFN573_FE_DBTN0_n712
XU1225 AOI22S $PINS O=n152 A1=N938 A2=FE_OFN555_FE_DBTN1_n711 B1=temp_LLR[2][2]
+ B2=FE_OFN633_n85
XU1226 AOI22S $PINS O=n151 A1=vec2_1D[50] A2=FE_OFN648_n86 B1=N556
+ B2=FE_OFN582_FE_DBTN0_n712
XU1227 AOI22S $PINS O=n150 A1=N939 A2=FE_OFN555_FE_DBTN1_n711 B1=temp_LLR[2][3]
+ B2=FE_OFN633_n85
XU1228 AOI22S $PINS O=n149 A1=vec2_1D[51] A2=FE_OFN648_n86 B1=N557
+ B2=FE_OFN582_FE_DBTN0_n712
XU1229 AOI22S $PINS O=n148 A1=N940 A2=FE_OFN550_FE_DBTN1_n711 B1=temp_LLR[2][4]
+ B2=FE_OFN633_n85
XU1230 AOI22S $PINS O=n147 A1=vec2_1D[52] A2=FE_OFN642_n86 B1=N558
+ B2=FE_OFN576_FE_DBTN0_n712
XU1231 AOI22S $PINS O=n146 A1=N941 A2=FE_OFN545_FE_DBTN1_n711 B1=temp_LLR[2][5]
+ B2=FE_OFN630_n85
XU1232 AOI22S $PINS O=n145 A1=vec2_1D[53] A2=FE_OFN642_n86 B1=N559
+ B2=FE_OFN570_FE_DBTN0_n712
XU1233 AOI22S $PINS O=n128 A1=N902 A2=FE_OFN549_FE_DBTN1_n711 B1=temp_LLR[1][2]
+ B2=FE_OFN631_n85
XU1234 AOI22S $PINS O=n127 A1=vec2_1D[62] A2=FE_OFN647_n86 B1=N520
+ B2=FE_OFN577_FE_DBTN0_n712
XU1235 AOI22S $PINS O=n126 A1=N903 A2=FE_OFN547_FE_DBTN1_n711 B1=temp_LLR[1][3]
+ B2=FE_OFN631_n85
XU1236 AOI22S $PINS O=n125 A1=vec2_1D[63] A2=FE_OFN641_n86 B1=N521
+ B2=FE_OFN571_FE_DBTN0_n712
XU1237 AOI22S $PINS O=n124 A1=N904 A2=FE_OFN544_FE_DBTN1_n711 B1=temp_LLR[1][4]
+ B2=FE_OFN629_n85
XU1238 AOI22S $PINS O=n123 A1=vec2_1D[64] A2=FE_OFN641_n86 B1=N522
+ B2=FE_OFN571_FE_DBTN0_n712
XU1239 AOI22S $PINS O=n122 A1=N905 A2=FE_OFN544_FE_DBTN1_n711 B1=temp_LLR[1][5]
+ B2=FE_OFN629_n85
XU1240 AOI22S $PINS O=n121 A1=vec2_1D[65] A2=FE_OFN641_n86 B1=N523
+ B2=FE_OFN566_FE_DBTN0_n712
XU1241 AOI22S $PINS O=n104 A1=N866 A2=FE_OFN556_FE_DBTN1_n711 B1=temp_LLR[0][2]
+ B2=FE_OFN635_n85
XU1242 AOI22S $PINS O=n103 A1=vec2_1D[74] A2=FE_OFN648_n86 B1=N484
+ B2=FE_OFN588_FE_DBTN0_n712
XU1243 AOI22S $PINS O=n102 A1=N867 A2=FE_OFN555_FE_DBTN1_n711 B1=temp_LLR[0][3]
+ B2=FE_OFN635_n85
XU1244 AOI22S $PINS O=n101 A1=vec2_1D[75] A2=FE_OFN648_n86 B1=N485
+ B2=FE_OFN576_FE_DBTN0_n712
XU1245 AOI22S $PINS O=n100 A1=N868 A2=FE_OFN550_FE_DBTN1_n711 B1=temp_LLR[0][4]
+ B2=FE_OFN633_n85
XU1246 AOI22S $PINS O=n99 A1=vec2_1D[76] A2=FE_OFN642_n86 B1=N486
+ B2=FE_OFN576_FE_DBTN0_n712
XU1247 AOI22S $PINS O=n98 A1=N869 A2=FE_OFN548_FE_DBTN1_n711 B1=temp_LLR[0][5]
+ B2=FE_OFN633_n85
XU1248 AOI22S $PINS O=n97 A1=vec2_1D[77] A2=FE_OFN642_n86 B1=N487
+ B2=FE_OFN570_FE_DBTN0_n712
XU1249 AOI22S $PINS O=n204 A1=N1008 A2=FE_OFN553_FE_DBTN1_n711
+ B1=temp_LLR[4][0] B2=FE_OFN634_n85
XU1250 AOI22S $PINS O=n203 A1=vec2_1D[24] A2=FE_OFN658_n86 B1=N626
+ B2=FE_OFN597_FE_DBTN0_n712
XU1251 AOI22S $PINS O=n180 A1=N972 A2=FE_OFN554_FE_DBTN1_n711 B1=temp_LLR[3][0]
+ B2=FE_OFN634_n85
XU1252 AOI22S $PINS O=n179 A1=vec2_1D[36] A2=FE_OFN658_n86 B1=N590
+ B2=FE_OFN597_FE_DBTN0_n712
XU1253 AOI22S $PINS O=n156 A1=N936 A2=FE_OFN556_FE_DBTN1_n711 B1=temp_LLR[2][0]
+ B2=FE_OFN635_n85
XU1254 AOI22S $PINS O=n155 A1=vec2_1D[48] A2=FE_OFN648_n86 B1=N554
+ B2=FE_OFN588_FE_DBTN0_n712
XU1255 AOI22S $PINS O=n132 A1=N900 A2=FE_OFN553_FE_DBTN1_n711 B1=temp_LLR[1][0]
+ B2=FE_OFN634_n85
XU1256 AOI22S $PINS O=n131 A1=vec2_1D[60] A2=FE_OFN647_n86 B1=N518
+ B2=FE_OFN583_FE_DBTN0_n712
XU1257 AOI22S $PINS O=n108 A1=N864 A2=FE_OFN557_FE_DBTN1_n711 B1=temp_LLR[0][0]
+ B2=FE_OFN635_n85
XU1258 AOI22S $PINS O=n107 A1=vec2_1D[72] A2=FE_OFN648_n86 B1=N482
+ B2=FE_OFN588_FE_DBTN0_n712
XU1259 INV1S $PINS O=n968 I=state[1]
XU1260 INV1S $PINS O=n1035 I=read_counter[0]
XU1261 INV1S $PINS O=n1036 I=read_counter[1]
XU1262 MOAI1S $PINS O=n332 A1=n1035 A2=n70 B1=read_counter[1] B2=n333
XU1263 OR2 $PINS O=n70 I1=n68 I2=read_counter[1]
XU1264 NR2 $PINS O=n333 I1=n68 I2=read_counter[0]
XU1265 INV1S $PINS O=n1032 I=iter_counter[2]
XU1266 INV1S $PINS O=n1029 I=iter_counter[5]
XU1267 INV1S $PINS O=n1031 I=iter_counter[1]
XU1268 INV1S $PINS O=n1034 I=iter_counter[4]
XU1269 OR2 $PINS O=n76 I1=n313 I2=dec1_finish
XU1270 INV1S $PINS O=n964 I=vec2_reg[0]
XU1271 INV1S $PINS O=n957 I=vec1_reg[0]
XU1272 INV1S $PINS O=n950 I=vec0_reg[0]
XU1273 INV1S $PINS O=n963 I=vec2_reg[1]
XU1274 INV1S $PINS O=n956 I=vec1_reg[1]
XU1275 INV1S $PINS O=n949 I=vec0_reg[1]
XU1276 INV1S $PINS O=n962 I=vec2_reg[2]
XU1277 INV1S $PINS O=n955 I=vec1_reg[2]
XU1278 INV1S $PINS O=n948 I=vec0_reg[2]
XU1279 INV1S $PINS O=n961 I=vec2_reg[3]
XU1280 INV1S $PINS O=n954 I=vec1_reg[3]
XU1281 INV1S $PINS O=n947 I=vec0_reg[3]
XU1282 INV1S $PINS O=n960 I=vec2_reg[4]
XU1283 INV1S $PINS O=n953 I=vec1_reg[4]
XU1284 INV1S $PINS O=n946 I=vec0_reg[4]
XU1285 INV1S $PINS O=n959 I=vec2_reg[5]
XU1286 INV1S $PINS O=n952 I=vec1_reg[5]
XU1287 INV1S $PINS O=n945 I=vec0_reg[5]
XU1288 INV1S $PINS O=n958 I=vec2_reg[6]
XU1289 INV1S $PINS O=n951 I=vec1_reg[6]
XU1290 INV1S $PINS O=n944 I=vec0_reg[6]
XU1291 ND3 $PINS O=n75 I1=start_reg I2=n71 I3=read_counter[2]
XU1295 XOR2HS $PINS O=N1039 I1=add_290/carry[5] I2=iter_counter[5]
.ENDS

.SUBCKT CHIP clk_p_i reset_n_i data_i[20] data_i[19] data_i[18] data_i[17]
+ data_i[16] data_i[15] data_i[14] data_i[13] data_i[12] data_i[11] data_i[10]
+ data_i[9] data_i[8] data_i[7] data_i[6] data_i[5] data_i[4] data_i[3]
+ data_i[2] data_i[1] data_i[0] start_i data_o[4] data_o[3] data_o[2] data_o[1]
+ data_o[0] done_o
XFE_OFC488_n_logic0 BUF1 $PINS O=FE_OFN620_n_logic0 I=FE_OFN618_n_logic0
XFE_OFC487_n_logic0 BUF1 $PINS O=FE_OFN619_n_logic0 I=FE_OFN617_n_logic0
XFE_OFC486_n_logic0 BUF1 $PINS O=FE_OFN618_n_logic0 I=FE_OFN616_n_logic0
XFE_OFC485_n_logic0 BUF1 $PINS O=FE_OFN617_n_logic0 I=FE_OFN615_n_logic0
XFE_OFC484_n_logic0 BUF1 $PINS O=FE_OFN616_n_logic0 I=FE_OFN614_n_logic0
XFE_OFC483_n_logic0 BUF1 $PINS O=FE_OFN615_n_logic0 I=FE_OFN613_n_logic0
XFE_OFC482_n_logic0 BUF1 $PINS O=FE_OFN614_n_logic0 I=FE_OFN612_n_logic0
XFE_OFC481_n_logic0 BUF1 $PINS O=FE_OFN613_n_logic0 I=FE_OFN611_n_logic0
XFE_OFC480_n_logic0 BUF1 $PINS O=FE_OFN612_n_logic0 I=FE_OFN610_n_logic0
XFE_OFC479_n_logic0 BUF1 $PINS O=FE_OFN611_n_logic0 I=FE_OFN609_n_logic0
XFE_OFC478_n_logic0 BUF1 $PINS O=FE_OFN610_n_logic0 I=FE_OFN608_n_logic0
XFE_OFC477_n_logic0 BUF1 $PINS O=FE_OFN609_n_logic0 I=FE_OFN607_n_logic0
XFE_OFC476_n_logic0 BUF1 $PINS O=FE_OFN608_n_logic0 I=FE_OFN606_n_logic0
XFE_OFC475_n_logic0 BUF1 $PINS O=FE_OFN607_n_logic0 I=FE_OFN605_n_logic0
XFE_OFC474_n_logic0 BUF1 $PINS O=FE_OFN606_n_logic0 I=FE_OFN604_n_logic0
XFE_OFC473_n_logic0 BUF1 $PINS O=FE_OFN605_n_logic0 I=FE_OFN603_n_logic0
XFE_OFC472_n_logic0 BUF1 $PINS O=FE_OFN604_n_logic0 I=FE_OFN601_n_logic0
XFE_OFC471_n_logic0 INV1S $PINS O=FE_OFN603_n_logic0 I=FE_OFN600_n_logic0
XFE_OFC470_n_logic0 INV1S $PINS O=FE_OFN602_n_logic0 I=FE_OFN600_n_logic0
XFE_OFC469_n_logic0 BUF1 $PINS O=FE_OFN601_n_logic0 I=n_logic0
XFE_OFC468_n_logic0 INV1S $PINS O=FE_OFN600_n_logic0 I=n_logic0
Xdeco_in Deco $PINS clk_p_i=i_clk_p_i reset_n_i=i_reset_n_i
+ data_i[20]=i_data_i[20] data_i[19]=i_data_i[19] data_i[18]=i_data_i[18]
+ data_i[17]=i_data_i[17] data_i[16]=i_data_i[16] data_i[15]=i_data_i[15]
+ data_i[14]=i_data_i[14] data_i[13]=i_data_i[13] data_i[12]=i_data_i[12]
+ data_i[11]=i_data_i[11] data_i[10]=i_data_i[10] data_i[9]=i_data_i[9]
+ data_i[8]=i_data_i[8] data_i[7]=i_data_i[7] data_i[6]=i_data_i[6]
+ data_i[5]=i_data_i[5] data_i[4]=i_data_i[4] data_i[3]=i_data_i[3]
+ data_i[2]=i_data_i[2] data_i[1]=i_data_i[1] data_i[0]=i_data_i[0]
+ data_o[4]=i_data_o[4] data_o[3]=i_data_o[3] data_o[2]=i_data_o[2]
+ data_o[1]=i_data_o[1] data_o[0]=i_data_o[0] start_i=i_start_i done_o=i_done_o
Xipad_n_logic0 TIE0 $PINS O=n_logic0
Xipad_n_logic1 TIE1 $PINS O=n_logic1
Xipad_clk_p_i XMD $PINS O=i_clk_p_i I=clk_p_i PU=FE_OFN620_n_logic0
+ PD=FE_OFN620_n_logic0 SMT=FE_OFN620_n_logic0
Xipad_reset_n_i XMD $PINS O=i_reset_n_i I=reset_n_i PU=FE_OFN620_n_logic0
+ PD=FE_OFN620_n_logic0 SMT=FE_OFN620_n_logic0
Xipad_start_i XMD $PINS O=i_start_i I=start_i PU=FE_OFN618_n_logic0
+ PD=FE_OFN618_n_logic0 SMT=FE_OFN618_n_logic0
Xipad_data_i_0 XMD $PINS O=i_data_i[0] I=data_i[0] PU=FE_OFN618_n_logic0
+ PD=FE_OFN618_n_logic0 SMT=FE_OFN616_n_logic0
Xipad_data_i_1 XMD $PINS O=i_data_i[1] I=data_i[1] PU=FE_OFN616_n_logic0
+ PD=FE_OFN616_n_logic0 SMT=FE_OFN616_n_logic0
Xipad_data_i_2 XMD $PINS O=i_data_i[2] I=data_i[2] PU=FE_OFN614_n_logic0
+ PD=FE_OFN616_n_logic0 SMT=FE_OFN614_n_logic0
Xipad_data_i_3 XMD $PINS O=i_data_i[3] I=data_i[3] PU=FE_OFN614_n_logic0
+ PD=FE_OFN614_n_logic0 SMT=FE_OFN614_n_logic0
Xipad_data_i_4 XMD $PINS O=i_data_i[4] I=data_i[4] PU=FE_OFN612_n_logic0
+ PD=FE_OFN612_n_logic0 SMT=FE_OFN612_n_logic0
Xipad_data_i_5 XMD $PINS O=i_data_i[5] I=data_i[5] PU=FE_OFN611_n_logic0
+ PD=FE_OFN611_n_logic0 SMT=FE_OFN611_n_logic0
Xipad_data_i_6 XMD $PINS O=i_data_i[6] I=data_i[6] PU=FE_OFN613_n_logic0
+ PD=FE_OFN613_n_logic0 SMT=FE_OFN613_n_logic0
Xipad_data_i_7 XMD $PINS O=i_data_i[7] I=data_i[7] PU=FE_OFN613_n_logic0
+ PD=FE_OFN613_n_logic0 SMT=FE_OFN615_n_logic0
Xipad_data_i_8 XMD $PINS O=i_data_i[8] I=data_i[8] PU=FE_OFN615_n_logic0
+ PD=FE_OFN615_n_logic0 SMT=FE_OFN615_n_logic0
Xipad_data_i_9 XMD $PINS O=i_data_i[9] I=data_i[9] PU=FE_OFN617_n_logic0
+ PD=FE_OFN615_n_logic0 SMT=FE_OFN617_n_logic0
Xipad_data_i_10 XMD $PINS O=i_data_i[10] I=data_i[10] PU=FE_OFN617_n_logic0
+ PD=FE_OFN617_n_logic0 SMT=FE_OFN617_n_logic0
Xipad_data_i_11 XMD $PINS O=i_data_i[11] I=data_i[11] PU=FE_OFN619_n_logic0
+ PD=FE_OFN619_n_logic0 SMT=FE_OFN619_n_logic0
Xipad_data_i_12 XMD $PINS O=i_data_i[12] I=data_i[12] PU=FE_OFN619_n_logic0
+ PD=FE_OFN619_n_logic0 SMT=FE_OFN619_n_logic0
Xipad_data_i_13 XMD $PINS O=i_data_i[13] I=data_i[13] PU=FE_OFN611_n_logic0
+ PD=FE_OFN609_n_logic0 SMT=FE_OFN611_n_logic0
Xipad_data_i_14 XMD $PINS O=i_data_i[14] I=data_i[14] PU=FE_OFN609_n_logic0
+ PD=FE_OFN609_n_logic0 SMT=FE_OFN609_n_logic0
Xipad_data_i_15 XMD $PINS O=i_data_i[15] I=data_i[15] PU=FE_OFN607_n_logic0
+ PD=FE_OFN607_n_logic0 SMT=FE_OFN609_n_logic0
Xipad_data_i_16 XMD $PINS O=i_data_i[16] I=data_i[16] PU=FE_OFN607_n_logic0
+ PD=FE_OFN607_n_logic0 SMT=FE_OFN607_n_logic0
Xipad_data_i_17 XMD $PINS O=i_data_i[17] I=data_i[17] PU=FE_OFN605_n_logic0
+ PD=FE_OFN605_n_logic0 SMT=FE_OFN605_n_logic0
Xipad_data_i_18 XMD $PINS O=i_data_i[18] I=data_i[18] PU=FE_OFN605_n_logic0
+ PD=FE_OFN603_n_logic0 SMT=FE_OFN605_n_logic0
Xipad_data_i_19 XMD $PINS O=i_data_i[19] I=data_i[19] PU=FE_OFN603_n_logic0
+ PD=FE_OFN603_n_logic0 SMT=FE_OFN603_n_logic0
Xipad_data_i_20 XMD $PINS O=i_data_i[20] I=data_i[20] PU=FE_OFN602_n_logic0
+ PD=FE_OFN602_n_logic0 SMT=FE_OFN602_n_logic0
Xipad_done_o YA2GSD $PINS O=done_o I=i_done_o E=n_logic1 E2=n_logic0
+ E4=n_logic0 E8=n_logic0 SR=FE_OFN601_n_logic0
Xipad_data_o_0 YA2GSD $PINS O=data_o[0] I=i_data_o[0] E=n_logic1
+ E2=FE_OFN601_n_logic0 E4=FE_OFN601_n_logic0 E8=FE_OFN601_n_logic0
+ SR=FE_OFN604_n_logic0
Xipad_data_o_1 YA2GSD $PINS O=data_o[1] I=i_data_o[1] E=n_logic1
+ E2=FE_OFN604_n_logic0 E4=FE_OFN604_n_logic0 E8=FE_OFN604_n_logic0
+ SR=FE_OFN606_n_logic0
Xipad_data_o_2 YA2GSD $PINS O=data_o[2] I=i_data_o[2] E=n_logic1
+ E2=FE_OFN606_n_logic0 E4=FE_OFN606_n_logic0 E8=FE_OFN606_n_logic0
+ SR=FE_OFN608_n_logic0
Xipad_data_o_3 YA2GSD $PINS O=data_o[3] I=i_data_o[3] E=n_logic1
+ E2=FE_OFN608_n_logic0 E4=FE_OFN608_n_logic0 E8=FE_OFN608_n_logic0
+ SR=FE_OFN610_n_logic0
Xipad_data_o_4 YA2GSD $PINS O=data_o[4] I=i_data_o[4] E=n_logic1
+ E2=FE_OFN610_n_logic0 E4=FE_OFN610_n_logic0 E8=FE_OFN610_n_logic0
+ SR=FE_OFN612_n_logic0
.ENDS
